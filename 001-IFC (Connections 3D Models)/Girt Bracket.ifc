Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView_V2.0, QuantityTakeOffAddOnView], Option [BaseQuantities:On], Option [GridExport:On], Option [Assemblies:On], Option [Bolts:On], Option [Rebars:On], Option [PourObjects:Off], Option [Welds:Off], Option [SurfaceTreatments:Off], Option [LocationBy:0], Option [ViewColors:Off], Option [SectionedSpine:Off], Option [PropertySets:On], Option [Export all:Off]
File name: Girt Bracket.ifc
Time: 2026-02-19T12:13:00
Author: DESKTOP-BKNQL56\admin
Organization: Structural Designer
Written by: IFC Database Version: Work
Made in: Tekla Structures 2019 Service Pack 13, IFC Export Version: 4.0.0.0 Oct 18 2021

# IfcBuildingStorey, Undefined
In: Undefined
Elevation: 0 mm

# IfcBeam: TH:120-95 (6)
In: Undefined
Description: TH:120-95; Material: STEEL/300PLUS
Default - ASSEMBLY_POS: B/9
Tekla Common - Bottom elevation: +1.903; Top elevation: +2.067; Phase: 1; Class: 4
Tekla Quantity - Weight: 2.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 0 m2; Net surface area: 0.9 m2; Height: 120 mm; Width: 165 mm; Length: 1343.4 mm
Pset_BeamCommon - LoadBearing: no; Reference: B/9
BaseQuantities - Length: 1343.4 mm; OuterSurfaceArea: 6.12617e-07 m2; NetVolume: 0.000471807 m3; NetWeight: 3.70369 kg

# IfcBeam: TH:64-95 (6)
In: Undefined
Description: TH:64-95; Material: STEEL/300PLUS
Default - ASSEMBLY_POS: B/6
Tekla Common - Bottom elevation: +3.120; Top elevation: +3.250; Phase: 1; Class: 4
Tekla Quantity - Weight: 2.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 0 m2; Net surface area: 0.6 m2; Height: 64 mm; Width: 130 mm; Length: 1343.4 mm
Pset_BeamCommon - LoadBearing: no; Reference: B/6
BaseQuantities - Length: 1343.4 mm; OuterSurfaceArea: 6.12617e-07 m2; NetVolume: 0.000289581 m3; NetWeight: 2.27321 kg

# IfcBeam: TH:75-95 (6)
In: Undefined
Description: TH:75-95; Material: STEEL/300PLUS
Default - ASSEMBLY_POS: B/7
Tekla Common - Bottom elevation: +2.723; Top elevation: +2.848; Phase: 1; Class: 4
Tekla Quantity - Weight: 2.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 0 m2; Net surface area: 0.6 m2; Height: 75 mm; Width: 125 mm; Length: 1343.4 mm
Pset_BeamCommon - LoadBearing: no; Reference: B/7
BaseQuantities - Length: 1343.4 mm; OuterSurfaceArea: 6.12617e-07 m2; NetVolume: 0.000311535 m3; NetWeight: 2.44555 kg

# IfcBeam: TH:96-95 (6)
In: Undefined
Description: TH:96-95; Material: STEEL/300PLUS
Default - ASSEMBLY_POS: B/8
Tekla Common - Bottom elevation: +2.310; Top elevation: +2.460; Phase: 1; Class: 4
Tekla Quantity - Weight: 2.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 0 m2; Net surface area: 0.9 m2; Height: 96 mm; Width: 150 mm; Length: 1343.4 mm
Pset_BeamCommon - LoadBearing: no; Reference: B/8
BaseQuantities - Length: 1343.4 mm; OuterSurfaceArea: 6.12617e-07 m2; NetVolume: 0.000385787 m3; NetWeight: 3.02843 kg

# IfcColumn: C:100-15, COLUMN
In: Undefined
Description: C:100-15; Material: STEEL/G450
Default - ASSEMBLY_POS: Z/180
Tekla Common - Finish: 25 deg; Bottom elevation: +0.000; Top elevation: +3.400; Phase: 1; Class: 10
Tekla Quantity - Weight: 8.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 178.7 m2; Net surface area: 1.5 m2; Height: 102 mm; Width: 51 mm; Length: 3400 mm
Pset_ColumnCommon - LoadBearing: no; Reference: Z/180
BaseQuantities - Length: 3400 mm; OuterSurfaceArea: 1.54087 m2; NetVolume: 0.0011475 m3; NetWeight: 9.00787 kg

# IfcColumn: C:150-24, COLUMN
In: Undefined
Description: C:150-24; Material: STEEL/G450
Tekla Common - Finish: 25 deg; Bottom elevation: +0.000; Top elevation: +3.400; Phase: 1; Class: 10
Default - ASSEMBLY_POS: Z/8
Tekla Quantity - Weight: 18.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 111.2 m2; Net surface area: 2.1 m2; Height: 152 mm; Width: 64 mm; Length: 3400 mm
Pset_ColumnCommon - LoadBearing: no; Reference: Z/8
BaseQuantities - Length: 3400 mm; OuterSurfaceArea: 2.10812 m2; NetVolume: 0.00250838 m3; NetWeight: 19.6908 kg

# IfcColumn: C:200-24, COLUMN
In: Undefined
Description: C:200-24; Material: STEEL/G450
Tekla Common - Finish: 25 deg; Bottom elevation: +0.000; Top elevation: +3.400; Phase: 1; Class: 10
Default - ASSEMBLY_POS: Z/17
Tekla Quantity - Weight: 24.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 110.1 m2; Net surface area: 2.7 m2; Height: 203 mm; Width: 76 mm; Length: 3400 mm
Pset_ColumnCommon - LoadBearing: no; Reference: Z/17
BaseQuantities - Length: 3400 mm; OuterSurfaceArea: 2.6525 m2; NetVolume: 0.00316118 m3; NetWeight: 24.8153 kg

# IfcColumn: C:250-24, COLUMN
In: Undefined
Description: C:250-24; Material: STEEL/G450
Default - ASSEMBLY_POS: Z/28
Tekla Common - Finish: 25 deg; Bottom elevation: +0.000; Top elevation: +3.300; Phase: 1; Class: 10
Tekla Quantity - Weight: 26.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 109.7 m2; Net surface area: 2.9 m2; Height: 254 mm; Width: 76 mm; Length: 3300 mm
Pset_ColumnCommon - LoadBearing: no; Reference: Z/28
BaseQuantities - Length: 3300 mm; OuterSurfaceArea: 2.90478 m2; NetVolume: 0.00346421 m3; NetWeight: 27.194 kg

# IfcColumn: C:300-30, COLUMN
In: Undefined
Description: C:300-30; Material: STEEL/G450
Tekla Common - Finish: 25 deg; Bottom elevation: +0.000; Top elevation: +3.400; Phase: 1; Class: 10
Default - ASSEMBLY_POS: Z/36
Tekla Quantity - Weight: 42.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.4 m2; Net surface area: 3.7 m2; Height: 300 mm; Width: 96 mm; Length: 3400 mm
Pset_ColumnCommon - LoadBearing: no; Reference: Z/36
BaseQuantities - Length: 3400 mm; OuterSurfaceArea: 3.71606 m2; NetVolume: 0.0055386 m3; NetWeight: 43.478 kg

# IfcColumn: C:350-30, COLUMN
In: Undefined
Description: C:350-30; Material: STEEL/G450
Tekla Common - Finish: 25 deg; Bottom elevation: +0.000; Top elevation: +3.400; Phase: 1; Class: 10
Default - ASSEMBLY_POS: Z/42
Tekla Quantity - Weight: 50.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.1 m2; Net surface area: 4.4 m2; Height: 350 mm; Width: 125 mm; Length: 3400 mm
Pset_ColumnCommon - LoadBearing: no; Reference: Z/42
BaseQuantities - Length: 3400 mm; OuterSurfaceArea: 4.43069 m2; NetVolume: 0.0066096 m3; NetWeight: 51.8854 kg

# IfcElementAssembly (54)
In: Undefined
PredefinedType: RIGID_FRAME
Name | ASSEMBLY_POSITION_CODE = Assembly/Cast unit position code | ASSEMBLY_POS = Assembly/Cast unit Mark | Assembly/Cast unit weight (kg) | Assembly/Cast unit bottom elevation | Assembly/Cast unit top elevation | Width (mm)
GIRT BRACKET | C350TB/1 | Z/215 | 0.3 | +1.903 | +2.067 | 31.6
GIRT BRACKET | C350TB/1 | Z/214 | 0.2 | +2.310 | +2.460 | 31.6
GIRT BRACKET | C350TB/1 | Z/213 | 0.1 | +2.723 | +2.848 | 31.6
GIRT BRACKET | C350TB/1 | Z/212 | 0.1 | +3.120 | +3.250 | 31.6
TH | C350TB/1-2 | B/9 | 2.4 | +1.903 | +2.067 | 165
TH | C350TB/1-2 | B/8 | 2.4 | +2.310 | +2.460 | 150
TH | C350TB/1-2 | B/7 | 2.4 | +2.723 | +2.848 | 125
TH | C350TB/1-2 | B/6 | 2.4 | +3.120 | +3.250 | 130
GIRT BRACKET | C300TB/1 | Z/215 | 0.3 | +1.903 | +2.067 | 31.6
GIRT BRACKET | C300TB/1 | Z/214 | 0.2 | +2.310 | +2.460 | 31.6
GIRT BRACKET | C300TB/1 | Z/213 | 0.1 | +2.723 | +2.848 | 31.6
GIRT BRACKET | C300TB/1 | Z/212 | 0.1 | +3.120 | +3.250 | 31.6
TH | C300TB/1-2 | B/9 | 2.4 | +1.903 | +2.067 | 165
TH | C300TB/1-2 | B/8 | 2.4 | +2.310 | +2.460 | 150
TH | C300TB/1-2 | B/7 | 2.4 | +2.723 | +2.848 | 125
TH | C300TB/1-2 | B/6 | 2.4 | +3.120 | +3.250 | 130
GIRT BRACKET | C250TB/1 | Z/215 | 0.3 | +1.903 | +2.067 | 31.6
GIRT BRACKET | C250TB/1 | Z/214 | 0.2 | +2.310 | +2.460 | 31.6
GIRT BRACKET | C250TB/1 | Z/213 | 0.1 | +2.723 | +2.848 | 31.6
GIRT BRACKET | C250TB/1 | Z/212 | 0.1 | +3.120 | +3.250 | 31.6
TH | C250TB/1-2 | B/9 | 2.4 | +1.903 | +2.067 | 165
TH | C250TB/1-2 | B/8 | 2.4 | +2.310 | +2.460 | 150
TH | C250TB/1-2 | B/7 | 2.4 | +2.723 | +2.848 | 125
TH | C250TB/1-2 | B/6 | 2.4 | +3.120 | +3.250 | 130
GIRT BRACKET | C200TB/1 | Z/215 | 0.3 | +1.903 | +2.067 | 31.6
GIRT BRACKET | C200TB/1 | Z/214 | 0.2 | +2.310 | +2.460 | 31.6
GIRT BRACKET | C200TB/1 | Z/213 | 0.1 | +2.723 | +2.848 | 31.6
GIRT BRACKET | C200TB/1 | Z/212 | 0.1 | +3.120 | +3.250 | 31.6
TH | C200TB/1-2 | B/9 | 2.4 | +1.903 | +2.067 | 165
TH | C200TB/1-2 | B/8 | 2.4 | +2.310 | +2.460 | 150
TH | C200TB/1-2 | B/7 | 2.4 | +2.723 | +2.848 | 125
TH | C200TB/1-2 | B/6 | 2.4 | +3.120 | +3.250 | 130
GIRT BRACKET | C150TB/1 | Z/215 | 0.3 | +1.903 | +2.067 | 31.6
GIRT BRACKET | C150TB/1 | Z/214 | 0.2 | +2.310 | +2.460 | 31.6
GIRT BRACKET | C150TB/1 | Z/213 | 0.1 | +2.723 | +2.848 | 31.6
GIRT BRACKET | C150TB/1 | Z/212 | 0.1 | +3.120 | +3.250 | 31.6
TH | C150TB/1-2 | B/9 | 2.4 | +1.903 | +2.067 | 165
TH | C150TB/1-2 | B/8 | 2.4 | +2.310 | +2.460 | 150
TH | C150TB/1-2 | B/7 | 2.4 | +2.723 | +2.848 | 125
TH | C150TB/1-2 | B/6 | 2.4 | +3.120 | +3.250 | 130
GIRT BRACKET |  | GB/4 | 0.3 | +1.903 | +2.067 | 31.6
GIRT BRACKET |  | GB/3 | 0.2 | +2.310 | +2.460 | 31.6
GIRT BRACKET |  | GB/2 | 0.1 | +2.723 | +2.848 | 31.6
GIRT BRACKET |  | GB/1 | 0.1 | +3.120 | +3.250 | 31.6
TH |  | B/9 | 2.4 | +1.903 | +2.067 | 165
TH |  | B/8 | 2.4 | +2.310 | +2.460 | 150
TH |  | B/7 | 2.4 | +2.723 | +2.848 | 125
TH |  | B/6 | 2.4 | +3.120 | +3.250 | 130
COLUMN |  | Z/180 | 8.6 | +0.000 | +3.400 | 51
COLUMN | C350TB/1 | Z/42 | 50.8 | +0.000 | +3.400 | 125
COLUMN | C300TB/1 | Z/36 | 42.5 | +0.000 | +3.400 | 96
COLUMN | C250TB/1 | Z/28 | 26.5 | +0.000 | +3.300 | 76
COLUMN | C200TB/1 | Z/17 | 24.1 | +0.000 | +3.400 | 76
COLUMN | C150TB/1 | Z/8 | 18.9 | +0.000 | +3.400 | 64

# IfcPlate: PLT1.6*102.9 (6)
In: Undefined
Description: PLT1.6*102.9; Material: STEEL/250
Tekla Common - Bottom elevation: +2.310; Top elevation: +2.460; Phase: 1; Class: 11
Tekla Quantity - Weight: 0.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 164.4 m2; Net surface area: 0 m2; Height: 102.9 mm; Width: 1.6 mm; Length: 150 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 102.854 mm; NetArea: 0.0319737 m2; GrossArea: 0.0154281 m2; CrossSectionArea: 0.00000256 m2; NetVolume: 0.0000247686 m3; GrossVolume: 0.0000247686 m3
Name | ASSEMBLY_POS = Reference
5 x GIRT BRACKET | Z/214
GIRT BRACKET | GB/3

# IfcPlate: PLT1.6*127.9 (6)
In: Undefined
Description: PLT1.6*127.9; Material: STEEL/250
Tekla Common - Bottom elevation: +1.903; Top elevation: +2.067; Phase: 1; Class: 11
Tekla Quantity - Weight: 0.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 163.6 m2; Net surface area: 0 m2; Height: 127.9 mm; Width: 1.6 mm; Length: 165 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 127.854 mm; NetArea: 0.0434681 m2; GrossArea: 0.0210959 m2; CrossSectionArea: 0.00000256 m2; NetVolume: 0.0000338454 m3; GrossVolume: 0.0000338454 m3
Name | ASSEMBLY_POS = Reference
5 x GIRT BRACKET | Z/215
GIRT BRACKET | GB/4

# IfcPlate: PLT1.6*77.9 (6)
In: Undefined
Description: PLT1.6*77.9; Material: STEEL/250
Tekla Common - Bottom elevation: +3.120; Top elevation: +3.250; Phase: 1; Class: 11
Tekla Quantity - Weight: 0.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 165.8 m2; Net surface area: 0 m2; Height: 77.9 mm; Width: 1.6 mm; Length: 130 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 77.854 mm; NetArea: 0.0211746 m2; GrossArea: 0.010121 m2; CrossSectionArea: 0.00000256 m2; NetVolume: 0.0000162661 m3; GrossVolume: 0.0000162661 m3
Name | ASSEMBLY_POS = Reference
5 x GIRT BRACKET | Z/212
GIRT BRACKET | GB/1

# IfcPlate: PLT1.6*82.9 (6)
In: Undefined
Description: PLT1.6*82.9; Material: STEEL/250
Tekla Common - Bottom elevation: +2.723; Top elevation: +2.848; Phase: 1; Class: 11
Tekla Quantity - Weight: 0.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 165.6 m2; Net surface area: 0 m2; Height: 82.9 mm; Width: 1.6 mm; Length: 125 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 82.854 mm; NetArea: 0.0216358 m2; GrossArea: 0.0103567 m2; CrossSectionArea: 0.00000256 m2; NetVolume: 0.0000166405 m3; GrossVolume: 0.0000166405 m3
Name | ASSEMBLY_POS = Reference
5 x GIRT BRACKET | Z/213
GIRT BRACKET | GB/2
