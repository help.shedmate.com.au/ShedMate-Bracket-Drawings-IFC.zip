Properties of the parts of a building model (IFC2X3), part 2 of 2

# IfcPlate: PLT3*205 (14)
BaseQuantities - Width: 205 mm; NetArea: 0.0717053 m2; GrossArea: 0.0719896 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000102393 m3; GrossVolume: 0.000102393 m3
Name | Bottom elevation | Top elevation
ADJUSTABLE FASCIA BRA | +5.339 | +5.544
ADJUSTABLE FASCIA BRA | +5.839 | +6.044
ADJUSTABLE FASCIA BRA | +4.605 | +4.810
ADJUSTABLE FASCIA BRA | +4.607 | +4.812
ADJUSTABLE FASCIA BRA | +4.712 | +4.917
ADJUSTABLE FASCIA BRA | +4.553 | +4.758
ADJUSTABLE FASCIA BRA | +5.867 | +6.072
ADJUSTABLE FASCIA BRA | +5.881 | +6.086
ADJUSTABLE FASCIA BRA | +4.163 | +4.368
ADJUSTABLE FASCIA BRA | +4.107 | +4.312
ADJUSTABLE FASCIA BRA | +4.213 | +4.418
ADJUSTABLE FASCIA BRA | +4.054 | +4.259
ADJUSTABLE FASCIA BRA | +5.367 | +5.572
ADJUSTABLE FASCIA BRA | +5.382 | +5.587

# IfcPlate: PLT3*210 (7)
In: Undefined
Description: PLT3*210; Material: STEEL/250
Default - ASSEMBLY_POS: PL/701(?)
Pset_PlateCommon - LoadBearing: no; Reference: PL/701(?)
Tekla Common - Phase: 1; Class: 2
Tekla Quantity - Weight: 0.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 89.3 m2; Net surface area: 0.1 m2; Height: 210 mm; Width: 3 mm; Length: 351.2 mm
BaseQuantities - Width: 210 mm; NetArea: 0.0696025 m2; GrossArea: 0.0737454 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.0000992041 m3; GrossVolume: 0.0000992041 m3
Name | Bottom elevation | Top elevation
ADJUSTABLE FASCIA BRA | +3.772 | +3.982
ADJUSTABLE FASCIA BRA | +4.839 | +5.049
ADJUSTABLE FASCIA BRA | +4.867 | +5.077
ADJUSTABLE FASCIA BRA | +3.663 | +3.873
ADJUSTABLE FASCIA BRA | +3.665 | +3.875
ADJUSTABLE FASCIA BRA | +3.615 | +3.825
ADJUSTABLE FASCIA BRA | +4.882 | +5.092

# IfcPlate: PLT3*250 (7)
In: Undefined
Description: PLT3*250; Material: STEEL/250
Default - ASSEMBLY_POS: PL/701(?)
Pset_PlateCommon - LoadBearing: no; Reference: PL/701(?)
Tekla Common - Phase: 1; Class: 2
Tekla Quantity - Weight: 0.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 89.2 m2; Net surface area: 0.1 m2; Height: 250 mm; Width: 3 mm; Length: 351.2 mm
BaseQuantities - Width: 250 mm; NetArea: 0.0782753 m2; GrossArea: 0.0877921 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000111843 m3; GrossVolume: 0.000111843 m3
Name | Bottom elevation | Top elevation
ADJUSTABLE FASCIA BRA | +6.059 | +6.309
ADJUSTABLE FASCIA BRA | +6.061 | +6.311
ADJUSTABLE FASCIA BRA | +6.167 | +6.417
ADJUSTABLE FASCIA BRA | +6.010 | +6.260
ADJUSTABLE FASCIA BRA | +7.338 | +7.588
ADJUSTABLE FASCIA BRA | +7.365 | +7.615
ADJUSTABLE FASCIA BRA | +7.379 | +7.629

# IfcPlate: PLT3*260 (7)
In: Undefined
Description: PLT3*260; Material: STEEL/250
Default - ASSEMBLY_POS: PL/701(?)
Pset_PlateCommon - LoadBearing: no; Reference: PL/701(?)
Tekla Common - Phase: 1; Class: 2
Tekla Quantity - Weight: 0.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 89.2 m2; Net surface area: 0.1 m2; Height: 260 mm; Width: 3 mm; Length: 351.2 mm
BaseQuantities - Width: 260 mm; NetArea: 0.0797353 m2; GrossArea: 0.0913038 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000113943 m3; GrossVolume: 0.000113943 m3
Name | Bottom elevation | Top elevation
ADJUSTABLE FASCIA BRA | +5.559 | +5.819
ADJUSTABLE FASCIA BRA | +5.562 | +5.822
ADJUSTABLE FASCIA BRA | +5.668 | +5.928
ADJUSTABLE FASCIA BRA | +5.511 | +5.771
ADJUSTABLE FASCIA BRA | +6.764 | +7.024
ADJUSTABLE FASCIA BRA | +6.736 | +6.996
ADJUSTABLE FASCIA BRA | +6.880 | +7.140

# IfcPlate: PLT3*280 (7)
In: Undefined
Description: PLT3*280; Material: STEEL/250
Default - ASSEMBLY_POS: PL/701(?)
Pset_PlateCommon - LoadBearing: no; Reference: PL/701(?)
Tekla Common - Phase: 1; Class: 2
Tekla Quantity - Weight: 0.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 89.3 m2; Net surface area: 0.1 m2; Height: 280 mm; Width: 3 mm; Length: 351.2 mm
BaseQuantities - Width: 280 mm; NetArea: 0.0798225 m2; GrossArea: 0.0983272 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000113904 m3; GrossVolume: 0.000113904 m3
Name | Bottom elevation | Top elevation
ADJUSTABLE FASCIA BRA | +5.165 | +5.445
ADJUSTABLE FASCIA BRA | +5.064 | +5.344
ADJUSTABLE FASCIA BRA | +5.170 | +5.450
ADJUSTABLE FASCIA BRA | +5.013 | +5.293
ADJUSTABLE FASCIA BRA | +6.341 | +6.621
ADJUSTABLE FASCIA BRA | +6.368 | +6.648
ADJUSTABLE FASCIA BRA | +6.382 | +6.662

# IfcPlate: PLT3*317.5 (2)
In: Undefined
Description: PLT3*317.5; Material: STEEL/250
Default - ASSEMBLY_POS: PL/701(?)
Tekla Common - Phase: 1; Class: 2
Tekla Quantity - Weight: 0.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 89.5 m2; Net surface area: 0.1 m2; Height: 317.5 mm; Width: 3 mm; Length: 351.2 mm
Pset_PlateCommon - LoadBearing: no; Reference: PL/701(?)
BaseQuantities - Width: 317.5 mm; NetArea: 0.0729432 m2; GrossArea: 0.111496 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000103775 m3; GrossVolume: 0.000103775 m3
Name | Bottom elevation | Top elevation
ADJUSTABLE FASCIA BRA | +7.805 | +8.122
ADJUSTABLE FASCIA BRA | +5.175 | +5.492

# IfcPlate: PLT3*394.5 (2)
In: Undefined
Description: PLT3*394.5; Material: STEEL/450
Tekla Common - Bottom elevation: +5.765; Top elevation: +6.180; Phase: 1; Class: 11
Tekla Quantity - Weight: 3.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.5 m2; Net surface area: 0.3 m2; Height: 394.5 mm; Width: 3 mm; Length: 463.2 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 394.529 mm; NetArea: 0.272188 m2; GrossArea: 0.182742 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000400928 m3; GrossVolume: 0.000400928 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1268
PLATE | PL/1250

# IfcPlate: PLT3*398.7 (2)
In: Undefined
Description: PLT3*398.7; Material: STEEL/450
Tekla Common - Bottom elevation: +6.214; Top elevation: +6.640; Phase: 1; Class: 11
Tekla Quantity - Weight: 3.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.5 m2; Net surface area: 0.3 m2; Height: 398.7 mm; Width: 3 mm; Length: 473.2 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 398.698 mm; NetArea: 0.272142 m2; GrossArea: 0.188674 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000400838 m3; GrossVolume: 0.000400838 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1269
PLATE | PL/1251

# IfcPlate: PLT3*399.3 (2)
In: Undefined
Description: PLT3*399.3; Material: STEEL/450
Tekla Common - Bottom elevation: +5.329; Top elevation: +5.733; Phase: 1; Class: 11
Tekla Quantity - Weight: 3.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.5 m2; Net surface area: 0.3 m2; Height: 399.3 mm; Width: 3 mm; Length: 453.8 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 399.25 mm; NetArea: 0.272289 m2; GrossArea: 0.181195 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000401092 m3; GrossVolume: 0.000401092 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1261
PLATE | PL/1253

# IfcPlate: PLT3*399.6 (2)
In: Undefined
Description: PLT3*399.6; Material: STEEL/450
Tekla Common - Bottom elevation: +7.327; Top elevation: +7.782; Phase: 1; Class: 11
Tekla Quantity - Weight: 3.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.5 m2; Net surface area: 0.3 m2; Height: 399.6 mm; Width: 3 mm; Length: 504 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 399.568 mm; NetArea: 0.271684 m2; GrossArea: 0.201392 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000400088 m3; GrossVolume: 0.000400088 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1265
PLATE | PL/1257

# IfcPlate: PLT3*407.3 (2)
In: Undefined
Description: PLT3*407.3; Material: STEEL/450
Tekla Common - Bottom elevation: +5.897; Top elevation: +6.291; Phase: 1; Class: 11
Tekla Quantity - Weight: 3.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.5 m2; Net surface area: 0.3 m2; Height: 407.3 mm; Width: 3 mm; Length: 439.7 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 407.335 mm; NetArea: 0.271991 m2; GrossArea: 0.179115 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000400662 m3; GrossVolume: 0.000400662 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1272
PLATE | PL/1249

# IfcPlate: PLT3*412.5 (2)
In: Undefined
Description: PLT3*412.5; Material: STEEL/450
Tekla Common - Bottom elevation: +5.331; Top elevation: +5.713; Phase: 1; Class: 11
Tekla Quantity - Weight: 3.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.5 m2; Net surface area: 0.3 m2; Height: 412.5 mm; Width: 3 mm; Length: 426.2 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 412.49 mm; NetArea: 0.271189 m2; GrossArea: 0.175805 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00039948 m3; GrossVolume: 0.00039948 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1271
PLATE | PL/1248

# IfcPlate: PLT3*414.4 (2)
In: Undefined
Description: PLT3*414.4; Material: STEEL/450
Tekla Common - Bottom elevation: +5.051; Top elevation: +5.427; Phase: 1; Class: 11
Tekla Quantity - Weight: 3.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.5 m2; Net surface area: 0.3 m2; Height: 414.4 mm; Width: 3 mm; Length: 419.8 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 414.411 mm; NetArea: 0.270632 m2; GrossArea: 0.17395 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000398657 m3; GrossVolume: 0.000398657 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1273
PLATE | PL/1246

# IfcPlate: PLT3*419.4 (2)
In: Undefined
Description: PLT3*419.4; Material: STEEL/450
Tekla Common - Bottom elevation: +4.632; Top elevation: +5.019; Phase: 1; Class: 11
Tekla Quantity - Weight: 3.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.5 m2; Net surface area: 0.3 m2; Height: 419.4 mm; Width: 3 mm; Length: 434.3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 419.362 mm; NetArea: 0.278278 m2; GrossArea: 0.182123 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000410015 m3; GrossVolume: 0.000410015 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1270
PLATE | PL/1247

# IfcPlate: PLT3*425 (2)
In: Undefined
Description: PLT3*425; Material: STEEL/450
Tekla Common - Bottom elevation: +4.632; Top elevation: +5.032; Phase: 1; Class: 11
Tekla Quantity - Weight: 3.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.5 m2; Net surface area: 0.3 m2; Height: 425 mm; Width: 3 mm; Length: 446.2 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 425.022 mm; NetArea: 0.284054 m2; GrossArea: 0.189625 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00041859 m3; GrossVolume: 0.00041859 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1266
PLATE | PL/1258

# IfcPlate: PLT3*435.5 (2)
In: Undefined
Description: PLT3*435.5; Material: STEEL/450
Tekla Common - Bottom elevation: +4.631; Top elevation: +5.058; Phase: 1; Class: 11
Tekla Quantity - Weight: 3.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.5 m2; Net surface area: 0.3 m2; Height: 435.5 mm; Width: 3 mm; Length: 469.9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 435.456 mm; NetArea: 0.2955 m2; GrossArea: 0.204623 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000435582 m3; GrossVolume: 0.000435582 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1267
PLATE | PL/1259

# IfcPlate: PLT3*442.5 (2)
In: Undefined
Description: PLT3*442.5; Material: STEEL/450
Tekla Common - Bottom elevation: +3.629; Top elevation: +4.077; Phase: 1; Class: 11
Tekla Quantity - Weight: 3.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.5 m2; Net surface area: 0.3 m2; Height: 442.5 mm; Width: 3 mm; Length: 487.8 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 442.489 mm; NetArea: 0.304007 m2; GrossArea: 0.215836 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000448205 m3; GrossVolume: 0.000448205 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1260
PLATE | PL/1252

# IfcPlate: PLT3*448.9 (2)
In: Undefined
Description: PLT3*448.9; Material: STEEL/450
Tekla Common - Bottom elevation: +3.623; Top elevation: +4.091; Phase: 1; Class: 11
Tekla Quantity - Weight: 3.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.5 m2; Net surface area: 0.3 m2; Height: 448.9 mm; Width: 3 mm; Length: 505.7 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 448.851 mm; NetArea: 0.312452 m2; GrossArea: 0.226981 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000460732 m3; GrossVolume: 0.000460732 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1262
PLATE | PL/1254

# IfcPlate: PLT3*454.7 (2)
In: Undefined
Description: PLT3*454.7; Material: STEEL/450
Tekla Common - Bottom elevation: +3.616; Top elevation: +4.106; Phase: 1; Class: 11
Tekla Quantity - Weight: 3.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.5 m2; Net surface area: 0.3 m2; Height: 454.7 mm; Width: 3 mm; Length: 524.3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 454.707 mm; NetArea: 0.321325 m2; GrossArea: 0.238384 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000473891 m3; GrossVolume: 0.000473891 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1263
PLATE | PL/1255

# IfcPlate: PLT3*458.6 (2)
In: Undefined
Description: PLT3*458.6; Material: STEEL/450
Tekla Common - Bottom elevation: +3.599; Top elevation: +4.137; Phase: 1; Class: 11
Tekla Quantity - Weight: 3.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.5 m2; Net surface area: 0.3 m2; Height: 458.6 mm; Width: 3 mm; Length: 569.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 458.565 mm; NetArea: 0.340214 m2; GrossArea: 0.261204 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00050188 m3; GrossVolume: 0.00050188 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1264
PLATE | PL/1256
