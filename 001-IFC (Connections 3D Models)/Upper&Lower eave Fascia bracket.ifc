Properties of the parts of a building model (IFC2X3), part 1 of 2

# File
Description: ViewDefinition[CoordinationView_V2.0, QuantityTakeOffAddOnView], Option [BaseQuantities:On], Option [GridExport:On], Option [Assemblies:On], Option [Bolts:On], Option [Rebars:On], Option [PourObjects:Off], Option [Welds:Off], Option [SurfaceTreatments:Off], Option [LocationBy:0], Option [ViewColors:Off], Option [SectionedSpine:Off], Option [PropertySets:On], Option [Export all:Off]
File name: Upper&Lower eave Fascia bracket.ifc
Time: 2026-05-26T13:53:05
Author: DESKTOP-BKNQL56\admin
Organization: Structural Designer
Written by: IFC Database Version: Work
Made in: Tekla Structures 2019 Service Pack 13, IFC Export Version: 4.0.0.0 Oct 18 2021

# IfcBuildingStorey, Undefined
In: Undefined
Elevation: 0 mm

# IfcBeam: C:100-15 (90)
In: Undefined
Description: C:100-15; Material: STEEL/300PLUS
Tekla Common - Phase: 1
Tekla Quantity - Volume: 0 m3; Height: 102 mm; Width: 51 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Class | Weight (kg) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
FASCIA | F/18(?) | +8.039 | +8.141 | 13 | 1 | 0 | 179.3 | 0.2 | 400 | 0.181875 | 0.000135 | 1.05975
FASCIA | F/18(?) | +8.039 | +8.141 | 13 | 2.5 | 0.1 | 178.9 | 0.5 | 1000 | 0.453675 | 0.0003375 | 2.64938
FASCIA | F/18(?) | +8.039 | +8.141 | 13 | 0.5 | 0 | 180 | 0.1 | 200 | 0.091275 | 0.0000675 | 0.529875
FASCIA | F/18(?) | +5.409 | +5.511 | 13 | 1 | 0 | 179.3 | 0.2 | 400 | 0.181875 | 0.000135 | 1.05975
FASCIA | F/18(?) | +5.409 | +5.511 | 13 | 2.5 | 0.1 | 178.9 | 0.5 | 1000 | 0.453675 | 0.0003375 | 2.64938
FASCIA | F/18(?) | +5.409 | +5.511 | 13 | 0.5 | 0 | 180 | 0.1 | 200 | 0.091275 | 0.0000675 | 0.529875
FASCIA | F/18(?) | +5.362 | +5.464 | 13 | 1 | 0 | 179.3 | 0.2 | 400 | 0.181875 | 0.000135 | 1.05975
FASCIA | F/18(?) | +5.362 | +5.464 | 13 | 2.5 | 0.1 | 178.9 | 0.5 | 1000 | 0.453675 | 0.0003375 | 2.64938
FASCIA | F/18(?) | +5.362 | +5.464 | 13 | 0.5 | 0 | 180 | 0.1 | 200 | 0.091275 | 0.0000675 | 0.529875
FASCIA | F/18(?) | +5.261 | +5.363 | 13 | 1 | 0 | 179.3 | 0.2 | 400 | 0.181875 | 0.000135 | 1.05975
FASCIA | F/18(?) | +5.261 | +5.363 | 13 | 2.5 | 0.1 | 178.9 | 0.5 | 1000 | 0.453675 | 0.0003375 | 2.64938
FASCIA | F/18(?) | +5.261 | +5.363 | 13 | 0.5 | 0 | 180 | 0.1 | 200 | 0.091275 | 0.0000675 | 0.529875
FASCIA | F/18(?) | +5.367 | +5.469 | 13 | 1 | 0 | 179.3 | 0.2 | 400 | 0.181875 | 0.000135 | 1.05975
FASCIA | F/18(?) | +5.367 | +5.469 | 13 | 2.5 | 0.1 | 178.9 | 0.5 | 1000 | 0.453675 | 0.0003375 | 2.64938
FASCIA | F/18(?) | +5.367 | +5.469 | 13 | 0.5 | 0 | 180 | 0.1 | 200 | 0.091275 | 0.0000675 | 0.529875
FASCIA | F/18(?) | +5.210 | +5.312 | 13 | 1 | 0 | 179.3 | 0.2 | 400 | 0.181875 | 0.000135 | 1.05975
FASCIA | F/18(?) | +5.210 | +5.312 | 13 | 2.5 | 0.1 | 178.9 | 0.5 | 1000 | 0.453675 | 0.0003375 | 2.64938
FASCIA | F/18(?) | +5.210 | +5.312 | 13 | 0.5 | 0 | 180 | 0.1 | 200 | 0.091275 | 0.0000675 | 0.529875
FASCIA | F/18(?) | +6.537 | +6.639 | 13 | 1 | 0 | 179.3 | 0.2 | 400 | 0.181875 | 0.000135 | 1.05975
FASCIA | F/18(?) | +6.537 | +6.639 | 13 | 2.5 | 0.1 | 178.9 | 0.5 | 1000 | 0.453675 | 0.0003375 | 2.64938
FASCIA | F/18(?) | +6.537 | +6.639 | 13 | 0.5 | 0 | 180 | 0.1 | 200 | 0.091275 | 0.0000675 | 0.529875
FASCIA | F/18(?) | +6.565 | +6.667 | 13 | 1 | 0 | 179.3 | 0.2 | 400 | 0.181875 | 0.000135 | 1.05975
FASCIA | F/18(?) | +6.565 | +6.667 | 13 | 2.5 | 0.1 | 178.9 | 0.5 | 1000 | 0.453675 | 0.0003375 | 2.64938
FASCIA | F/18(?) | +6.565 | +6.667 | 13 | 0.5 | 0 | 180 | 0.1 | 200 | 0.091275 | 0.0000675 | 0.529875
FASCIA | F/18(?) | +6.579 | +6.681 | 13 | 1 | 0 | 179.3 | 0.2 | 400 | 0.181875 | 0.000135 | 1.05975
FASCIA | F/18(?) | +6.579 | +6.681 | 13 | 2.5 | 0.1 | 178.9 | 0.5 | 1000 | 0.453675 | 0.0003375 | 2.64938
FASCIA | F/18(?) | +6.579 | +6.681 | 13 | 0.5 | 0 | 180 | 0.1 | 200 | 0.091275 | 0.0000675 | 0.529875
FASCIA | F/18(?) | +4.953 | +5.055 | 13 | 1 | 0 | 179.3 | 0.2 | 400 | 0.181875 | 0.000135 | 1.05975
FASCIA | F/18(?) | +4.953 | +5.055 | 13 | 2.5 | 0.1 | 178.9 | 0.5 | 1000 | 0.453675 | 0.0003375 | 2.64938
FASCIA | F/18(?) | +4.953 | +5.055 | 13 | 0.5 | 0 | 180 | 0.1 | 200 | 0.091275 | 0.0000675 | 0.529875
FASCIA | F/18(?) | +4.981 | +5.083 | 13 | 1 | 0 | 179.3 | 0.2 | 400 | 0.181875 | 0.000135 | 1.05975
FASCIA | F/18(?) | +4.981 | +5.083 | 13 | 2.5 | 0.1 | 178.9 | 0.5 | 1000 | 0.453675 | 0.0003375 | 2.64938
FASCIA | F/18(?) | +4.981 | +5.083 | 13 | 0.5 | 0 | 180 | 0.1 | 200 | 0.091275 | 0.0000675 | 0.529875
FASCIA | F/18(?) | +4.996 | +5.098 | 13 | 1 | 0 | 179.3 | 0.2 | 400 | 0.181875 | 0.000135 | 1.05975
FASCIA | F/18(?) | +4.996 | +5.098 | 13 | 2.5 | 0.1 | 178.9 | 0.5 | 1000 | 0.453675 | 0.0003375 | 2.64938
FASCIA | F/18(?) | +4.996 | +5.098 | 13 | 0.5 | 0 | 180 | 0.1 | 200 | 0.091275 | 0.0000675 | 0.529875
FASCIA | F/18(?) | +3.729 | +3.831 | 13 | 1 | 0 | 179.3 | 0.2 | 400 | 0.181875 | 0.000135 | 1.05975
FASCIA | F/18(?) | +3.729 | +3.831 | 13 | 2.5 | 0.1 | 178.9 | 0.5 | 1000 | 0.453675 | 0.0003375 | 2.64938
FASCIA | F/18(?) | +3.729 | +3.831 | 13 | 0.5 | 0 | 180 | 0.1 | 200 | 0.091275 | 0.0000675 | 0.529875
FASCIA | F/18(?) | +3.886 | +3.988 | 13 | 1 | 0 | 179.3 | 0.2 | 400 | 0.181875 | 0.000135 | 1.05975
FASCIA | F/18(?) | +3.886 | +3.988 | 13 | 2.5 | 0.1 | 178.9 | 0.5 | 1000 | 0.453675 | 0.0003375 | 2.64938
FASCIA | F/18(?) | +3.886 | +3.988 | 13 | 0.5 | 0 | 180 | 0.1 | 200 | 0.091275 | 0.0000675 | 0.529875
FASCIA | F/18(?) | +3.779 | +3.881 | 13 | 1 | 0 | 179.3 | 0.2 | 400 | 0.181875 | 0.000135 | 1.05975
FASCIA | F/18(?) | +3.779 | +3.881 | 13 | 2.5 | 0.1 | 178.9 | 0.5 | 1000 | 0.453675 | 0.0003375 | 2.64938
FASCIA | F/18(?) | +3.779 | +3.881 | 13 | 0.5 | 0 | 180 | 0.1 | 200 | 0.091275 | 0.0000675 | 0.529875
2 x TH | B/5(?) | +7.120 | +7.234 | 4 | 2.5 | 0 | 178.9 | 0.5 | 1000 | 0.453675 | 0.0003375 | 2.64938
2 x TH | B/5(?) | +6.620 | +6.734 | 4 | 2.5 | 0 | 178.9 | 0.5 | 1000 | 0.453675 | 0.0003375 | 2.64938
2 x TH | B/5(?) | +7.600 | +7.704 | 4 | 2.5 | 0 | 178.9 | 0.5 | 1000 | 0.453675 | 0.0003375 | 2.64937
2 x TH | B/5(?) | +7.100 | +7.204 | 4 | 2.5 | 0 | 178.9 | 0.5 | 1000 | 0.453675 | 0.0003375 | 2.64937
2 x TH | B/5(?) | +7.673 | +7.779 | 4 | 2.5 | 0 | 178.9 | 0.5 | 1000 | 0.453675 | 0.0003375 | 2.64938
2 x TH | B/5(?) | +7.173 | +7.279 | 4 | 2.5 | 0 | 178.9 | 0.5 | 1000 | 0.453675 | 0.0003375 | 2.64938
2 x TH | B/5(?) | +7.787 | +7.896 | 4 | 2.5 | 0 | 178.9 | 0.5 | 1000 | 0.453675 | 0.0003375 | 2.64938
2 x TH | B/5(?) | +7.287 | +7.396 | 4 | 2.5 | 0 | 178.9 | 0.5 | 1000 | 0.453675 | 0.0003375 | 2.64938
2 x TH | B/5(?) | +6.787 | +6.896 | 4 | 2.5 | 0 | 178.9 | 0.5 | 1000 | 0.453675 | 0.0003375 | 2.64938
2 x TH | B/5(?) | +6.673 | +6.779 | 4 | 2.5 | 0 | 178.9 | 0.5 | 1000 | 0.453675 | 0.0003375 | 2.64938
2 x TH | B/5(?) | +6.600 | +6.704 | 4 | 2.5 | 0 | 178.9 | 0.5 | 1000 | 0.453675 | 0.0003375 | 2.64937
2 x TH | B/5(?) | +6.120 | +6.234 | 4 | 2.5 | 0 | 178.9 | 0.5 | 1000 | 0.453675 | 0.0003375 | 2.64938
2 x TH | B/5(?) | +7.043 | +7.156 | 4 | 2.5 | 0 | 178.9 | 0.5 | 1000 | 0.453675 | 0.0003375 | 2.64938
2 x TH | B/5(?) | +6.543 | +6.656 | 4 | 2.5 | 0 | 178.9 | 0.5 | 1000 | 0.453675 | 0.0003375 | 2.64938
2 x TH | B/5(?) | +6.043 | +6.156 | 4 | 2.5 | 0 | 178.9 | 0.5 | 1000 | 0.453675 | 0.0003375 | 2.64938
2 x TH | B/5(?) | +6.914 | +7.026 | 4 | 2.5 | 0 | 178.9 | 0.5 | 1000 | 0.453675 | 0.0003375 | 2.64937
2 x TH | B/5(?) | +6.414 | +6.526 | 4 | 2.5 | 0 | 178.9 | 0.5 | 1000 | 0.453675 | 0.0003375 | 2.64937
2 x TH | B/5(?) | +5.914 | +6.026 | 4 | 2.5 | 0 | 178.9 | 0.5 | 1000 | 0.453675 | 0.0003375 | 2.64937
2 x TH | B/5(?) | +6.852 | +6.962 | 4 | 2.5 | 0 | 178.9 | 0.5 | 1000 | 0.453675 | 0.0003375 | 2.64937
2 x TH | B/5(?) | +6.352 | +6.462 | 4 | 2.5 | 0 | 178.9 | 0.5 | 1000 | 0.453675 | 0.0003375 | 2.64937
2 x TH | B/5(?) | +5.852 | +5.962 | 4 | 2.5 | 0 | 178.9 | 0.5 | 1000 | 0.453675 | 0.0003375 | 2.64937
FASCIA | F/18(?) | +3.777 | +3.879 | 13 | 1 | 0 | 179.3 | 0.2 | 400 | 0.181875 | 0.000135 | 1.05975
FASCIA | F/18(?) | +3.777 | +3.879 | 13 | 2.5 | 0.1 | 178.9 | 0.5 | 1000 | 0.453675 | 0.0003375 | 2.64938
FASCIA | F/18(?) | +3.777 | +3.879 | 13 | 0.5 | 0 | 180 | 0.1 | 200 | 0.091275 | 0.0000675 | 0.529875

# IfcBeam: C:150-15 (36)
In: Undefined
Description: C:150-15; Material: STEEL/300PLUS
Pset_BeamCommon - LoadBearing: no
Tekla Common - Phase: 1
Tekla Quantity - Volume: 0 m3; Height: 152 mm; Width: 64 mm
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Class | Weight (kg) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
FASCIA | F/18(?) | +5.708 | +5.860 | 13 | 1.4 | 0 | 176.9 | 0.2 | 400 | 0.246115 | 0.000183 | 1.43655
FASCIA | F/18(?) | +5.708 | +5.860 | 13 | 3.5 | 0.1 | 176.4 | 0.6 | 1000 | 0.613915 | 0.0004575 | 3.59138
FASCIA | F/18(?) | +5.708 | +5.860 | 13 | 0.8 | 0 | 177.6 | 0.1 | 200 | 0.123515 | 0.0000915 | 0.718275
FASCIA | F/18(?) | +5.711 | +5.863 | 13 | 1.4 | 0 | 176.9 | 0.2 | 400 | 0.246115 | 0.000183 | 1.43655
FASCIA | F/18(?) | +5.711 | +5.863 | 13 | 3.5 | 0.1 | 176.4 | 0.6 | 1000 | 0.613915 | 0.0004575 | 3.59138
FASCIA | F/18(?) | +5.711 | +5.863 | 13 | 0.8 | 0 | 177.6 | 0.1 | 200 | 0.123515 | 0.0000915 | 0.718275
FASCIA | F/18(?) | +5.817 | +5.969 | 13 | 1.4 | 0 | 176.9 | 0.2 | 400 | 0.246115 | 0.000183 | 1.43655
FASCIA | F/18(?) | +5.817 | +5.969 | 13 | 3.5 | 0.1 | 176.4 | 0.6 | 1000 | 0.613915 | 0.0004575 | 3.59138
FASCIA | F/18(?) | +5.817 | +5.969 | 13 | 0.8 | 0 | 177.6 | 0.1 | 200 | 0.123515 | 0.0000915 | 0.718275
FASCIA | F/18(?) | +5.660 | +5.812 | 13 | 1.4 | 0 | 176.9 | 0.2 | 400 | 0.246115 | 0.000183 | 1.43655
FASCIA | F/18(?) | +5.660 | +5.812 | 13 | 3.5 | 0.1 | 176.4 | 0.6 | 1000 | 0.613915 | 0.0004575 | 3.59138
FASCIA | F/18(?) | +5.660 | +5.812 | 13 | 0.8 | 0 | 177.6 | 0.1 | 200 | 0.123515 | 0.0000915 | 0.718275
FASCIA | F/18(?) | +6.913 | +7.065 | 13 | 1.4 | 0 | 176.9 | 0.2 | 400 | 0.246115 | 0.000183 | 1.43655
FASCIA | F/18(?) | +6.913 | +7.065 | 13 | 3.5 | 0.1 | 176.4 | 0.6 | 1000 | 0.613915 | 0.0004575 | 3.59138
FASCIA | F/18(?) | +6.913 | +7.065 | 13 | 0.8 | 0 | 177.6 | 0.1 | 200 | 0.123515 | 0.0000915 | 0.718275
FASCIA | F/18(?) | +6.885 | +7.037 | 13 | 1.4 | 0 | 176.9 | 0.2 | 400 | 0.246115 | 0.000183 | 1.43655
FASCIA | F/18(?) | +6.885 | +7.037 | 13 | 3.5 | 0.1 | 176.4 | 0.6 | 1000 | 0.613915 | 0.0004575 | 3.59138
FASCIA | F/18(?) | +6.885 | +7.037 | 13 | 0.8 | 0 | 177.6 | 0.1 | 200 | 0.123515 | 0.0000915 | 0.718275
FASCIA | F/18(?) | +7.029 | +7.181 | 13 | 1.4 | 0 | 176.9 | 0.2 | 400 | 0.246115 | 0.000183 | 1.43655
FASCIA | F/18(?) | +7.029 | +7.181 | 13 | 3.5 | 0.1 | 176.4 | 0.6 | 1000 | 0.613915 | 0.0004575 | 3.59138
FASCIA | F/18(?) | +7.029 | +7.181 | 13 | 0.8 | 0 | 177.6 | 0.1 | 200 | 0.123515 | 0.0000915 | 0.718275
FASCIA | F/18(?) | +5.403 | +5.555 | 13 | 0.8 | 0 | 177.6 | 0.1 | 200 | 0.123515 | 0.0000915 | 0.718275
FASCIA | F/18(?) | +5.431 | +5.583 | 13 | 0.8 | 0 | 177.6 | 0.1 | 200 | 0.123515 | 0.0000915 | 0.718275
FASCIA | F/18(?) | +5.446 | +5.598 | 13 | 0.8 | 0 | 177.6 | 0.1 | 200 | 0.123515 | 0.0000915 | 0.718275
FASCIA | F/18(?) | +4.118 | +4.270 | 13 | 0.8 | 0 | 177.6 | 0.1 | 200 | 0.123515 | 0.0000915 | 0.718275
FASCIA | F/18(?) | +4.277 | +4.429 | 13 | 0.8 | 0 | 177.6 | 0.1 | 200 | 0.123515 | 0.0000915 | 0.718275
FASCIA | F/18(?) | +4.171 | +4.323 | 13 | 0.8 | 0 | 177.6 | 0.1 | 200 | 0.123515 | 0.0000915 | 0.718275
2 x TH | B/5(?) | +6.796 | +6.958 | 4 | 3.5 | 0 | 176.4 | 0.6 | 1000 | 0.613915 | 0.0004575 | 3.59137
2 x TH | B/5(?) | +6.296 | +6.458 | 4 | 3.5 | 0 | 176.4 | 0.6 | 1000 | 0.613915 | 0.0004575 | 3.59137
2 x TH | B/5(?) | +5.796 | +5.958 | 4 | 3.5 | 0 | 176.4 | 0.6 | 1000 | 0.613915 | 0.0004575 | 3.59137
FASCIA | F/18(?) | +4.227 | +4.379 | 13 | 1.4 | 0 | 176.9 | 0.2 | 400 | 0.246115 | 0.000183 | 1.43655
FASCIA | F/18(?) | +4.227 | +4.379 | 13 | 3.5 | 0.1 | 176.4 | 0.6 | 1000 | 0.613915 | 0.0004575 | 3.59138
FASCIA | F/18(?) | +4.227 | +4.379 | 13 | 0.8 | 0 | 177.6 | 0.1 | 200 | 0.123515 | 0.0000915 | 0.718275

# IfcBeam: C:150-24 (86)
In: Undefined
Description: C:150-24; Material: STEEL/G450
Tekla Common - Phase: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 111.2 m2; Height: 152 mm; Width: 64 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Finish | Bottom elevation | Top elevation | Class | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x RAFTER | Z/1696(?) | 3 deg | +7.330 | +7.944 | 10 | 49.2 | 5.5 | 8830.8 | 8830.76 | 5.47302 | 0.00651498 | 51.1426
2 x RAFTER | Z/1696(?) | 3 deg | +6.830 | +7.444 | 10 | 49.2 | 5.5 | 8830.8 | 8830.76 | 5.47302 | 0.00651498 | 51.1426
2 x RAFTER | Z/1696(?) | 3 deg | +6.330 | +6.944 | 10 | 49.2 | 5.5 | 8830.8 | 8830.76 | 5.47302 | 0.00651498 | 51.1426
2 x RAFTER | Z/1696(?) | 3 deg | +5.830 | +6.444 | 10 | 49.2 | 5.5 | 8830.8 | 8830.76 | 5.47302 | 0.00651498 | 51.1426
2 x RAFTER | Z/1696(?) | 3 deg | +5.330 | +5.944 | 10 | 49.2 | 5.5 | 8830.8 | 8830.76 | 5.47302 | 0.00651498 | 51.1426
2 x RAFTER | Z/1699(?) | 5 deg | +7.319 | +8.241 | 10 | 49.3 | 5.5 | 8844.6 | 8844.6 | 5.48159 | 0.00652519 | 51.2228
2 x RAFTER | Z/1699(?) | 5 deg | +6.819 | +7.741 | 10 | 49.3 | 5.5 | 8844.6 | 8844.6 | 5.48159 | 0.00652519 | 51.2228
2 x RAFTER | Z/1699(?) | 5 deg | +6.319 | +7.241 | 10 | 49.3 | 5.5 | 8844.6 | 8844.6 | 5.48159 | 0.00652519 | 51.2228
2 x RAFTER | Z/1699(?) | 5 deg | +5.819 | +6.741 | 10 | 49.3 | 5.5 | 8844.6 | 8844.6 | 5.48159 | 0.00652519 | 51.2228
2 x RAFTER | Z/1699(?) | 5 deg | +5.319 | +6.241 | 10 | 49.3 | 5.5 | 8844.6 | 8844.6 | 5.48159 | 0.00652519 | 51.2228
2 x RAFTER | Z/1702(?) | 9 deg | +7.297 | +8.840 | 10 | 49.6 | 5.5 | 8901.5 | 8901.5 | 5.51685 | 0.00656717 | 51.5523
2 x RAFTER | Z/1702(?) | 9 deg | +6.797 | +8.340 | 10 | 49.6 | 5.5 | 8901.5 | 8901.5 | 5.51685 | 0.00656717 | 51.5523
2 x RAFTER | Z/1702(?) | 9 deg | +6.297 | +7.840 | 10 | 49.6 | 5.5 | 8901.5 | 8901.5 | 5.51685 | 0.00656717 | 51.5523
2 x RAFTER | Z/1702(?) | 9 deg | +5.797 | +7.340 | 10 | 49.6 | 5.5 | 8901.5 | 8901.5 | 5.51685 | 0.00656717 | 51.5523
2 x RAFTER | Z/1702(?) | 9 deg | +5.297 | +6.840 | 10 | 49.6 | 5.5 | 8901.5 | 8901.5 | 5.51685 | 0.00656717 | 51.5523
2 x RAFTER | Z/1692(?) | 18 deg | +6.245 | +9.344 | 10 | 53.3 | 5.9 | 9560.8 | 9560.78 | 5.92534 | 0.00705356 | 55.3705
2 x RAFTER | Z/1692(?) | 18 deg | +5.745 | +8.844 | 10 | 53.3 | 5.9 | 9560.8 | 9560.78 | 5.92534 | 0.00705356 | 55.3705
2 x RAFTER | Z/1692(?) | 18 deg | +5.245 | +8.344 | 10 | 53.3 | 5.9 | 9560.8 | 9560.78 | 5.92534 | 0.00705356 | 55.3705
2 x RAFTER | Z/1692(?) | 18 deg | +4.745 | +7.844 | 10 | 53.3 | 5.9 | 9560.8 | 9560.78 | 5.92534 | 0.00705356 | 55.3705
2 x RAFTER | Z/1692(?) | 18 deg | +4.245 | +7.344 | 10 | 53.3 | 5.9 | 9560.8 | 9560.78 | 5.92534 | 0.00705356 | 55.3705
2 x RAFTER | Z/1689(?) | 15 deg | +6.133 | +8.999 | 10 | 58.6 | 6.5 | 10506.2 | 10506.2 | 6.5111 | 0.00775103 | 60.8456
2 x RAFTER | Z/1689(?) | 15 deg | +5.633 | +8.499 | 10 | 58.6 | 6.5 | 10506.2 | 10506.2 | 6.5111 | 0.00775103 | 60.8456
2 x RAFTER | Z/1689(?) | 15 deg | +5.133 | +7.999 | 10 | 58.6 | 6.5 | 10506.2 | 10506.2 | 6.5111 | 0.00775103 | 60.8456
2 x RAFTER | Z/1689(?) | 15 deg | +4.633 | +7.499 | 10 | 58.6 | 6.5 | 10506.2 | 10506.2 | 6.5111 | 0.00775103 | 60.8456
2 x RAFTER | Z/1689(?) | 15 deg | +4.133 | +6.999 | 10 | 58.6 | 6.5 | 10506.2 | 10506.2 | 6.5111 | 0.00775103 | 60.8456
2 x RAFTER | Z/1673(?) | 12 deg | +6.126 | +8.543 | 10 | 60.8 | 6.8 | 10914 | 10914 | 6.7638 | 0.00805192 | 63.2076
2 x RAFTER | Z/1673(?) | 12 deg | +5.626 | +8.043 | 10 | 60.8 | 6.8 | 10914 | 10914 | 6.7638 | 0.00805192 | 63.2076
2 x RAFTER | Z/1673(?) | 12 deg | +5.126 | +7.543 | 10 | 60.8 | 6.8 | 10914 | 10914 | 6.7638 | 0.00805192 | 63.2076
2 x RAFTER | Z/1673(?) | 12 deg | +4.626 | +7.043 | 10 | 60.8 | 6.8 | 10914 | 10914 | 6.7638 | 0.00805192 | 63.2076
2 x RAFTER | Z/1673(?) | 12 deg | +4.126 | +6.543 | 10 | 60.8 | 6.8 | 10914 | 10914 | 6.7638 | 0.00805192 | 63.2076
COLUMN | Z/1858 | 25 deg | +0.000 | +7.543 | 12 | 42 | 4.7 | 7543.3 | 7543.26 | 4.67528 | 0.00556512 | 43.6862
COLUMN | Z/1693 | 25 deg | +0.000 | +3.813 | 12 | 21.3 | 2.4 | 3812.8 | 3812.81 | 2.36389 | 0.00281294 | 22.0815
COLUMN | Z/1842 | 18 deg | +0.000 | +6.431 | 12 | 35.8 | 4 | 6430.8 | 6430.8 | 3.986 | 0.00474438 | 37.2434
RAFTER | Z/1692 | 18 deg | +3.745 | +6.844 | 10 | 53.3 | 5.9 | 9560.8 | 9560.78 | 5.92534 | 0.00705356 | 55.3705
COLUMN | Z/1691 | 18 deg | +0.000 | +3.831 | 12 | 21.4 | 2.4 | 3830.7 | 3830.73 | 2.37499 | 0.00282616 | 22.1853
COLUMN | Z/1830 | 15 deg | +0.000 | +5.982 | 12 | 33.3 | 3.7 | 5981.8 | 5981.82 | 3.70781 | 0.00441315 | 34.6432
RAFTER | Z/1689 | 15 deg | +3.633 | +6.499 | 10 | 58.6 | 6.5 | 10506.2 | 10506.2 | 6.5111 | 0.00775103 | 60.8456
COLUMN | Z/1688 | 15 deg | +0.000 | +3.838 | 12 | 21.4 | 2.4 | 3838.2 | 3838.23 | 2.37964 | 0.00283169 | 22.2288
RAFTER | Z/1673 | 12 deg | +3.626 | +6.043 | 10 | 60.8 | 6.8 | 10914 | 10914 | 6.7638 | 0.00805192 | 63.2076
COLUMN | Z/1672 | 12 deg | +0.000 | +3.844 | 12 | 21.4 | 2.4 | 3844.4 | 3844.4 | 2.38347 | 0.00283625 | 22.2645
RAFTER | Z/1702 | 9 deg | +4.797 | +6.340 | 10 | 49.6 | 5.5 | 8901.5 | 8901.5 | 5.51685 | 0.00656717 | 51.5523
COLUMN | Z/1701 | 9 deg | +0.000 | +4.846 | 12 | 27 | 3 | 4845.8 | 4845.81 | 3.00394 | 0.00357505 | 28.0641
RAFTER | Z/1699 | 5 deg | +4.819 | +5.741 | 10 | 49.3 | 5.5 | 8844.6 | 8844.6 | 5.48159 | 0.00652519 | 51.2228
COLUMN | Z/1698 | 5 deg | +0.000 | +4.847 | 12 | 27 | 3 | 4847.1 | 4847.12 | 3.00475 | 0.00357601 | 28.0717
RAFTER | Z/1696 | 3 deg | +4.830 | +5.444 | 10 | 49.2 | 5.5 | 8830.8 | 8830.76 | 5.47302 | 0.00651498 | 51.1426
COLUMN | Z/1695 | 3 deg | +0.000 | +4.848 | 12 | 27 | 3 | 4847.6 | 4847.59 | 3.00504 | 0.00357636 | 28.0744
COLUMN | Z/1687 | 12 deg | +0.000 | +5.545 | 12 | 30.9 | 3.4 | 5544.9 | 5544.86 | 3.43707 | 0.00409077 | 32.1126
COLUMN | Z/1703 | 9 deg | +0.000 | +6.113 | 12 | 34.1 | 3.8 | 6112.9 | 6112.89 | 3.78902 | 0.00450985 | 35.4023
COLUMN | Z/1700 | 5 deg | +0.000 | +5.547 | 12 | 30.9 | 3.4 | 5547 | 5547.03 | 3.43842 | 0.00409238 | 32.1252
COLUMN | Z/1697 | 3 deg | +0.000 | +5.267 | 12 | 29.4 | 3.3 | 5266.8 | 5266.85 | 3.26481 | 0.00388567 | 30.5025
RAFTER | Z/1702(?) | 9 deg | +4.797 | +6.340 | 10 | 49.6 | 5.5 | 8901.5 | 8901.5 | 5.51685 | 0.00656717 | 51.5523
RAFTER | Z/1699(?) | 5 deg | +4.819 | +5.741 | 10 | 49.3 | 5.5 | 8844.6 | 8844.6 | 5.48159 | 0.00652519 | 51.2228
RAFTER | Z/1696(?) | 3 deg | +4.830 | +5.444 | 10 | 49.2 | 5.5 | 8830.8 | 8830.76 | 5.47302 | 0.00651498 | 51.1426
RAFTER | Z/1692(?) | 18 deg | +3.745 | +6.844 | 10 | 53.3 | 5.9 | 9560.8 | 9560.78 | 5.92534 | 0.00705356 | 55.3705
RAFTER | Z/1689(?) | 15 deg | +3.633 | +6.499 | 10 | 58.6 | 6.5 | 10506.2 | 10506.2 | 6.5111 | 0.00775103 | 60.8456
RAFTER | Z/1673(?) | 12 deg | +3.626 | +6.043 | 10 | 60.8 | 6.8 | 10914 | 10914 | 6.7638 | 0.00805192 | 63.2076

# IfcBeam: C:200-15 (84)
In: Undefined
Description: C:200-15; Material: STEEL/300PLUS
Pset_BeamCommon - LoadBearing: no
Tekla Common - Phase: 1
Tekla Quantity - Volume: 0 m3; Height: 203 mm; Width: 76 mm
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Class | Weight (kg) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
FASCIA | F/18(?) | +6.157 | +6.360 | 13 | 1.7 | 0 | 175.8 | 0.3 | 400 | 0.30634 | 0.000228 | 1.7898
FASCIA | F/18(?) | +6.157 | +6.360 | 13 | 4.4 | 0.1 | 175.4 | 0.8 | 1000 | 0.76414 | 0.00057 | 4.4745
FASCIA | F/18(?) | +6.157 | +6.360 | 13 | 0.8 | 0 | 176.4 | 0.2 | 200 | 0.15374 | 0.000114 | 0.8949
FASCIA | F/18(?) | +6.160 | +6.363 | 13 | 1.7 | 0 | 175.8 | 0.3 | 400 | 0.30634 | 0.000228 | 1.7898
FASCIA | F/18(?) | +6.160 | +6.363 | 13 | 4.4 | 0.1 | 175.4 | 0.8 | 1000 | 0.76414 | 0.00057 | 4.4745
FASCIA | F/18(?) | +6.160 | +6.363 | 13 | 0.8 | 0 | 176.4 | 0.2 | 200 | 0.15374 | 0.000114 | 0.8949
FASCIA | F/18(?) | +6.266 | +6.469 | 13 | 1.7 | 0 | 175.8 | 0.3 | 400 | 0.30634 | 0.000228 | 1.7898
FASCIA | F/18(?) | +6.266 | +6.469 | 13 | 4.4 | 0.1 | 175.4 | 0.8 | 1000 | 0.76414 | 0.00057 | 4.4745
FASCIA | F/18(?) | +6.266 | +6.469 | 13 | 0.8 | 0 | 176.4 | 0.2 | 200 | 0.15374 | 0.000114 | 0.8949
FASCIA | F/18(?) | +6.109 | +6.312 | 13 | 1.7 | 0 | 175.8 | 0.3 | 400 | 0.30634 | 0.000228 | 1.7898
FASCIA | F/18(?) | +6.109 | +6.312 | 13 | 4.4 | 0.1 | 175.4 | 0.8 | 1000 | 0.76414 | 0.00057 | 4.4745
FASCIA | F/18(?) | +6.109 | +6.312 | 13 | 0.8 | 0 | 176.4 | 0.2 | 200 | 0.15374 | 0.000114 | 0.8949
FASCIA | F/18(?) | +7.436 | +7.639 | 13 | 1.7 | 0 | 175.8 | 0.3 | 400 | 0.30634 | 0.000228 | 1.7898
FASCIA | F/18(?) | +7.436 | +7.639 | 13 | 4.4 | 0.1 | 175.4 | 0.8 | 1000 | 0.76414 | 0.00057 | 4.4745
FASCIA | F/18(?) | +7.436 | +7.639 | 13 | 0.8 | 0 | 176.4 | 0.2 | 200 | 0.15374 | 0.000114 | 0.8949
FASCIA | F/18(?) | +7.464 | +7.667 | 13 | 1.7 | 0 | 175.8 | 0.3 | 400 | 0.30634 | 0.000228 | 1.7898
FASCIA | F/18(?) | +7.464 | +7.667 | 13 | 4.4 | 0.1 | 175.4 | 0.8 | 1000 | 0.76414 | 0.00057 | 4.4745
FASCIA | F/18(?) | +7.464 | +7.667 | 13 | 0.8 | 0 | 176.4 | 0.2 | 200 | 0.15374 | 0.000114 | 0.8949
FASCIA | F/18(?) | +7.478 | +7.681 | 13 | 1.7 | 0 | 175.8 | 0.3 | 400 | 0.30634 | 0.000228 | 1.7898
FASCIA | F/18(?) | +7.478 | +7.681 | 13 | 4.4 | 0.1 | 175.4 | 0.8 | 1000 | 0.76414 | 0.00057 | 4.4745
FASCIA | F/18(?) | +7.478 | +7.681 | 13 | 0.8 | 0 | 176.4 | 0.2 | 200 | 0.15374 | 0.000114 | 0.8949
FASCIA | F/18(?) | +5.852 | +6.055 | 13 | 1.7 | 0 | 175.8 | 0.3 | 400 | 0.30634 | 0.000228 | 1.7898
FASCIA | F/18(?) | +5.852 | +6.055 | 13 | 4.4 | 0.1 | 175.4 | 0.8 | 1000 | 0.76414 | 0.00057 | 4.4745
FASCIA | F/18(?) | +5.852 | +6.055 | 13 | 0.8 | 0 | 176.4 | 0.2 | 200 | 0.15374 | 0.000114 | 0.8949
FASCIA | F/18(?) | +4.618 | +4.821 | 13 | 1.7 | 0 | 175.8 | 0.3 | 400 | 0.30634 | 0.000228 | 1.7898
FASCIA | F/18(?) | +4.618 | +4.821 | 13 | 4.4 | 0.1 | 175.4 | 0.8 | 1000 | 0.76414 | 0.00057 | 4.4745
FASCIA | F/18(?) | +4.618 | +4.821 | 13 | 0.8 | 0 | 176.4 | 0.2 | 200 | 0.15374 | 0.000114 | 0.8949
FASCIA | F/18(?) | +4.620 | +4.823 | 13 | 1.7 | 0 | 175.8 | 0.3 | 400 | 0.30634 | 0.000228 | 1.7898
FASCIA | F/18(?) | +4.620 | +4.823 | 13 | 4.4 | 0.1 | 175.4 | 0.8 | 1000 | 0.76414 | 0.00057 | 4.4745
FASCIA | F/18(?) | +4.620 | +4.823 | 13 | 0.8 | 0 | 176.4 | 0.2 | 200 | 0.15374 | 0.000114 | 0.8949
FASCIA | F/18(?) | +4.726 | +4.929 | 13 | 1.7 | 0 | 175.8 | 0.3 | 400 | 0.30634 | 0.000228 | 1.7898
FASCIA | F/18(?) | +4.726 | +4.929 | 13 | 4.4 | 0.1 | 175.4 | 0.8 | 1000 | 0.76414 | 0.00057 | 4.4745
FASCIA | F/18(?) | +4.726 | +4.929 | 13 | 0.8 | 0 | 176.4 | 0.2 | 200 | 0.15374 | 0.000114 | 0.8949
FASCIA | F/18(?) | +4.567 | +4.770 | 13 | 1.7 | 0 | 175.8 | 0.3 | 400 | 0.30634 | 0.000228 | 1.7898
FASCIA | F/18(?) | +4.567 | +4.770 | 13 | 4.4 | 0.1 | 175.4 | 0.8 | 1000 | 0.76414 | 0.00057 | 4.4745
FASCIA | F/18(?) | +4.567 | +4.770 | 13 | 0.8 | 0 | 176.4 | 0.2 | 200 | 0.15374 | 0.000114 | 0.8949
FASCIA | F/18(?) | +5.880 | +6.083 | 13 | 1.7 | 0 | 175.8 | 0.3 | 400 | 0.30634 | 0.000228 | 1.7898
FASCIA | F/18(?) | +5.880 | +6.083 | 13 | 4.4 | 0.1 | 175.4 | 0.8 | 1000 | 0.76414 | 0.00057 | 4.4745
FASCIA | F/18(?) | +5.880 | +6.083 | 13 | 0.8 | 0 | 176.4 | 0.2 | 200 | 0.15374 | 0.000114 | 0.8949
FASCIA | F/18(?) | +5.895 | +6.098 | 13 | 1.7 | 0 | 175.8 | 0.3 | 400 | 0.30634 | 0.000228 | 1.7898
FASCIA | F/18(?) | +5.895 | +6.098 | 13 | 4.4 | 0.1 | 175.4 | 0.8 | 1000 | 0.76414 | 0.00057 | 4.4745
FASCIA | F/18(?) | +5.895 | +6.098 | 13 | 0.8 | 0 | 176.4 | 0.2 | 200 | 0.15374 | 0.000114 | 0.8949
2 x TH | B/5(?) | +6.903 | +7.119 | 4 | 4.4 | 0 | 175.4 | 0.8 | 1000 | 0.76414 | 0.00057 | 4.4745
2 x TH | B/5(?) | +6.403 | +6.619 | 4 | 4.4 | 0 | 175.4 | 0.8 | 1000 | 0.76414 | 0.00057 | 4.4745
2 x TH | B/5(?) | +7.573 | +7.780 | 4 | 4.4 | 0 | 175.4 | 0.8 | 1000 | 0.76414 | 0.00057 | 4.4745
2 x TH | B/5(?) | +7.073 | +7.280 | 4 | 4.4 | 0 | 175.4 | 0.8 | 1000 | 0.76414 | 0.00057 | 4.4745
2 x TH | B/5(?) | +7.628 | +7.837 | 4 | 4.4 | 0 | 175.4 | 0.8 | 1000 | 0.76414 | 0.00057 | 4.4745
2 x TH | B/5(?) | +7.128 | +7.337 | 4 | 4.4 | 0 | 175.4 | 0.8 | 1000 | 0.76414 | 0.00057 | 4.4745
2 x TH | B/5(?) | +7.707 | +7.919 | 4 | 4.4 | 0 | 175.4 | 0.8 | 1000 | 0.76414 | 0.00057 | 4.4745
2 x TH | B/5(?) | +7.207 | +7.419 | 4 | 4.4 | 0 | 175.4 | 0.8 | 1000 | 0.76414 | 0.00057 | 4.4745
2 x TH | B/5(?) | +6.707 | +6.919 | 4 | 4.4 | 0 | 175.4 | 0.8 | 1000 | 0.76414 | 0.00057 | 4.4745
2 x TH | B/5(?) | +6.628 | +6.837 | 4 | 4.4 | 0 | 175.4 | 0.8 | 1000 | 0.76414 | 0.00057 | 4.4745
2 x TH | B/5(?) | +6.573 | +6.780 | 4 | 4.4 | 0 | 175.4 | 0.8 | 1000 | 0.76414 | 0.00057 | 4.4745
2 x TH | B/5(?) | +5.903 | +6.119 | 4 | 4.4 | 0 | 175.4 | 0.8 | 1000 | 0.76414 | 0.00057 | 4.4745
2 x TH | B/5(?) | +6.885 | +7.102 | 4 | 4.4 | 0 | 175.4 | 0.8 | 1000 | 0.76414 | 0.00057 | 4.4745
2 x TH | B/5(?) | +6.385 | +6.602 | 4 | 4.4 | 0 | 175.4 | 0.8 | 1000 | 0.76414 | 0.00057 | 4.4745
2 x TH | B/5(?) | +5.885 | +6.102 | 4 | 4.4 | 0 | 175.4 | 0.8 | 1000 | 0.76414 | 0.00057 | 4.4745
2 x TH | B/5(?) | +6.781 | +6.997 | 4 | 4.4 | 0 | 175.4 | 0.8 | 1000 | 0.76414 | 0.00057 | 4.4745
2 x TH | B/5(?) | +6.281 | +6.497 | 4 | 4.4 | 0 | 175.4 | 0.8 | 1000 | 0.76414 | 0.00057 | 4.4745
2 x TH | B/5(?) | +5.781 | +5.997 | 4 | 4.4 | 0 | 175.4 | 0.8 | 1000 | 0.76414 | 0.00057 | 4.4745
2 x TH | B/5(?) | +6.746 | +6.960 | 4 | 4.4 | 0 | 175.4 | 0.8 | 1000 | 0.76414 | 0.00057 | 4.4745
2 x TH | B/5(?) | +6.246 | +6.460 | 4 | 4.4 | 0 | 175.4 | 0.8 | 1000 | 0.76414 | 0.00057 | 4.4745
2 x TH | B/5(?) | +5.746 | +5.960 | 4 | 4.4 | 0 | 175.4 | 0.8 | 1000 | 0.76414 | 0.00057 | 4.4745

# IfcBeam: TH:120-120 (42)
In: Undefined
Description: TH:120-120; Material: STEEL/300PLUS
Default - ASSEMBLY_POS: B/5(?)
Pset_BeamCommon - LoadBearing: no; Reference: B/5(?)
Tekla Common - Phase: 1; Class: 4
Tekla Quantity - Weight: 1.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 0 m2; Net surface area: 0.6 m2; Height: 120 mm; Width: 165 mm; Length: 1000 mm
BaseQuantities - Length: 1000 mm; OuterSurfaceArea: 4.5602e-07 m2; NetVolume: 0.000420979 m3; NetWeight: 3.30468 kg
Name | Bottom elevation | Top elevation
2 x TH | +6.223 | +6.358
2 x TH | +5.723 | +5.858
2 x TH | +5.485 | +5.638
2 x TH | +4.985 | +5.138
2 x TH | +6.074 | +6.200
2 x TH | +5.574 | +5.700
2 x TH | +6.124 | +6.253
2 x TH | +5.624 | +5.753
2 x TH | +5.223 | +5.358
2 x TH | +5.124 | +5.253
2 x TH | +5.074 | +5.200
2 x TH | +4.485 | +4.638
2 x TH | +5.435 | +5.581
2 x TH | +4.935 | +5.081
2 x TH | +4.435 | +4.581
2 x TH | +5.380 | +5.523
2 x TH | +4.880 | +5.023
2 x TH | +4.380 | +4.523
2 x TH | +5.236 | +5.376
2 x TH | +4.736 | +4.876
2 x TH | +4.236 | +4.376

# IfcBeam: TH:64-95 (42)
In: Undefined
Description: TH:64-95; Material: STEEL/300PLUS
Default - ASSEMBLY_POS: B/5(?)
Pset_BeamCommon - LoadBearing: no; Reference: B/5(?)
Tekla Common - Phase: 1; Class: 4
Tekla Quantity - Weight: 1.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 0 m2; Net surface area: 0.3 m2; Height: 64 mm; Width: 130 mm; Length: 1000 mm
BaseQuantities - Length: 1000 mm; OuterSurfaceArea: 4.5602e-07 m2; NetVolume: 0.000215558 m3; NetWeight: 1.69213 kg
Name | Bottom elevation | Top elevation
2 x TH | +6.257 | +6.333
2 x TH | +5.757 | +5.833
2 x TH | +5.577 | +5.670
2 x TH | +5.077 | +5.170
2 x TH | +6.086 | +6.154
2 x TH | +5.586 | +5.654
2 x TH | +6.143 | +6.214
2 x TH | +5.643 | +5.714
2 x TH | +5.257 | +5.333
2 x TH | +5.143 | +5.214
2 x TH | +5.086 | +5.154
2 x TH | +4.577 | +4.670
2 x TH | +5.502 | +5.588
2 x TH | +5.002 | +5.088
2 x TH | +5.424 | +5.507
2 x TH | +4.924 | +5.007
2 x TH | +5.344 | +5.424
2 x TH | +4.844 | +4.924
2 x TH | +4.502 | +4.588
2 x TH | +4.424 | +4.507
2 x TH | +4.344 | +4.424

# IfcBeam: TH:75-95 (6)
In: Undefined
Description: TH:75-95; Material: STEEL/300PLUS
Default - ASSEMBLY_POS: B/5(?)
Pset_BeamCommon - LoadBearing: no; Reference: B/5(?)
Tekla Common - Phase: 1; Class: 4
Tekla Quantity - Weight: 1.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 0 m2; Net surface area: 0.5 m2; Height: 75 mm; Width: 125 mm; Length: 1000 mm
BaseQuantities - Length: 1000 mm; OuterSurfaceArea: 4.5602e-07 m2; NetVolume: 0.000231901 m3; NetWeight: 1.82042 kg
Name | Bottom elevation | Top elevation
2 x TH | +5.317 | +5.407
2 x TH | +4.817 | +4.907
2 x TH | +4.317 | +4.407

# IfcBeam: TH:96-95 (6)
In: Undefined
Description: TH:96-95; Material: STEEL/300PLUS
Default - ASSEMBLY_POS: B/5(?)
Pset_BeamCommon - LoadBearing: no; Reference: B/5(?)
Tekla Common - Phase: 1; Class: 4
Tekla Quantity - Weight: 1.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 0 m2; Net surface area: 0.6 m2; Height: 96 mm; Width: 150 mm; Length: 1000 mm
BaseQuantities - Length: 1000 mm; OuterSurfaceArea: 4.5602e-07 m2; NetVolume: 0.000287172 m3; NetWeight: 2.2543 kg
Name | Bottom elevation | Top elevation
2 x TH | +5.284 | +5.397
2 x TH | +4.784 | +4.897
2 x TH | +4.284 | +4.397

# IfcColumn: C:150-24 (14)
In: Undefined
Description: C:150-24; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Phase: 1; Class: 12
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 111.2 m2; Height: 152 mm; Width: 64 mm
Pset_ColumnCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Finish | Top elevation | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
COLUMN | Z/1687 | 12 deg | +5.545 | 30.9 | 3.4 | 5544.9 | 5544.86 | 3.43707 | 0.00409077 | 32.1126
COLUMN | Z/1703 | 9 deg | +6.113 | 34.1 | 3.8 | 6112.9 | 6112.89 | 3.78902 | 0.00450985 | 35.4023
COLUMN | Z/1700 | 5 deg | +5.547 | 30.9 | 3.4 | 5547 | 5547.03 | 3.43842 | 0.00409238 | 32.1252
COLUMN | Z/1697 | 3 deg | +5.267 | 29.4 | 3.3 | 5266.8 | 5266.85 | 3.26481 | 0.00388567 | 30.5025
COLUMN | Z/1858 | 25 deg | +7.543 | 42 | 4.7 | 7543.3 | 7543.26 | 4.67528 | 0.00556512 | 43.6862
COLUMN | Z/1842 | 18 deg | +6.431 | 35.8 | 4 | 6430.8 | 6430.8 | 3.986 | 0.00474438 | 37.2434
COLUMN | Z/1830 | 15 deg | +5.982 | 33.3 | 3.7 | 5981.8 | 5981.82 | 3.70781 | 0.00441315 | 34.6432
COLUMN | Z/1701 | 9 deg | +4.846 | 27 | 3 | 4845.8 | 4845.81 | 3.00394 | 0.00357505 | 28.0641
COLUMN | Z/1698 | 5 deg | +4.847 | 27 | 3 | 4847.1 | 4847.12 | 3.00475 | 0.00357601 | 28.0717
COLUMN | Z/1695 | 3 deg | +4.848 | 27 | 3 | 4847.6 | 4847.59 | 3.00504 | 0.00357636 | 28.0744
COLUMN | Z/1693 | 25 deg | +3.813 | 21.3 | 2.4 | 3812.8 | 3812.81 | 2.36389 | 0.00281294 | 22.0815
COLUMN | Z/1691 | 18 deg | +3.831 | 21.4 | 2.4 | 3830.7 | 3830.73 | 2.37499 | 0.00282616 | 22.1853
COLUMN | Z/1688 | 15 deg | +3.838 | 21.4 | 2.4 | 3838.2 | 3838.23 | 2.37964 | 0.00283169 | 22.2288
COLUMN | Z/1672 | 12 deg | +3.844 | 21.4 | 2.4 | 3844.4 | 3844.4 | 2.38347 | 0.00283625 | 22.2645

# IfcElementAssembly (490)
In: Undefined
PredefinedType: RIGID_FRAME
Name | ASSEMBLY_POSITION_CODE = Assembly/Cast unit position code | ASSEMBLY_POS = Assembly/Cast unit Mark | Assembly/Cast unit weight (kg) | Assembly/Cast unit bottom elevation | Assembly/Cast unit top elevation | Width (mm)
ADJUSTABLE FASCIA BRA | C150SD/3> | PL/701(?) | 0.8 | +7.805 | +8.122 | 153
FASCIA | C150SD-C200SD/3> | F/18(?) | 2.5 | +8.039 | +8.141 | 51
FASCIA | C150SD/3> | F/18(?) | 0.5 | +8.039 | +8.141 | 51
FASCIA | C150SD-C200SD/3> | F/18(?) | 1 | +8.039 | +8.141 | 51
ADJUSTABLE FASCIA BRA | C150SD/3 | PL/701(?) | 0.8 | +5.175 | +5.492 | 153
FASCIA | C150SD-C200SD/3 | F/18(?) | 2.5 | +5.409 | +5.511 | 51
FASCIA | C150SD/3 | F/18(?) | 0.5 | +5.409 | +5.511 | 51
FASCIA | C150SD-C200SD/3 | F/18(?) | 1 | +5.409 | +5.511 | 51
RAFTER | C150SD/1-3 | Z/1696(?) | 49.2 | +4.830 | +5.444 | 64
RAFTER | C150SD/<1-3> | Z/1689(?) | 58.6 | +6.133 | +8.999 | 64
RAFTER | C150SD/1-3> | Z/1692(?) | 53.3 | +6.245 | +9.344 | 64
RAFTER | C150SD/<1-3> | Z/1694(?) | 55.7 | +3.601 | +7.962 | 64
RAFTER | C150SD/<1-3> | Z/1694(?) | 55.7 | +6.101 | +10.462 | 64
RAFTER | C150SD/1-3 | Z/1696(?) | 49.2 | +5.330 | +5.944 | 64
RAFTER | C150SD/1-3 | Z/1696(?) | 49.2 | +5.830 | +6.444 | 64
RAFTER | C150SD/1-3 | Z/1696(?) | 49.2 | +6.330 | +6.944 | 64
RAFTER | C150SD/1-3 | Z/1696(?) | 49.2 | +7.330 | +7.944 | 64
RAFTER | C150SD/1-3 | Z/1699(?) | 49.3 | +5.319 | +6.241 | 64
RAFTER | C150SD/1-3 | Z/1699(?) | 49.3 | +5.819 | +6.741 | 64
RAFTER | C150SD/1-3 | Z/1699(?) | 49.3 | +6.319 | +7.241 | 64
RAFTER | C150SD/1-3 | Z/1699(?) | 49.3 | +7.319 | +8.241 | 64
RAFTER | C150SD/1-3 | Z/1702(?) | 49.6 | +4.797 | +6.340 | 64
RAFTER | C150SD/1-3 | Z/1702(?) | 49.6 | +5.297 | +6.840 | 64
RAFTER | C150SD/1-3 | Z/1702(?) | 49.6 | +5.797 | +7.340 | 64
RAFTER | C150SD/1-3 | Z/1702(?) | 49.6 | +6.297 | +7.840 | 64
RAFTER | C150SD/1-3 | Z/1702(?) | 49.6 | +6.797 | +8.340 | 64
RAFTER | C150SD/1-3 | Z/1702(?) | 49.6 | +7.297 | +8.840 | 64
RAFTER | C150SD/<1-3> | Z/1673(?) | 60.8 | +5.126 | +7.543 | 64
RAFTER | C150SD/<1-3> | Z/1673(?) | 60.8 | +5.626 | +8.043 | 64
RAFTER | C150SD/<1-3> | Z/1673(?) | 60.8 | +4.626 | +7.043 | 64
RAFTER | C150SD/<1-3> | Z/1673(?) | 60.8 | +4.126 | +6.543 | 64
RAFTER | C150SD/<1-3> | Z/1673(?) | 60.8 | +3.626 | +6.043 | 64
RAFTER | C150SD/<1-3> | Z/1673(?) | 60.8 | +6.126 | +8.543 | 64
FASCIA | C150SD-C200SD/<1 | F/18(?) | 4.4 | +6.157 | +6.360 | 76
ADJUSTABLE FASCIA BRA | C150SD/<1 | PL/701(?) | 0.8 | +6.059 | +6.309 | 153
FASCIA | C150SD/<1 | F/18(?) | 0.8 | +6.157 | +6.360 | 76
FASCIA | C150SD-C200SD/<1 | F/18(?) | 1.7 | +6.157 | +6.360 | 76
FASCIA | C150SD-C200SD/<1 | F/18(?) | 4.4 | +6.160 | +6.363 | 76
ADJUSTABLE FASCIA BRA | C150SD/<1 | PL/701(?) | 0.8 | +6.061 | +6.311 | 153
FASCIA | C150SD/<1 | F/18(?) | 0.8 | +6.160 | +6.363 | 76
FASCIA | C150SD-C200SD/<1 | F/18(?) | 1.7 | +6.160 | +6.363 | 76
FASCIA | C150SD-C200SD/1 | F/18(?) | 4.4 | +6.266 | +6.469 | 76
ADJUSTABLE FASCIA BRA | C150SD/1 | PL/701(?) | 0.8 | +6.167 | +6.417 | 153
FASCIA | C150SD/1 | F/18(?) | 0.8 | +6.266 | +6.469 | 76
FASCIA | C150SD-C200SD/1 | F/18(?) | 1.7 | +6.266 | +6.469 | 76
FASCIA | C150SD-C200SD/<1 | F/18(?) | 4.4 | +6.109 | +6.312 | 76
ADJUSTABLE FASCIA BRA | C150SD/<1 | PL/701(?) | 0.8 | +6.010 | +6.260 | 153
FASCIA | C150SD/<1 | F/18(?) | 0.8 | +6.109 | +6.312 | 76
FASCIA | C150SD-C200SD/<1 | F/18(?) | 1.7 | +6.109 | +6.312 | 76
FASCIA | C150SD-C200SD/1 | F/18(?) | 4.4 | +7.436 | +7.639 | 76
ADJUSTABLE FASCIA BRA | C150SD/1 | PL/701(?) | 0.8 | +7.338 | +7.588 | 153
FASCIA | C150SD/1 | F/18(?) | 0.8 | +7.436 | +7.639 | 76
FASCIA | C150SD-C200SD/1 | F/18(?) | 1.7 | +7.436 | +7.639 | 76
FASCIA | C150SD-C200SD/1 | F/18(?) | 4.4 | +7.464 | +7.667 | 76
ADJUSTABLE FASCIA BRA | C150SD/1 | PL/701(?) | 0.8 | +7.365 | +7.615 | 153
FASCIA | C150SD/1 | F/18(?) | 0.8 | +7.464 | +7.667 | 76
FASCIA | C150SD-C200SD/1 | F/18(?) | 1.7 | +7.464 | +7.667 | 76
FASCIA | C150SD-C200SD/1 | F/18(?) | 4.4 | +7.478 | +7.681 | 76
ADJUSTABLE FASCIA BRA | C150SD/1 | PL/701(?) | 0.8 | +7.379 | +7.629 | 153
FASCIA | C150SD/1 | F/18(?) | 0.8 | +7.478 | +7.681 | 76
FASCIA | C150SD-C200SD/1 | F/18(?) | 1.7 | +7.478 | +7.681 | 76
RAFTER | C150SD/<1-3> | Z/1689(?) | 58.6 | +4.633 | +7.499 | 64
RAFTER | C150SD/<1-3> | Z/1694(?) | 55.7 | +4.101 | +8.462 | 64
RAFTER | C150SD/1-3 | Z/1699(?) | 49.3 | +6.819 | +7.741 | 64
FASCIA | C150SD-C200SD/<1 | F/18(?) | 3.5 | +5.708 | +5.860 | 64
ADJUSTABLE FASCIA BRA | C150SD/<1 | PL/701(?) | 0.8 | +5.559 | +5.819 | 153
FASCIA | C150SD/<1 | F/18(?) | 0.8 | +5.708 | +5.860 | 64
FASCIA | C150SD-C200SD/<1 | F/18(?) | 1.4 | +5.708 | +5.860 | 64
FASCIA | C150SD-C200SD/<1 | F/18(?) | 3.5 | +5.711 | +5.863 | 64
ADJUSTABLE FASCIA BRA | C150SD/<1 | PL/701(?) | 0.8 | +5.562 | +5.822 | 153
FASCIA | C150SD/<1 | F/18(?) | 0.8 | +5.711 | +5.863 | 64
FASCIA | C150SD-C200SD/<1 | F/18(?) | 1.4 | +5.711 | +5.863 | 64
FASCIA | C150SD-C200SD/1 | F/18(?) | 3.5 | +5.817 | +5.969 | 64
ADJUSTABLE FASCIA BRA | C150SD/1 | PL/701(?) | 0.8 | +5.668 | +5.928 | 153
FASCIA | C150SD/1 | F/18(?) | 0.8 | +5.817 | +5.969 | 64
FASCIA | C150SD-C200SD/1 | F/18(?) | 1.4 | +5.817 | +5.969 | 64
FASCIA | C150SD-C200SD/<1 | F/18(?) | 3.5 | +5.660 | +5.812 | 64
ADJUSTABLE FASCIA BRA | C150SD/<1 | PL/701(?) | 0.8 | +5.511 | +5.771 | 153
FASCIA | C150SD/<1 | F/18(?) | 0.8 | +5.660 | +5.812 | 64
FASCIA | C150SD-C200SD/<1 | F/18(?) | 1.4 | +5.660 | +5.812 | 64
FASCIA | C150SD-C200SD/1 | F/18(?) | 3.5 | +6.913 | +7.065 | 64
ADJUSTABLE FASCIA BRA | C150SD/1 | PL/701(?) | 0.8 | +6.764 | +7.024 | 153
FASCIA | C150SD/1 | F/18(?) | 0.8 | +6.913 | +7.065 | 64
FASCIA | C150SD-C200SD/1 | F/18(?) | 1.4 | +6.913 | +7.065 | 64
FASCIA | C150SD-C200SD/1 | F/18(?) | 3.5 | +6.885 | +7.037 | 64
ADJUSTABLE FASCIA BRA | C150SD/1 | PL/701(?) | 0.8 | +6.736 | +6.996 | 153
FASCIA | C150SD/1 | F/18(?) | 0.8 | +6.885 | +7.037 | 64
FASCIA | C150SD-C200SD/1 | F/18(?) | 1.4 | +6.885 | +7.037 | 64
FASCIA | C150SD-C200SD/1 | F/18(?) | 3.5 | +7.029 | +7.181 | 64
ADJUSTABLE FASCIA BRA | C150SD/1 | PL/701(?) | 0.8 | +6.880 | +7.140 | 153
FASCIA | C150SD/1 | F/18(?) | 0.8 | +7.029 | +7.181 | 64
FASCIA | C150SD-C200SD/1 | F/18(?) | 1.4 | +7.029 | +7.181 | 64
RAFTER | C150SD/1-3 | Z/1696(?) | 49.2 | +6.830 | +7.444 | 64
RAFTER | C150SD/1-3> | Z/1692(?) | 53.3 | +5.745 | +8.844 | 64
RAFTER | C150SD/<1-3> | Z/1689(?) | 58.6 | +3.633 | +6.499 | 64
FASCIA | C150SD-C200SD/<1 | F/18(?) | 2.5 | +5.362 | +5.464 | 51
ADJUSTABLE FASCIA BRA | C150SD/<1 | PL/701(?) | 0.8 | +5.165 | +5.445 | 153
FASCIA | C150SD/<1 | F/18(?) | 0.5 | +5.362 | +5.464 | 51
FASCIA | C150SD-C200SD/<1 | F/18(?) | 1 | +5.362 | +5.464 | 51
FASCIA | C150SD-C200SD/<1 | F/18(?) | 2.5 | +5.261 | +5.363 | 51
ADJUSTABLE FASCIA BRA | C150SD/<1 | PL/701(?) | 0.8 | +5.064 | +5.344 | 153
FASCIA | C150SD/<1 | F/18(?) | 0.5 | +5.261 | +5.363 | 51
FASCIA | C150SD-C200SD/<1 | F/18(?) | 1 | +5.261 | +5.363 | 51
FASCIA | C150SD-C200SD/1 | F/18(?) | 2.5 | +5.367 | +5.469 | 51
ADJUSTABLE FASCIA BRA | C150SD/1 | PL/701(?) | 0.8 | +5.170 | +5.450 | 153
FASCIA | C150SD/1 | F/18(?) | 0.5 | +5.367 | +5.469 | 51
FASCIA | C150SD-C200SD/1 | F/18(?) | 1 | +5.367 | +5.469 | 51
FASCIA | C150SD-C200SD/<1 | F/18(?) | 2.5 | +5.210 | +5.312 | 51
ADJUSTABLE FASCIA BRA | C150SD/<1 | PL/701(?) | 0.8 | +5.013 | +5.293 | 153
FASCIA | C150SD/<1 | F/18(?) | 0.5 | +5.210 | +5.312 | 51
FASCIA | C150SD-C200SD/<1 | F/18(?) | 1 | +5.210 | +5.312 | 51
FASCIA | C150SD-C200SD/1 | F/18(?) | 2.5 | +6.537 | +6.639 | 51
ADJUSTABLE FASCIA BRA | C150SD/1 | PL/701(?) | 0.8 | +6.341 | +6.621 | 153
FASCIA | C150SD/1 | F/18(?) | 0.5 | +6.537 | +6.639 | 51
FASCIA | C150SD-C200SD/1 | F/18(?) | 1 | +6.537 | +6.639 | 51
FASCIA | C150SD-C200SD/1 | F/18(?) | 2.5 | +6.565 | +6.667 | 51
ADJUSTABLE FASCIA BRA | C150SD/1 | PL/701(?) | 0.8 | +6.368 | +6.648 | 153
FASCIA | C150SD/1 | F/18(?) | 0.5 | +6.565 | +6.667 | 51
FASCIA | C150SD-C200SD/1 | F/18(?) | 1 | +6.565 | +6.667 | 51
FASCIA | C150SD-C200SD/1 | F/18(?) | 2.5 | +6.579 | +6.681 | 51
ADJUSTABLE FASCIA BRA | C150SD/1 | PL/701(?) | 0.8 | +6.382 | +6.662 | 153
FASCIA | C150SD/1 | F/18(?) | 0.5 | +6.579 | +6.681 | 51
FASCIA | C150SD-C200SD/1 | F/18(?) | 1 | +6.579 | +6.681 | 51
RAFTER | C150SD/1-3> | Z/1692(?) | 53.3 | +4.745 | +7.844 | 64
ADJUSTABLE FASCIA BRA | C150SD/1 | PL/701(?) | 0.8 | +5.339 | +5.544 | 153
FASCIA | C150SD/1 | F/18(?) | 0.8 | +5.403 | +5.555 | 64
FASCIA | C150SD-C200SD/1 | F/18(?) | 4.4 | +5.852 | +6.055 | 76
ADJUSTABLE FASCIA BRA | C150SD/1 | PL/701(?) | 0.8 | +5.839 | +6.044 | 153
FASCIA | C150SD/1 | F/18(?) | 0.8 | +5.852 | +6.055 | 76
FASCIA | C150SD-C200SD/1 | F/18(?) | 1.7 | +5.852 | +6.055 | 76
FASCIA | C150SD-C200SD/<1 | F/18(?) | 4.4 | +4.618 | +4.821 | 76
ADJUSTABLE FASCIA BRA | C150SD/<1 | PL/701(?) | 0.8 | +4.605 | +4.810 | 153
FASCIA | C150SD/<1 | F/18(?) | 0.8 | +4.618 | +4.821 | 76
FASCIA | C150SD-C200SD/<1 | F/18(?) | 1.7 | +4.618 | +4.821 | 76
FASCIA | C150SD-C200SD/<1 | F/18(?) | 4.4 | +4.620 | +4.823 | 76
ADJUSTABLE FASCIA BRA | C150SD/<1 | PL/701(?) | 0.8 | +4.607 | +4.812 | 153
FASCIA | C150SD/<1 | F/18(?) | 0.8 | +4.620 | +4.823 | 76
FASCIA | C150SD-C200SD/<1 | F/18(?) | 1.7 | +4.620 | +4.823 | 76
FASCIA | C150SD-C200SD/1 | F/18(?) | 4.4 | +4.726 | +4.929 | 76
ADJUSTABLE FASCIA BRA | C150SD/1 | PL/701(?) | 0.8 | +4.712 | +4.917 | 153
FASCIA | C150SD/1 | F/18(?) | 0.8 | +4.726 | +4.929 | 76
FASCIA | C150SD-C200SD/1 | F/18(?) | 1.7 | +4.726 | +4.929 | 76
FASCIA | C150SD-C200SD/<1 | F/18(?) | 4.4 | +4.567 | +4.770 | 76
ADJUSTABLE FASCIA BRA | C150SD/<1 | PL/701(?) | 0.8 | +4.553 | +4.758 | 153
FASCIA | C150SD/<1 | F/18(?) | 0.8 | +4.567 | +4.770 | 76
FASCIA | C150SD-C200SD/<1 | F/18(?) | 1.7 | +4.567 | +4.770 | 76
FASCIA | C150SD-C200SD/1 | F/18(?) | 4.4 | +5.880 | +6.083 | 76
ADJUSTABLE FASCIA BRA | C150SD/1 | PL/701(?) | 0.8 | +5.867 | +6.072 | 153
FASCIA | C150SD/1 | F/18(?) | 0.8 | +5.880 | +6.083 | 76
FASCIA | C150SD-C200SD/1 | F/18(?) | 1.7 | +5.880 | +6.083 | 76
FASCIA | C150SD-C200SD/1 | F/18(?) | 4.4 | +5.895 | +6.098 | 76
ADJUSTABLE FASCIA BRA | C150SD/1 | PL/701(?) | 0.8 | +5.881 | +6.086 | 153
FASCIA | C150SD/1 | F/18(?) | 0.8 | +5.895 | +6.098 | 76
FASCIA | C150SD-C200SD/1 | F/18(?) | 1.7 | +5.895 | +6.098 | 76
ADJUSTABLE FASCIA BRA | C150SD/1 | PL/701(?) | 0.8 | +3.772 | +3.982 | 153
ADJUSTABLE FASCIA BRA | C150SD/<1 | PL/701(?) | 0.8 | +4.163 | +4.368 | 153
ADJUSTABLE FASCIA BRA | C150SD/<1 | PL/701(?) | 0.8 | +4.107 | +4.312 | 153
ADJUSTABLE FASCIA BRA | C150SD/1 | PL/701(?) | 0.8 | +4.213 | +4.418 | 153
ADJUSTABLE FASCIA BRA | C150SD/<1 | PL/701(?) | 0.8 | +4.054 | +4.259 | 153
ADJUSTABLE FASCIA BRA | C150SD/1 | PL/701(?) | 0.8 | +5.367 | +5.572 | 153
FASCIA | C150SD/1 | F/18(?) | 0.8 | +5.431 | +5.583 | 64
ADJUSTABLE FASCIA BRA | C150SD/1 | PL/701(?) | 0.8 | +5.382 | +5.587 | 153
FASCIA | C150SD/1 | F/18(?) | 0.8 | +5.446 | +5.598 | 64
FASCIA | C150SD/<1 | F/18(?) | 0.8 | +4.118 | +4.270 | 64
FASCIA | C150SD/1 | F/18(?) | 0.8 | +4.277 | +4.429 | 64
FASCIA | C150SD/<1 | F/18(?) | 0.8 | +4.171 | +4.323 | 64
RAFTER | C150SD/1-3> | Z/1692(?) | 53.3 | +4.245 | +7.344 | 64
RAFTER | C150SD/1-3 | Z/1699(?) | 49.3 | +4.819 | +5.741 | 64
RAFTER | C150SD/<1-3> | Z/1689(?) | 58.6 | +4.133 | +6.999 | 64
ADJUSTABLE FASCIA BRA | C150SD/1 | PL/701(?) | 0.8 | +4.839 | +5.049 | 153
ADJUSTABLE FASCIA BRA | C150SD/1 | PL/701(?) | 0.8 | +4.867 | +5.077 | 153
ADJUSTABLE FASCIA BRA | C150SD/<1 | PL/701(?) | 0.8 | +3.663 | +3.873 | 153
ADJUSTABLE FASCIA BRA | C150SD/<1 | PL/701(?) | 0.8 | +3.665 | +3.875 | 153
ADJUSTABLE FASCIA BRA | C150SD/<1 | PL/701(?) | 0.8 | +3.615 | +3.825 | 153
RAFTER | C150SD/1-3> | Z/1692(?) | 53.3 | +3.745 | +6.844 | 64
FASCIA | C150SD-C200SD/1 | F/18(?) | 2.5 | +4.953 | +5.055 | 51
FASCIA | C150SD/1 | F/18(?) | 0.5 | +4.953 | +5.055 | 51
FASCIA | C150SD-C200SD/1 | F/18(?) | 1 | +4.953 | +5.055 | 51
FASCIA | C150SD-C200SD/1 | F/18(?) | 2.5 | +4.981 | +5.083 | 51
FASCIA | C150SD/1 | F/18(?) | 0.5 | +4.981 | +5.083 | 51
FASCIA | C150SD-C200SD/1 | F/18(?) | 1 | +4.981 | +5.083 | 51
ADJUSTABLE FASCIA BRA | C150SD/1 | PL/701(?) | 0.8 | +4.882 | +5.092 | 153
FASCIA | C150SD-C200SD/1 | F/18(?) | 2.5 | +4.996 | +5.098 | 51
FASCIA | C150SD/1 | F/18(?) | 0.5 | +4.996 | +5.098 | 51
FASCIA | C150SD-C200SD/1 | F/18(?) | 1 | +4.996 | +5.098 | 51
FASCIA | C150SD-C200SD/<1 | F/18(?) | 2.5 | +3.729 | +3.831 | 51
FASCIA | C150SD/<1 | F/18(?) | 0.5 | +3.729 | +3.831 | 51
FASCIA | C150SD-C200SD/<1 | F/18(?) | 1 | +3.729 | +3.831 | 51
FASCIA | C150SD-C200SD/1 | F/18(?) | 2.5 | +3.886 | +3.988 | 51
FASCIA | C150SD/1 | F/18(?) | 0.5 | +3.886 | +3.988 | 51
FASCIA | C150SD-C200SD/1 | F/18(?) | 1 | +3.886 | +3.988 | 51
FASCIA | C150SD-C200SD/<1 | F/18(?) | 2.5 | +3.779 | +3.881 | 51
FASCIA | C150SD/<1 | F/18(?) | 0.5 | +3.779 | +3.881 | 51
FASCIA | C150SD-C200SD/<1 | F/18(?) | 1 | +3.779 | +3.881 | 51
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 4.4 | +6.903 | +7.119 | 76
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 2.5 | +7.120 | +7.234 | 51
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 4.4 | +6.403 | +6.619 | 76
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 2.5 | +6.620 | +6.734 | 51
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 4.4 | +7.573 | +7.780 | 76
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 2.5 | +7.600 | +7.704 | 51
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 4.4 | +7.073 | +7.280 | 76
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 2.5 | +7.100 | +7.204 | 51
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 4.4 | +7.628 | +7.837 | 76
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 2.5 | +7.673 | +7.779 | 51
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 4.4 | +7.128 | +7.337 | 76
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 2.5 | +7.173 | +7.279 | 51
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 4.4 | +7.707 | +7.919 | 76
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 2.5 | +7.787 | +7.896 | 51
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 4.4 | +7.207 | +7.419 | 76
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 2.5 | +7.287 | +7.396 | 51
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 4.4 | +6.707 | +6.919 | 76
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 2.5 | +6.787 | +6.896 | 51
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 4.4 | +6.628 | +6.837 | 76
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 2.5 | +6.673 | +6.779 | 51
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 4.4 | +6.573 | +6.780 | 76
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 2.5 | +6.600 | +6.704 | 51
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 4.4 | +5.903 | +6.119 | 76
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 2.5 | +6.120 | +6.234 | 51
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 1.7 | +6.223 | +6.358 | 165
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 1.7 | +6.257 | +6.333 | 130
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 1.7 | +5.723 | +5.858 | 165
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 1.7 | +5.757 | +5.833 | 130
RAFTER | C150SD-C200SD/<1-3> | Z/1694(?) | 55.7 | +6.101 | +10.462 | 64
RAFTER | C150SD-C200SD/<1-3> | Z/1694(?) | 55.7 | +5.601 | +9.962 | 64
RAFTER | C150SD/<1-3> | Z/1694(?) | 55.7 | +5.601 | +9.962 | 64
RAFTER | C150SD-C200SD/<1-3> | Z/1694(?) | 55.7 | +5.101 | +9.462 | 64
RAFTER | C150SD/<1-3> | Z/1694(?) | 55.7 | +5.101 | +9.462 | 64
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 1.7 | +5.485 | +5.638 | 165
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 1.7 | +5.577 | +5.670 | 130
RAFTER | C150SD-C200SD/<1-3> | Z/1694(?) | 55.7 | +4.601 | +8.962 | 64
RAFTER | C150SD/<1-3> | Z/1694(?) | 55.7 | +4.601 | +8.962 | 64
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 1.7 | +4.985 | +5.138 | 165
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 1.7 | +5.077 | +5.170 | 130
RAFTER | C150SD-C200SD/<1-3> | Z/1694(?) | 55.7 | +4.101 | +8.462 | 64
RAFTER | C150SD-C200SD/1-3 | Z/1696(?) | 49.2 | +7.330 | +7.944 | 64
RAFTER | C150SD-C200SD/1-3 | Z/1696(?) | 49.2 | +6.830 | +7.444 | 64
RAFTER | C150SD-C200SD/1-3 | Z/1696(?) | 49.2 | +6.330 | +6.944 | 64
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 1.7 | +6.074 | +6.200 | 165
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 1.7 | +6.086 | +6.154 | 130
RAFTER | C150SD-C200SD/1-3 | Z/1696(?) | 49.2 | +5.830 | +6.444 | 64
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 1.7 | +5.574 | +5.700 | 165
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 1.7 | +5.586 | +5.654 | 130
RAFTER | C150SD-C200SD/1-3 | Z/1696(?) | 49.2 | +5.330 | +5.944 | 64
RAFTER | C150SD-C200SD/1-3 | Z/1699(?) | 49.3 | +7.319 | +8.241 | 64
RAFTER | C150SD-C200SD/1-3 | Z/1699(?) | 49.3 | +6.819 | +7.741 | 64
RAFTER | C150SD-C200SD/1-3 | Z/1699(?) | 49.3 | +6.319 | +7.241 | 64
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 1.7 | +6.124 | +6.253 | 165
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 1.7 | +6.143 | +6.214 | 130
RAFTER | C150SD-C200SD/1-3 | Z/1699(?) | 49.3 | +5.819 | +6.741 | 64
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 1.7 | +5.624 | +5.753 | 165
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 1.7 | +5.643 | +5.714 | 130
RAFTER | C150SD-C200SD/1-3 | Z/1699(?) | 49.3 | +5.319 | +6.241 | 64
RAFTER | C150SD-C200SD/1-3 | Z/1702(?) | 49.6 | +7.297 | +8.840 | 64
RAFTER | C150SD-C200SD/1-3 | Z/1702(?) | 49.6 | +6.797 | +8.340 | 64
RAFTER | C150SD-C200SD/1-3 | Z/1702(?) | 49.6 | +6.297 | +7.840 | 64
RAFTER | C150SD-C200SD/1-3 | Z/1702(?) | 49.6 | +5.797 | +7.340 | 64
RAFTER | C150SD-C200SD/1-3 | Z/1702(?) | 49.6 | +5.297 | +6.840 | 64
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 1.7 | +5.223 | +5.358 | 165
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 1.7 | +5.257 | +5.333 | 130
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 1.7 | +5.124 | +5.253 | 165
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 1.7 | +5.143 | +5.214 | 130
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 1.7 | +5.074 | +5.200 | 165
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 1.7 | +5.086 | +5.154 | 130
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 1.7 | +4.485 | +4.638 | 165
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 1.7 | +4.577 | +4.670 | 130
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 4.4 | +6.885 | +7.102 | 76
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 2.5 | +7.043 | +7.156 | 51
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 4.4 | +6.385 | +6.602 | 76
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 2.5 | +6.543 | +6.656 | 51
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 4.4 | +5.885 | +6.102 | 76
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 2.5 | +6.043 | +6.156 | 51
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 1.7 | +5.435 | +5.581 | 165
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 1.7 | +5.502 | +5.588 | 130
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 1.7 | +4.935 | +5.081 | 165
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 1.7 | +5.002 | +5.088 | 130
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 1.7 | +4.435 | +4.581 | 165
RAFTER | C150SD-C200SD/1-3> | Z/1692(?) | 53.3 | +6.245 | +9.344 | 64
RAFTER | C150SD-C200SD/1-3> | Z/1692(?) | 53.3 | +5.745 | +8.844 | 64
RAFTER | C150SD-C200SD/1-3> | Z/1692(?) | 53.3 | +5.245 | +8.344 | 64
RAFTER | C150SD/1-3> | Z/1692(?) | 53.3 | +5.245 | +8.344 | 64
RAFTER | C150SD-C200SD/1-3> | Z/1692(?) | 53.3 | +4.745 | +7.844 | 64
RAFTER | C150SD-C200SD/1-3> | Z/1692(?) | 53.3 | +4.245 | +7.344 | 64
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 4.4 | +6.781 | +6.997 | 76
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 2.5 | +6.914 | +7.026 | 51
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 4.4 | +6.281 | +6.497 | 76
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 2.5 | +6.414 | +6.526 | 51
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 4.4 | +5.781 | +5.997 | 76
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 2.5 | +5.914 | +6.026 | 51
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 1.7 | +5.380 | +5.523 | 165
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 1.7 | +5.424 | +5.507 | 130
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 1.7 | +4.880 | +5.023 | 165
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 1.7 | +4.924 | +5.007 | 130
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 1.7 | +4.380 | +4.523 | 165
RAFTER | C150SD-C200SD/<1-3> | Z/1689(?) | 58.6 | +6.133 | +8.999 | 64
RAFTER | C150SD-C200SD/<1-3> | Z/1689(?) | 58.6 | +5.633 | +8.499 | 64
RAFTER | C150SD/<1-3> | Z/1689(?) | 58.6 | +5.633 | +8.499 | 64
RAFTER | C150SD-C200SD/<1-3> | Z/1689(?) | 58.6 | +5.133 | +7.999 | 64
RAFTER | C150SD/<1-3> | Z/1689(?) | 58.6 | +5.133 | +7.999 | 64
RAFTER | C150SD-C200SD/<1-3> | Z/1689(?) | 58.6 | +4.633 | +7.499 | 64
RAFTER | C150SD-C200SD/<1-3> | Z/1689(?) | 58.6 | +4.133 | +6.999 | 64
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 3.5 | +6.796 | +6.958 | 64
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 4.4 | +6.746 | +6.960 | 76
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 2.5 | +6.852 | +6.962 | 51
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 3.5 | +6.296 | +6.458 | 64
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 4.4 | +6.246 | +6.460 | 76
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 2.5 | +6.352 | +6.462 | 51
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 3.5 | +5.796 | +5.958 | 64
RAFTER | C150SD-C200SD/<1-3> | Z/1673(?) | 60.8 | +6.126 | +8.543 | 64
RAFTER | C150SD-C200SD/<1-3> | Z/1673(?) | 60.8 | +5.626 | +8.043 | 64
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 4.4 | +5.746 | +5.960 | 76
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 2.5 | +5.852 | +5.962 | 51
RAFTER | C150SD-C200SD/<1-3> | Z/1673(?) | 60.8 | +5.126 | +7.543 | 64
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 1.7 | +5.284 | +5.397 | 150
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 1.7 | +5.317 | +5.407 | 125
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 1.7 | +5.236 | +5.376 | 165
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 1.7 | +5.344 | +5.424 | 130
RAFTER | C150SD-C200SD/<1-3> | Z/1673(?) | 60.8 | +4.626 | +7.043 | 64
FASCIA | C150SD-C200SD/<1 | F/18(?) | 3.5 | +4.227 | +4.379 | 64
FASCIA | C150SD/<1 | F/18(?) | 0.8 | +4.227 | +4.379 | 64
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 1.7 | +4.784 | +4.897 | 150
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 1.7 | +4.817 | +4.907 | 125
FASCIA | C150SD-C200SD/<1 | F/18(?) | 1.4 | +4.227 | +4.379 | 64
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 1.7 | +4.736 | +4.876 | 165
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 1.7 | +4.844 | +4.924 | 130
RAFTER | C150SD-C200SD/<1-3> | Z/1673(?) | 60.8 | +4.126 | +6.543 | 64
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 1.7 | +4.284 | +4.397 | 150
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 1.7 | +4.317 | +4.407 | 125
FASCIA | C150SD-C200SD/<1 | F/18(?) | 2.5 | +3.777 | +3.879 | 51
FASCIA | C150SD/<1 | F/18(?) | 0.5 | +3.777 | +3.879 | 51
FASCIA | C150SD-C200SD/<1 | F/18(?) | 1 | +3.777 | +3.879 | 51
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 1.7 | +4.236 | +4.376 | 165
COLUMN | C150SD-C200SD/3 | Z/1858 | 42 | +0.000 | +7.543 | 64
RAFTER | C150SD-C200SD/<1-3> | Z/1694 | 55.7 | +3.601 | +7.962 | 64
COLUMN | C150SD-C200SD/1 | Z/1693 | 21.3 | +0.000 | +3.813 | 64
PLATE | C150SD-C200SD/3 | PL/1265 | 3.1 | +7.327 | +7.782 | 67
PLATE | C150SD-C200SD/1 | PL/1264 | 3.9 | +3.599 | +4.137 | 67
COLUMN | C150SD-C200SD/3 | Z/1842 | 35.8 | +0.000 | +6.431 | 64
RAFTER | C150SD-C200SD/1-3> | Z/1692 | 53.3 | +3.745 | +6.844 | 64
COLUMN | C150SD-C200SD/1 | Z/1691 | 21.4 | +0.000 | +3.831 | 64
PLATE | C150SD-C200SD/3 | PL/1269 | 3.1 | +6.214 | +6.640 | 66.5
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 1.7 | +4.502 | +4.588 | 130
PLATE | C150SD-C200SD/1 | PL/1263 | 3.7 | +3.616 | +4.106 | 67
COLUMN | C150SD-C200SD/3 | Z/1830 | 33.3 | +0.000 | +5.982 | 64
RAFTER | C150SD-C200SD/<1-3> | Z/1689 | 58.6 | +3.633 | +6.499 | 64
COLUMN | C150SD-C200SD/1 | Z/1688 | 21.4 | +0.000 | +3.838 | 64
PLATE | C150SD-C200SD/3 | PL/1268 | 3.1 | +5.765 | +6.180 | 66.5
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 1.7 | +4.424 | +4.507 | 130
PLATE | C150SD-C200SD/1 | PL/1262 | 3.6 | +3.623 | +4.091 | 67
COLUMN | C150SD-C200SD/3 | Z/1687 | 30.9 | +0.000 | +5.545 | 64
RAFTER | C150SD-C200SD/<1-3> | Z/1673 | 60.8 | +3.626 | +6.043 | 64
COLUMN | C150SD-C200SD/1 | Z/1672 | 21.4 | +0.000 | +3.844 | 64
PLATE | C150SD-C200SD/3 | PL/1261 | 3.1 | +5.329 | +5.733 | 67
2 x TH | C150SD-C200SD/1-2 | B/5(?) | 1.7 | +4.344 | +4.424 | 130
PLATE | C150SD-C200SD/1 | PL/1260 | 3.5 | +3.629 | +4.077 | 67
COLUMN | C150SD-C200SD/3 | Z/1703 | 34.1 | +0.000 | +6.113 | 64
RAFTER | C150SD-C200SD/1-3 | Z/1702 | 49.6 | +4.797 | +6.340 | 64
COLUMN | C150SD-C200SD/1 | Z/1701 | 27 | +0.000 | +4.846 | 64
PLATE | C150SD-C200SD/3 | PL/1272 | 3.1 | +5.897 | +6.291 | 67
PLATE | C150SD-C200SD/1 | PL/1267 | 3.5 | +4.631 | +5.058 | 67
RAFTER | C150SD-C200SD/1-3 | Z/1699 | 49.3 | +4.819 | +5.741 | 64
COLUMN | C150SD-C200SD/3 | Z/1700 | 30.9 | +0.000 | +5.547 | 64
COLUMN | C150SD-C200SD/1 | Z/1698 | 27 | +0.000 | +4.847 | 64
PLATE | C150SD-C200SD/3 | PL/1271 | 3.1 | +5.331 | +5.713 | 67
PLATE | C150SD-C200SD/1 | PL/1266 | 3.3 | +4.632 | +5.032 | 67
RAFTER | C150SD-C200SD/1-3 | Z/1696 | 49.2 | +4.830 | +5.444 | 64
COLUMN | C150SD-C200SD/3 | Z/1697 | 29.4 | +0.000 | +5.267 | 64
COLUMN | C150SD-C200SD/1 | Z/1695 | 27 | +0.000 | +4.848 | 64
PLATE | C150SD-C200SD/3 | PL/1273 | 3.1 | +5.051 | +5.427 | 67
PLATE | C150SD-C200SD/1 | PL/1270 | 3.2 | +4.632 | +5.019 | 67
COLUMN | C150SD/3 | Z/1858 | 42 | +0.000 | +7.543 | 64
PLATE | C150SD/3 | PL/1257 | 3.1 | +7.327 | +7.782 | 67
COLUMN | C150SD/3 | Z/1842 | 35.8 | +0.000 | +6.431 | 64
PLATE | C150SD/3 | PL/1251 | 3.1 | +6.214 | +6.640 | 66.5
COLUMN | C150SD/3 | Z/1830 | 33.3 | +0.000 | +5.982 | 64
PLATE | C150SD/3 | PL/1250 | 3.1 | +5.765 | +6.180 | 66.5
COLUMN | C150SD/3 | Z/1687 | 30.9 | +0.000 | +5.545 | 64
PLATE | C150SD/3 | PL/1253 | 3.1 | +5.329 | +5.733 | 67
COLUMN | C150SD/3 | Z/1697 | 29.4 | +0.000 | +5.267 | 64
COLUMN | C150SD/3 | Z/1703 | 34.1 | +0.000 | +6.113 | 64
COLUMN | C150SD/3 | Z/1700 | 30.9 | +0.000 | +5.547 | 64
COLUMN | C150SD/1 | Z/1701 | 27 | +0.000 | +4.846 | 64
COLUMN | C150SD/1 | Z/1698 | 27 | +0.000 | +4.847 | 64
COLUMN | C150SD/1 | Z/1695 | 27 | +0.000 | +4.848 | 64
PLATE | C150SD/3 | PL/1246 | 3.1 | +5.051 | +5.427 | 67
PLATE | C150SD/3 | PL/1249 | 3.1 | +5.897 | +6.291 | 67
PLATE | C150SD/3 | PL/1248 | 3.1 | +5.331 | +5.713 | 67
PLATE | C150SD/1 | PL/1259 | 3.5 | +4.631 | +5.058 | 67
PLATE | C150SD/1 | PL/1258 | 3.3 | +4.632 | +5.032 | 67
PLATE | C150SD/1 | PL/1247 | 3.2 | +4.632 | +5.019 | 67
COLUMN | C150SD/1 | Z/1693 | 21.3 | +0.000 | +3.813 | 64
COLUMN | C150SD/1 | Z/1691 | 21.4 | +0.000 | +3.831 | 64
COLUMN | C150SD/1 | Z/1688 | 21.4 | +0.000 | +3.838 | 64
COLUMN | C150SD/1 | Z/1672 | 21.4 | +0.000 | +3.844 | 64
PLATE | C150SD/1 | PL/1256 | 3.9 | +3.599 | +4.137 | 67
PLATE | C150SD/1 | PL/1255 | 3.7 | +3.616 | +4.106 | 67
PLATE | C150SD/1 | PL/1254 | 3.6 | +3.623 | +4.091 | 67
PLATE | C150SD/1 | PL/1252 | 3.5 | +3.629 | +4.077 | 67

# IfcMechanicalFastener: Bolt assembly (394)
In: Undefined
NominalDiameter: 12 mm
Tekla Bolt - Washer diameter: 12 mm; Slotted hole y: 0 mm; Location: Site
Name | NominalLength (mm) = Bolt length (mm) | Material = Bolt standard | Washer count = Nut count | Washer type | Washer name | Nut type | Nut name | Slotted hole x (mm) | Bolt hole diameter (mm) | Bolt count | Bolt size (mm) | Bolt Name
2 x Bolt assembly | 8 | PB1230 | 0 | FLAT | WASHERM12-FLAT | 4.6-HEX | NUTM12-4.6-HEX | 182 | 18 | 1 | 18 | BOLTPB1230
44 x Bolt assembly | 8 | 8.8S | 0 | HARD | WASHERM12-HARD | 8.8-HEX | NUTM12-8.8-HEX | 97 | 18 | 1 | 18 | BOLTM12*16
82 x Bolt assembly | 30 | FB1230Z | 1 | FLAT | WASHERM12-FLAT | 4.6-HEX | NUTM12-4.6-HEX | 0 | 14 | 1 | 12 | BOLTFB1230
168 x Bolt assembly | 30 | PB1230 | 1 | FLAT | WASHERM12-FLAT | 4.6-HEX | NUTM12-4.6-HEX | 0 | 18 | 1 | 12 | BOLTPB1230
7 x Bolt assembly | 8 | PB1230 | 0 | FLAT | WASHERM12-FLAT | 4.6-HEX | NUTM12-4.6-HEX | 212 | 18 | 1 | 18 | BOLTPB1230
7 x Bolt assembly | 8 | PB1230 | 0 | FLAT | WASHERM12-FLAT | 4.6-HEX | NUTM12-4.6-HEX | 222 | 18 | 1 | 18 | BOLTPB1230
7 x Bolt assembly | 8 | PB1230 | 0 | FLAT | WASHERM12-FLAT | 4.6-HEX | NUTM12-4.6-HEX | 242 | 18 | 1 | 18 | BOLTPB1230
14 x Bolt assembly | 8 | PB1230 | 0 | FLAT | WASHERM12-FLAT | 4.6-HEX | NUTM12-4.6-HEX | 167 | 18 | 1 | 18 | BOLTPB1230
7 x Bolt assembly | 8 | PB1230 | 0 | FLAT | WASHERM12-FLAT | 4.6-HEX | NUTM12-4.6-HEX | 172 | 18 | 1 | 18 | BOLTPB1230
56 x Bolt assembly | 30 | 8.8S | 6 | HARD | WASHERM12-HARD | 8.8-HEX | NUTM12-8.8-HEX | 0 | 14 | 6 | 12 | BOLTM12*30

# IfcMember: C:150-24 (12)
In: Undefined
Description: C:150-24; Material: STEEL/G450
Tekla Common - Finish: 25 deg; Phase: 1; Class: 10
Tekla Quantity - Weight: 55.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 111.2 m2; Net surface area: 6.2 m2; Height: 152 mm; Width: 64 mm; Length: 9992.2 mm
Pset_MemberCommon - LoadBearing: no
BaseQuantities - Length: 9992.22 mm; OuterSurfaceArea: 6.19266 m2; GrossSurfaceArea: 0 m2; CrossSectionArea: 0.00071 m2; NetVolume: 0.00737186 m3; GrossVolume: 0.00709448 m3; NetWeight: 57.8691 kg; GrossWeight: 55.6917 kg
Name | Bottom elevation | Top elevation | Reference
2 x RAFTER | +6.101 | +10.462 | Z/1694(?)
2 x RAFTER | +5.601 | +9.962 | Z/1694(?)
2 x RAFTER | +5.101 | +9.462 | Z/1694(?)
2 x RAFTER | +4.601 | +8.962 | Z/1694(?)
2 x RAFTER | +4.101 | +8.462 | Z/1694(?)
RAFTER | +3.601 | +7.962 | Z/1694
RAFTER | +3.601 | +7.962 | Z/1694(?)

# IfcPlate: PLT3*205 (14)
In: Undefined
Description: PLT3*205; Material: STEEL/250
Default - ASSEMBLY_POS: PL/701(?)
Pset_PlateCommon - LoadBearing: no; Reference: PL/701(?)
Tekla Common - Phase: 1; Class: 2
Tekla Quantity - Weight: 0.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 89.2 m2; Net surface area: 0.1 m2; Height: 205 mm; Width: 3 mm; Length: 351.2 mm
