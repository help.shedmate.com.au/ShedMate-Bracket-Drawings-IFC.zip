Properties of the parts of a building model (IFC2X3), part 4 of 4

# IfcPlate: PLT6*145 (132)
Description: PLT6*145; Material: STEEL/250
Tekla Common - Phase: 1; Class: 9
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.1 m2; Height: 145 mm; Width: 6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 145 mm; CrossSectionArea: 0.000036 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
2 x BRIDGING BRACKET | PL/218(?) | +3.333 | +3.603 | 1.8 | 45.2 | 270 | 0.08328 | 0.03915 | 0.0002349
2 x BRIDGING BRACKET | PL/218(?) | +3.353 | +3.623 | 1.8 | 45.2 | 270 | 0.08328 | 0.03915 | 0.0002349
2 x BRIDGING BRACKET | PL/218(?) | +3.371 | +3.641 | 1.8 | 45.2 | 270 | 0.08328 | 0.03915 | 0.0002349
4 x BRIDGING BRACKET | PL/218 | +3.380 | +3.650 | 1.8 | 45.2 | 270 | 0.08328 | 0.03915 | 0.0002349
2 x BRIDGING BRACKET | PL/218 | +3.383 | +3.653 | 1.8 | 45.2 | 270 | 0.08328 | 0.03915 | 0.0002349
2 x BRIDGING BRACKET | PL/218 | +3.367 | +3.637 | 1.8 | 45.2 | 270 | 0.08328 | 0.03915 | 0.0002349
2 x BRIDGING BRACKET | PL/1998 | +3.330 | +3.650 | 2.2 | 45 | 320 | 0.09838 | 0.0464 | 0.0002784
2 x BRIDGING BRACKET | PL/1998 | +3.353 | +3.673 | 2.2 | 45 | 320 | 0.09838 | 0.0464 | 0.0002784
2 x BRIDGING BRACKET | PL/1998 | +3.368 | +3.688 | 2.2 | 45 | 320 | 0.09838 | 0.0464 | 0.0002784
2 x BRIDGING BRACKET | PL/1998 | +3.334 | +3.654 | 2.2 | 45 | 320 | 0.09838 | 0.0464 | 0.0002784
2 x BRIDGING BRACKET | PL/1998(?) | +3.330 | +3.650 | 2.2 | 45 | 320 | 0.09838 | 0.0464 | 0.0002784
2 x BRIDGING BRACKET | PL/1998 | +3.285 | +3.605 | 2.2 | 45 | 320 | 0.09838 | 0.0464 | 0.0002784
2 x BRIDGING BRACKET | PL/1998 | +3.329 | +3.649 | 2.2 | 45 | 320 | 0.09838 | 0.0464 | 0.0002784
2 x BRIDGING BRACKET | PL/1998 | +3.313 | +3.633 | 2.2 | 45 | 320 | 0.09838 | 0.0464 | 0.0002784
2 x BRIDGING BRACKET | PL/1998 | +3.295 | +3.615 | 2.2 | 45 | 320 | 0.09838 | 0.0464 | 0.0002784
2 x BRIDGING BRACKET | PL/152 | +3.370 | +3.590 | 1.5 | 45.4 | 220 | 0.06818 | 0.0319 | 0.0001914
2 x BRIDGING BRACKET | PL/152 | +3.390 | +3.610 | 1.5 | 45.4 | 220 | 0.06818 | 0.0319 | 0.0001914
2 x BRIDGING BRACKET | PL/152 | +3.403 | +3.623 | 1.5 | 45.4 | 220 | 0.06818 | 0.0319 | 0.0001914
2 x BRIDGING BRACKET | PL/218 | +3.400 | +3.670 | 1.8 | 45.2 | 270 | 0.08328 | 0.03915 | 0.0002349
2 x BRIDGING BRACKET | PL/218 | +3.404 | +3.674 | 1.8 | 45.2 | 270 | 0.08328 | 0.03915 | 0.0002349
2 x BRIDGING BRACKET | PL/152 | +3.408 | +3.628 | 1.5 | 45.4 | 220 | 0.06818 | 0.0319 | 0.0001914
4 x BRIDGING BRACKET | PL/152 | +3.428 | +3.648 | 1.5 | 45.4 | 220 | 0.06818 | 0.0319 | 0.0001914
2 x BRIDGING BRACKET | PL/214 | +3.409 | +3.579 | 1.2 | 45.7 | 170 | 0.05308 | 0.02465 | 0.0001479
4 x BRIDGING BRACKET | PL/214 | +3.427 | +3.597 | 1.2 | 45.7 | 170 | 0.05308 | 0.02465 | 0.0001479
2 x BRIDGING BRACKET | PL/214 | +3.445 | +3.615 | 1.2 | 45.7 | 170 | 0.05308 | 0.02465 | 0.0001479
2 x BRIDGING BRACKET | PL/152 | +3.449 | +3.669 | 1.5 | 45.4 | 220 | 0.06818 | 0.0319 | 0.0001914
2 x BRIDGING BRACKET | PL/152 | +3.427 | +3.647 | 1.5 | 45.4 | 220 | 0.06818 | 0.0319 | 0.0001914
4 x BRIDGING BRACKET | PL/152 | +3.382 | +3.602 | 1.5 | 45.4 | 220 | 0.06818 | 0.0319 | 0.0001914
2 x BRIDGING BRACKET | PL/214 | +3.402 | +3.572 | 1.2 | 45.7 | 170 | 0.05308 | 0.02465 | 0.0001479
2 x BRIDGING BRACKET | PL/214 | +3.421 | +3.591 | 1.2 | 45.7 | 170 | 0.05308 | 0.02465 | 0.0001479
2 x BRIDGING BRACKET | PL/214 | +3.433 | +3.603 | 1.2 | 45.7 | 170 | 0.05308 | 0.02465 | 0.0001479
2 x BRIDGING BRACKET | PL/218(?) | +3.334 | +3.604 | 1.8 | 45.2 | 270 | 0.08328 | 0.03915 | 0.0002349
2 x BRIDGING BRACKET | PL/218(?) | +3.354 | +3.624 | 1.8 | 45.2 | 270 | 0.08328 | 0.03915 | 0.0002349
2 x BRIDGING BRACKET | PL/218(?) | +3.359 | +3.629 | 1.8 | 45.2 | 270 | 0.08328 | 0.03915 | 0.0002349
12 x BRIDGING BRACKET | PL/218 | +3.358 | +3.628 | 1.8 | 45.2 | 270 | 0.08328 | 0.03915 | 0.0002349
10 x BRIDGING BRACKET | PL/1998 | +3.308 | +3.628 | 2.2 | 45 | 320 | 0.09838 | 0.0464 | 0.0002784
2 x BRIDGING BRACKET | PL/1998 | +3.309 | +3.629 | 2.2 | 45 | 320 | 0.09838 | 0.0464 | 0.0002784
2 x BRIDGING BRACKET | PL/1998 | +3.284 | +3.604 | 2.2 | 45 | 320 | 0.09838 | 0.0464 | 0.0002784
2 x BRIDGING BRACKET | PL/1998 | +3.263 | +3.583 | 2.2 | 45 | 320 | 0.09838 | 0.0464 | 0.0002784
2 x BRIDGING BRACKET | PL/1998 | +3.293 | +3.613 | 2.2 | 45 | 320 | 0.09838 | 0.0464 | 0.0002784
2 x BRIDGING BRACKET | PL/152 | +3.371 | +3.591 | 1.5 | 45.4 | 220 | 0.06818 | 0.0319 | 0.0001914
2 x BRIDGING BRACKET | PL/152 | +3.386 | +3.606 | 1.5 | 45.4 | 220 | 0.06818 | 0.0319 | 0.0001914
8 x BRIDGING BRACKET | PL/152 | +3.406 | +3.626 | 1.5 | 45.4 | 220 | 0.06818 | 0.0319 | 0.0001914
2 x BRIDGING BRACKET | PL/152 | +3.396 | +3.616 | 1.5 | 45.4 | 220 | 0.06818 | 0.0319 | 0.0001914
2 x BRIDGING BRACKET | PL/214 | +3.407 | +3.577 | 1.2 | 45.7 | 170 | 0.05308 | 0.02465 | 0.0001479
2 x BRIDGING BRACKET | PL/214 | +3.447 | +3.617 | 1.2 | 45.7 | 170 | 0.05308 | 0.02465 | 0.0001479
2 x BRIDGING BRACKET | PL/152 | +3.360 | +3.580 | 1.5 | 45.4 | 220 | 0.06818 | 0.0319 | 0.0001914
2 x BRIDGING BRACKET | PL/214 | +3.401 | +3.571 | 1.2 | 45.7 | 170 | 0.05308 | 0.02465 | 0.0001479
4 x BRIDGING BRACKET | PL/214 | +3.411 | +3.581 | 1.2 | 45.7 | 170 | 0.05308 | 0.02465 | 0.0001479
