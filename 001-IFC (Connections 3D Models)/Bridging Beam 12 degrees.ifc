Properties of the parts of a building model (IFC2X3), part 1 of 4

# File
Description: ViewDefinition[CoordinationView_V2.0, QuantityTakeOffAddOnView], Option [BaseQuantities:On], Option [GridExport:On], Option [Assemblies:On], Option [Bolts:On], Option [Rebars:On], Option [PourObjects:Off], Option [Welds:Off], Option [SurfaceTreatments:Off], Option [LocationBy:0], Option [ViewColors:Off], Option [SectionedSpine:Off], Option [PropertySets:On], Option [Export all:Off]
File name: Bridging Beam 12 degrees.ifc
Time: 2026-10-02T13:56:50
Author: DESKTOP-BKNQL56\admin
Organization: Structural Designer
Written by: IFC Database version: Work
Made in: Tekla Structures 2019 Service Pack 13, IFC Export Version: 4.0.0.0 Oct 18 2021

# IfcBuildingStorey, Undefined
In: Undefined
Elevation: 0 mm

# IfcBeam: C:150-15 (66)
In: Undefined
Description: C:150-15; Material: STEEL/300PLUS
Tekla Common - Phase: 1; Class: 13
Tekla Quantity - Volume: 0 m3; Area per tons: 176.4 m2; Height: 152 mm; Width: 64 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Gross footprint area (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
FASCIA | F/16 | +3.558 | +3.710 | 9 | 0.2 | 1.6 | 2600 | 1.59472 | 0.0011895 | 9.33758
FASCIA | F/16 | +3.536 | +3.688 | 9 | 0.2 | 1.6 | 2600 | 1.59472 | 0.0011895 | 9.33758
FASCIA | F/16 | +3.512 | +3.664 | 9 | 0.2 | 1.6 | 2600 | 1.59472 | 0.0011895 | 9.33758
2 x FASCIA | F/15 | +3.559 | +3.711 | 9.4 | 0.2 | 1.7 | 2700 | 1.65602 | 0.00123525 | 9.69671
FASCIA | F/15 | +3.513 | +3.665 | 9.4 | 0.2 | 1.7 | 2700 | 1.65602 | 0.00123525 | 9.69671
FASCIA | F/15 | +3.468 | +3.620 | 9.4 | 0.2 | 1.7 | 2700 | 1.65602 | 0.00123525 | 9.69671
FASCIA | F/15 | +3.537 | +3.689 | 9.4 | 0.2 | 1.7 | 2700 | 1.65602 | 0.00123525 | 9.69671
FASCIA | F/15 | +3.514 | +3.666 | 9.4 | 0.2 | 1.7 | 2700 | 1.65602 | 0.00123525 | 9.69671
2 x FASCIA | F/14 | +3.558 | +3.710 | 8.1 | 0.1 | 1.4 | 2330 | 1.42921 | 0.00106598 | 8.3679
2 x FASCIA | F/14 | +3.536 | +3.688 | 8.1 | 0.1 | 1.4 | 2330 | 1.42921 | 0.00106598 | 8.3679
2 x FASCIA | F/14 | +3.513 | +3.665 | 8.1 | 0.1 | 1.4 | 2330 | 1.42921 | 0.00106598 | 8.3679
FASCIA | F/12 | +3.558 | +3.710 | 7.9 | 0.1 | 1.4 | 2260 | 1.3863 | 0.00103395 | 8.11651
FASCIA | F/12 | +3.537 | +3.689 | 7.9 | 0.1 | 1.4 | 2260 | 1.3863 | 0.00103395 | 8.11651
FASCIA | F/12 | +3.513 | +3.665 | 7.9 | 0.1 | 1.4 | 2260 | 1.3863 | 0.00103395 | 8.11651
3 x FASCIA | F/16 | +3.558 | +3.710 | 9 | 0.2 | 1.6 | 2600 | 1.59472 | 0.0011895 | 9.33757
3 x FASCIA | F/16 | +3.537 | +3.689 | 9 | 0.2 | 1.6 | 2600 | 1.59472 | 0.0011895 | 9.33757
3 x FASCIA | F/16 | +3.513 | +3.665 | 9 | 0.2 | 1.6 | 2600 | 1.59472 | 0.0011895 | 9.33757
FASCIA | F/11 | +3.559 | +3.711 | 7.7 | 0.1 | 1.2 | 2200 | 1.34952 | 0.0010065 | 7.90102
FASCIA | F/11 | +3.512 | +3.664 | 7.7 | 0.1 | 1.2 | 2200 | 1.34952 | 0.0010065 | 7.90102
3 x FASCIA | F/11 | +3.467 | +3.619 | 7.7 | 0.1 | 1.2 | 2200 | 1.34952 | 0.0010065 | 7.90102
FASCIA | F/11 | +3.513 | +3.665 | 7.7 | 0.1 | 1.2 | 2200 | 1.34952 | 0.0010065 | 7.90102
2 x FASCIA | F/11 | +3.491 | +3.643 | 7.7 | 0.1 | 1.2 | 2200 | 1.34952 | 0.0010065 | 7.90102
3 x FASCIA | F/16 | +3.491 | +3.643 | 9 | 0.2 | 1.6 | 2600 | 1.59472 | 0.0011895 | 9.33758
4 x FASCIA | F/15 | +3.492 | +3.644 | 9.4 | 0.2 | 1.7 | 2700 | 1.65602 | 0.00123525 | 9.69671
FASCIA | F/15 | +3.467 | +3.619 | 9.4 | 0.2 | 1.7 | 2700 | 1.65602 | 0.00123525 | 9.69671
FASCIA | F/15 | +3.446 | +3.598 | 9.4 | 0.2 | 1.7 | 2700 | 1.65602 | 0.00123525 | 9.69671
6 x FASCIA | F/14 | +3.491 | +3.643 | 8.1 | 0.1 | 1.4 | 2330 | 1.42921 | 0.00106598 | 8.3679
3 x FASCIA | F/12 | +3.491 | +3.643 | 7.9 | 0.1 | 1.4 | 2260 | 1.3863 | 0.00103395 | 8.11651
9 x FASCIA | F/75 | +3.491 | +3.643 | 9 | 0.2 | 1.6 | 2600 | 1.59472 | 0.0011895 | 9.33757
4 x FASCIA | F/11 | +3.445 | +3.597 | 7.7 | 0.1 | 1.2 | 2200 | 1.34952 | 0.0010065 | 7.90102

# IfcBeam: C:150-24 (36)
In: Undefined
Description: C:150-24; Material: STEEL/G450
Tekla Common - Finish: 12 deg; Phase: 1; Class: 1
Tekla Quantity - Weight: 2.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 111.7 m2; Net surface area: 0.3 m2; Height: 152 mm; Width: 64 mm; Length: 464.2 mm
Pset_BeamCommon - LoadBearing: no
BaseQuantities - Length: 464.162 mm; OuterSurfaceArea: 0.28907 m2; NetVolume: 0.00034244 m3; NetWeight: 2.68815 kg
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation
8 x RAFTER | Z/222 | +3.422 | +3.668
4 x RAFTER | Z/222 | +3.427 | +3.672
4 x RAFTER | Z/222 | +3.432 | +3.677
2 x RAFTER | Z/2555 | +3.432 | +3.677
2 x RAFTER | Z/2555 | +3.427 | +3.672
4 x RAFTER | Z/2555 | +3.422 | +3.668
4 x RAFTER | Z/222 | +3.386 | +3.631
2 x RAFTER | Z/2555 | +3.386 | +3.631
4 x RAFTER | Z/222 | +3.405 | +3.651
2 x RAFTER | Z/2555 | +3.405 | +3.651

# IfcBeam: C:200-24 (78)
In: Undefined
Description: C:200-24; Material: STEEL/G450
Tekla Common - Phase: 1
Tekla Quantity - Volume: 0 m3; Height: 203 mm; Width: 76 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Finish | Bottom elevation | Top elevation | Class | Weight (kg) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
12 x RAFTER | R/92 | 12 deg | +3.393 | +3.706 | 1 | 3.9 | 0 | 110.5 | 0.3 | 549.9 | 549.853 | 0.430525 | 0.000511232 | 4.01317
12 x RAFTER | R/92 | 12 deg | +3.412 | +3.725 | 1 | 3.9 | 0 | 110.5 | 0.3 | 549.9 | 549.853 | 0.430525 | 0.000511232 | 4.01317
12 x RAFTER | R/92 | 12 deg | +3.429 | +3.742 | 1 | 3.9 | 0 | 110.5 | 0.3 | 549.9 | 549.853 | 0.430525 | 0.000511232 | 4.01317
2 x RAFTER | R/93 | 12 deg | +3.393 | +3.706 | 1 | 3.9 | 0 | 110.5 | 0.3 | 549.9 | 549.854 | 0.430526 | 0.000511233 | 4.01318
2 x RAFTER | R/93 | 12 deg | +3.412 | +3.725 | 1 | 3.9 | 0 | 110.5 | 0.3 | 549.9 | 549.854 | 0.430526 | 0.000511233 | 4.01318
2 x RAFTER | R/93 | 12 deg | +3.429 | +3.742 | 1 | 3.9 | 0 | 110.5 | 0.3 | 549.9 | 549.854 | 0.430526 | 0.000511233 | 4.01318
4 x RAFTER | R/93 | 12 deg | +3.393 | +3.706 | 1 | 3.9 | 0 | 110.5 | 0.3 | 549.9 | 549.858 | 0.430529 | 0.000511236 | 4.0132
2 x RAFTER | R/93 | 12 deg | +3.412 | +3.725 | 1 | 3.9 | 0 | 110.5 | 0.3 | 549.9 | 549.848 | 0.430521 | 0.000511227 | 4.01313
2 x RAFTER | R/93 | 12 deg | +3.429 | +3.742 | 1 | 3.9 | 0 | 110.5 | 0.3 | 549.9 | 549.853 | 0.430525 | 0.000511232 | 4.01317
BRIDGING BEAM | BB/2 |  | +3.392 | +3.595 | 5 | 13.5 | 0.1 | 110.1 | 1.4 | 1904 | 1904 | 1.48622 | 0.00177026 | 13.8966
BRIDGING BEAM | BB/1 |  | +3.392 | +3.595 | 5 | 13.5 | 0.1 | 110.1 | 1.4 | 1904 | 1904 | 1.48622 | 0.00177026 | 13.8966
2 x RAFTER | R/93 | 12 deg | +3.412 | +3.725 | 1 | 3.9 | 0 | 110.5 | 0.3 | 549.9 | 549.858 | 0.430529 | 0.000511236 | 4.0132
BRIDGING BEAM | BB/2 |  | +3.411 | +3.614 | 5 | 13.5 | 0.1 | 110.1 | 1.4 | 1904 | 1904 | 1.48622 | 0.00177026 | 13.8966
BRIDGING BEAM | BB/1 |  | +3.411 | +3.614 | 5 | 13.5 | 0.1 | 110.1 | 1.4 | 1904 | 1904 | 1.48622 | 0.00177026 | 13.8966
2 x RAFTER | R/93 | 12 deg | +3.429 | +3.742 | 1 | 3.9 | 0 | 110.5 | 0.3 | 549.9 | 549.858 | 0.430529 | 0.000511236 | 4.0132
BRIDGING BEAM | BB/2 |  | +3.428 | +3.631 | 5 | 13.5 | 0.1 | 110.1 | 1.4 | 1904 | 1904 | 1.48622 | 0.00177026 | 13.8966
BRIDGING BEAM | BB/1 |  | +3.428 | +3.631 | 5 | 13.5 | 0.1 | 110.1 | 1.4 | 1904 | 1904 | 1.48622 | 0.00177026 | 13.8966
BEAM | B/15 |  | +3.386 | +3.589 | 5 | 13.6 | 0.1 | 110.1 | 1.4 | 1916 | 1916 | 1.49557 | 0.00178142 | 13.9841
BEAM | B/38 |  | +3.386 | +3.589 | 5 | 13.6 | 0.1 | 110.1 | 1.4 | 1916 | 1916 | 1.49557 | 0.00178142 | 13.9841
BEAM | B/15 |  | +3.405 | +3.608 | 5 | 13.6 | 0.1 | 110.1 | 1.4 | 1916 | 1916 | 1.49557 | 0.00178142 | 13.9841
BEAM | B/38 |  | +3.405 | +3.608 | 5 | 13.6 | 0.1 | 110.1 | 1.4 | 1916 | 1916 | 1.49557 | 0.00178142 | 13.9841
BEAM | B/15 |  | +3.416 | +3.619 | 5 | 13.6 | 0.1 | 110.1 | 1.4 | 1916 | 1916 | 1.49557 | 0.00178142 | 13.9841
BEAM | B/38 |  | +3.416 | +3.619 | 5 | 13.6 | 0.1 | 110.1 | 1.4 | 1916 | 1916 | 1.49557 | 0.00178142 | 13.9841
BRIDGING BEAM | BB/2 |  | +3.390 | +3.593 | 5 | 13.5 | 0.1 | 110.1 | 1.4 | 1904 | 1904 | 1.48622 | 0.00177026 | 13.8966
BRIDGING BEAM | BB/1 |  | +3.390 | +3.593 | 5 | 13.5 | 0.1 | 110.1 | 1.4 | 1904 | 1904 | 1.48622 | 0.00177026 | 13.8966
BRIDGING BEAM | BB/2 |  | +3.410 | +3.613 | 5 | 13.5 | 0.1 | 110.1 | 1.4 | 1904 | 1904 | 1.48622 | 0.00177026 | 13.8966
BRIDGING BEAM | BB/1 |  | +3.410 | +3.613 | 5 | 13.5 | 0.1 | 110.1 | 1.4 | 1904 | 1904 | 1.48622 | 0.00177026 | 13.8966
BRIDGING BEAM | BB/2 |  | +3.430 | +3.633 | 5 | 13.5 | 0.1 | 110.1 | 1.4 | 1904 | 1904 | 1.48622 | 0.00177026 | 13.8966
BRIDGING BEAM | BB/1 |  | +3.430 | +3.633 | 5 | 13.5 | 0.1 | 110.1 | 1.4 | 1904 | 1904 | 1.48622 | 0.00177026 | 13.8966
BEAM | B/15 |  | +3.384 | +3.587 | 5 | 13.6 | 0.1 | 110.1 | 1.4 | 1916 | 1916 | 1.49557 | 0.00178142 | 13.9841
BEAM | B/38 |  | +3.384 | +3.587 | 5 | 13.6 | 0.1 | 110.1 | 1.4 | 1916 | 1916 | 1.49557 | 0.00178142 | 13.9841
2 x BEAM | B/15 |  | +3.394 | +3.597 | 5 | 13.6 | 0.1 | 110.1 | 1.4 | 1916 | 1916 | 1.49557 | 0.00178142 | 13.9841
2 x BEAM | B/38 |  | +3.394 | +3.597 | 5 | 13.6 | 0.1 | 110.1 | 1.4 | 1916 | 1916 | 1.49557 | 0.00178142 | 13.9841

# IfcBeam: C:250-24 (90)
In: Undefined
Description: C:250-24; Material: STEEL/G450
Tekla Common - Phase: 1
Tekla Quantity - Volume: 0 m3; Height: 254 mm; Width: 76 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Finish | Bottom elevation | Top elevation | Class | Weight (kg) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
12 x RAFTER | Z/289 | 12 deg | +3.390 | +3.790 | 1 | 5.9 | 0 | 110 | 0.7 | 729.8 | 729.799 | 0.644031 | 0.000766114 | 6.014
12 x RAFTER | Z/289 | 12 deg | +3.373 | +3.773 | 1 | 5.9 | 0 | 110 | 0.7 | 729.8 | 729.799 | 0.644031 | 0.000766114 | 6.014
12 x RAFTER | Z/289 | 12 deg | +3.354 | +3.754 | 1 | 5.9 | 0 | 110 | 0.7 | 729.8 | 729.799 | 0.644031 | 0.000766114 | 6.014
4 x RAFTER | Z/2591 | 12 deg | +3.390 | +3.790 | 1 | 5.9 | 0 | 110 | 0.7 | 729.8 | 729.805 | 0.644036 | 0.00076612 | 6.01404
4 x RAFTER | Z/2591 | 12 deg | +3.373 | +3.773 | 1 | 5.9 | 0 | 110 | 0.7 | 729.8 | 729.805 | 0.644036 | 0.00076612 | 6.01404
4 x RAFTER | Z/2591 | 12 deg | +3.354 | +3.754 | 1 | 5.9 | 0 | 110 | 0.7 | 729.8 | 729.805 | 0.644036 | 0.00076612 | 6.01404
2 x RAFTER | Z/2591 | 12 deg | +3.354 | +3.754 | 1 | 5.9 | 0 | 110 | 0.7 | 729.8 | 729.801 | 0.644032 | 0.000766116 | 6.01401
2 x RAFTER | Z/2591 | 12 deg | +3.390 | +3.790 | 1 | 5.9 | 0 | 110 | 0.7 | 729.8 | 729.801 | 0.644032 | 0.000766116 | 6.01401
2 x RAFTER | Z/2591 | 12 deg | +3.373 | +3.773 | 1 | 5.9 | 0 | 110 | 0.7 | 729.8 | 729.801 | 0.644032 | 0.000766116 | 6.01401
BEAM | B/70 |  | +3.353 | +3.607 | 5 | 15.3 | 0.1 | 109.8 | 1.7 | 1904 | 1904 | 1.67686 | 0.00199874 | 15.6901
BEAM | B/92 |  | +3.353 | +3.607 | 5 | 15.3 | 0.1 | 109.8 | 1.7 | 1904 | 1904 | 1.67686 | 0.00199874 | 15.6901
BEAM | B/70 |  | +3.373 | +3.627 | 5 | 15.3 | 0.1 | 109.8 | 1.7 | 1904 | 1904 | 1.67686 | 0.00199874 | 15.6901
BEAM | B/92 |  | +3.373 | +3.627 | 5 | 15.3 | 0.1 | 109.8 | 1.7 | 1904 | 1904 | 1.67686 | 0.00199874 | 15.6901
BEAM | B/70 |  | +3.386 | +3.640 | 5 | 15.3 | 0.1 | 109.8 | 1.7 | 1904 | 1904 | 1.67686 | 0.00199874 | 15.6901
BEAM | B/92 |  | +3.386 | +3.640 | 5 | 15.3 | 0.1 | 109.8 | 1.7 | 1904 | 1904 | 1.67686 | 0.00199874 | 15.6901
BRIDGING BEAM | BB/4 |  | +3.391 | +3.645 | 5 | 15.3 | 0.1 | 109.8 | 1.7 | 1904 | 1904 | 1.67686 | 0.00199874 | 15.6901
BRIDGING BEAM | BB/3 |  | +3.391 | +3.645 | 5 | 15.3 | 0.1 | 109.8 | 1.7 | 1904 | 1904 | 1.67686 | 0.00199874 | 15.6901
2 x BRIDGING BEAM | BB/4 |  | +3.411 | +3.665 | 5 | 15.3 | 0.1 | 109.8 | 1.7 | 1904 | 1904 | 1.67686 | 0.00199874 | 15.6901
2 x BRIDGING BEAM | BB/3 |  | +3.411 | +3.665 | 5 | 15.3 | 0.1 | 109.8 | 1.7 | 1904 | 1904 | 1.67686 | 0.00199874 | 15.6901
BEAM | B/80 |  | +3.432 | +3.686 | 5 | 15.3 | 0.1 | 109.8 | 1.7 | 1916 | 1916 | 1.68741 | 0.00201134 | 15.789
BEAM | B/91 |  | +3.432 | +3.686 | 5 | 15.3 | 0.1 | 109.8 | 1.7 | 1916 | 1916 | 1.68741 | 0.00201134 | 15.789
BEAM | B/80 |  | +3.410 | +3.664 | 5 | 15.3 | 0.1 | 109.8 | 1.7 | 1916 | 1916 | 1.68741 | 0.00201134 | 15.789
BEAM | B/91 |  | +3.410 | +3.664 | 5 | 15.3 | 0.1 | 109.8 | 1.7 | 1916 | 1916 | 1.68741 | 0.00201134 | 15.789
2 x BEAM | B/80 |  | +3.365 | +3.619 | 5 | 15.3 | 0.1 | 109.8 | 1.7 | 1916 | 1916 | 1.68741 | 0.00201134 | 15.789
2 x BEAM | B/91 |  | +3.365 | +3.619 | 5 | 15.3 | 0.1 | 109.8 | 1.7 | 1916 | 1916 | 1.68741 | 0.00201134 | 15.789
BEAM | B/70 |  | +3.354 | +3.608 | 5 | 15.3 | 0.1 | 109.8 | 1.7 | 1904 | 1904 | 1.67686 | 0.00199874 | 15.6901
BEAM | B/92 |  | +3.354 | +3.608 | 5 | 15.3 | 0.1 | 109.8 | 1.7 | 1904 | 1904 | 1.67686 | 0.00199874 | 15.6901
BEAM | B/70 |  | +3.369 | +3.623 | 5 | 15.3 | 0.1 | 109.8 | 1.7 | 1904 | 1904 | 1.67686 | 0.00199874 | 15.6901
BEAM | B/92 |  | +3.369 | +3.623 | 5 | 15.3 | 0.1 | 109.8 | 1.7 | 1904 | 1904 | 1.67686 | 0.00199874 | 15.6901
BEAM | B/70 |  | +3.389 | +3.643 | 5 | 15.3 | 0.1 | 109.8 | 1.7 | 1904 | 1904 | 1.67686 | 0.00199874 | 15.6901
BEAM | B/92 |  | +3.389 | +3.643 | 5 | 15.3 | 0.1 | 109.8 | 1.7 | 1904 | 1904 | 1.67686 | 0.00199874 | 15.6901
BRIDGING BEAM | BB/4 |  | +3.379 | +3.633 | 5 | 15.3 | 0.1 | 109.8 | 1.7 | 1904 | 1904 | 1.67686 | 0.00199874 | 15.6901
BRIDGING BEAM | BB/3 |  | +3.379 | +3.633 | 5 | 15.3 | 0.1 | 109.8 | 1.7 | 1904 | 1904 | 1.67686 | 0.00199874 | 15.6901
2 x BRIDGING BEAM | BB/4 |  | +3.389 | +3.643 | 5 | 15.3 | 0.1 | 109.8 | 1.7 | 1904 | 1904 | 1.67686 | 0.00199874 | 15.6901
2 x BRIDGING BEAM | BB/3 |  | +3.389 | +3.643 | 5 | 15.3 | 0.1 | 109.8 | 1.7 | 1904 | 1904 | 1.67686 | 0.00199874 | 15.6901
BEAM | B/80 |  | +3.389 | +3.643 | 5 | 15.3 | 0.1 | 109.8 | 1.7 | 1916 | 1916 | 1.68741 | 0.00201134 | 15.789
BEAM | B/91 |  | +3.389 | +3.643 | 5 | 15.3 | 0.1 | 109.8 | 1.7 | 1916 | 1916 | 1.68741 | 0.00201134 | 15.789
BEAM | B/80 |  | +3.343 | +3.597 | 5 | 15.3 | 0.1 | 109.8 | 1.7 | 1916 | 1916 | 1.68741 | 0.00201134 | 15.789
BEAM | B/91 |  | +3.343 | +3.597 | 5 | 15.3 | 0.1 | 109.8 | 1.7 | 1916 | 1916 | 1.68741 | 0.00201134 | 15.789

# IfcBeam: C:300-24 (24)
In: Undefined
Description: C:300-24; Material: STEEL/G450
Tekla Common - Phase: 1; Class: 5
Tekla Quantity - Weight: 19 kg; Volume: 0 m3; Gross footprint area: 0.2 m2; Area per tons: 108.6 m2; Net surface area: 2.1 m2; Height: 300 mm; Width: 96 mm; Length: 1904 mm
Pset_BeamCommon - LoadBearing: no
BaseQuantities - Length: 1904 mm; OuterSurfaceArea: 2.05814 m2; NetVolume: 0.0024557 m3; NetWeight: 19.2773 kg
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation
BEAM | B/72 | +3.352 | +3.652
BEAM | B/93 | +3.352 | +3.652
BEAM | B/72 | +3.368 | +3.668
BEAM | B/93 | +3.368 | +3.668
BEAM | B/72 | +3.365 | +3.665
BEAM | B/93 | +3.365 | +3.665
BRIDGING BEAM | BB/6 | +3.385 | +3.685
BRIDGING BEAM | BB/5 | +3.385 | +3.685
BRIDGING BEAM | BB/6 | +3.389 | +3.689
BRIDGING BEAM | BB/5 | +3.389 | +3.689
BRIDGING BEAM | BB/6 | +3.365 | +3.665
BRIDGING BEAM | BB/5 | +3.365 | +3.665
3 x BEAM | B/72 | +3.343 | +3.643
3 x BEAM | B/93 | +3.343 | +3.643
3 x BRIDGING BEAM | BB/6 | +3.343 | +3.643
3 x BRIDGING BEAM | BB/5 | +3.343 | +3.643

# IfcBeam: C:300-30 (48)
In: Undefined
Description: C:300-30; Material: STEEL/G450
Tekla Common - Phase: 1
Tekla Quantity - Volume: 0 m3; Height: 300 mm; Width: 96 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Finish | Bottom elevation | Top elevation | Class | Weight (kg) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
RAFTER | Z/430 | 12 deg | +3.319 | +3.761 | 1 | 9 | 0 | 87.7 | 0.7 | 715 | 714.952 | 0.783986 | 0.00116466 | 9.14256
4 x RAFTER | Z/430 | 12 deg | +3.314 | +3.756 | 1 | 8.8 | 0 | 87.7 | 0.7 | 715 | 714.952 | 0.783986 | 0.00116466 | 9.14256
4 x RAFTER | Z/430 | 12 deg | +3.310 | +3.752 | 1 | 8.8 | 0 | 87.7 | 0.7 | 715 | 714.952 | 0.783986 | 0.00116466 | 9.14256
2 x RAFTER | Z/2599 | 12 deg | +3.310 | +3.752 | 1 | 8.8 | 0 | 87.7 | 0.7 | 715 | 714.952 | 0.783986 | 0.00116466 | 9.14256
2 x RAFTER | Z/2599 | 12 deg | +3.314 | +3.756 | 1 | 8.8 | 0 | 87.7 | 0.7 | 715 | 714.952 | 0.783986 | 0.00116466 | 9.14256
2 x RAFTER | Z/2599 | 12 deg | +3.319 | +3.761 | 1 | 8.8 | 0 | 87.7 | 0.7 | 715 | 714.952 | 0.783986 | 0.00116466 | 9.14256
7 x RAFTER | Z/430 | 12 deg | +3.319 | +3.761 | 1 | 8.8 | 0 | 87.7 | 0.7 | 715 | 714.952 | 0.783986 | 0.00116466 | 9.14256
BEAM | B/96 |  | +3.318 | +3.618 | 5 | 23.6 | 0.2 | 87.4 | 2.1 | 1884 | 1884 | 2.06059 | 0.00306904 | 24.0919
BEAM | B/97 |  | +3.318 | +3.618 | 5 | 23.6 | 0.2 | 87.4 | 2.1 | 1884 | 1884 | 2.06059 | 0.00306904 | 24.0919
2 x RAFTER | Z/2599 | 12 deg | +3.319 | +3.761 | 1 | 8.8 | 0 | 87.7 | 0.7 | 715 | 714.962 | 0.783997 | 0.00116467 | 9.14268
BEAM | B/96 |  | +3.338 | +3.638 | 5 | 23.6 | 0.2 | 87.4 | 2.1 | 1884 | 1884 | 2.06059 | 0.00306904 | 24.0919
BEAM | B/97 |  | +3.338 | +3.638 | 5 | 23.6 | 0.2 | 87.4 | 2.1 | 1884 | 1884 | 2.06059 | 0.00306904 | 24.0919
4 x RAFTER | Z/430 | 12 deg | +3.339 | +3.781 | 1 | 8.8 | 0 | 87.7 | 0.7 | 715 | 714.952 | 0.783986 | 0.00116466 | 9.14256
2 x RAFTER | Z/2599 | 12 deg | +3.339 | +3.781 | 1 | 8.8 | 0 | 87.7 | 0.7 | 715 | 714.962 | 0.783997 | 0.00116467 | 9.14268
BEAM | B/96 |  | +3.356 | +3.656 | 5 | 23.6 | 0.2 | 87.4 | 2.1 | 1884 | 1884 | 2.06059 | 0.00306904 | 24.0919
BEAM | B/97 |  | +3.356 | +3.656 | 5 | 23.6 | 0.2 | 87.4 | 2.1 | 1884 | 1884 | 2.06059 | 0.00306904 | 24.0919
4 x RAFTER | Z/430 | 12 deg | +3.356 | +3.798 | 1 | 8.8 | 0 | 87.7 | 0.7 | 715 | 714.952 | 0.783986 | 0.00116466 | 9.14256
2 x RAFTER | Z/2599 | 12 deg | +3.356 | +3.798 | 1 | 8.8 | 0 | 87.7 | 0.7 | 715 | 714.962 | 0.783997 | 0.00116467 | 9.14268
BEAM | B/102 |  | +3.319 | +3.619 | 5 | 23.6 | 0.2 | 87.4 | 2.1 | 1884 | 1884 | 2.06059 | 0.00306904 | 24.0919
BEAM | B/105 |  | +3.319 | +3.619 | 5 | 23.6 | 0.2 | 87.4 | 2.1 | 1884 | 1884 | 2.06059 | 0.00306904 | 24.0919
BEAM | B/106 |  | +3.339 | +3.639 | 5 | 23.6 | 0.2 | 87.4 | 2.1 | 1884 | 1884 | 2.06059 | 0.00306904 | 24.0919
BEAM | B/95 |  | +3.339 | +3.639 | 5 | 23.6 | 0.2 | 87.4 | 2.1 | 1884 | 1884 | 2.06059 | 0.00306904 | 24.0919
BEAM | B/102 |  | +3.344 | +3.644 | 5 | 23.6 | 0.2 | 87.4 | 2.1 | 1884 | 1884 | 2.06059 | 0.00306904 | 24.0919
BEAM | B/105 |  | +3.344 | +3.644 | 5 | 23.6 | 0.2 | 87.4 | 2.1 | 1884 | 1884 | 2.06059 | 0.00306904 | 24.0919

# IfcBeam: C:350-30 (54)
In: Undefined
Description: C:350-30; Material: STEEL/G450
Tekla Common - Phase: 1
Tekla Quantity - Volume: 0 m3; Height: 350 mm; Width: 125 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Class | Weight (kg) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
4 x RAFTER | Z/431 | +3.316 | +3.809 | 1 | 10.8 | 0 | 87.4 | 1 | 725 | 724.988 | 0.947822 | 0.00140938 | 11.0636 | Tekla Common - Finish: 12 deg
4 x RAFTER | Z/431 | +3.299 | +3.792 | 1 | 10.8 | 0 | 87.4 | 1 | 725 | 724.988 | 0.947822 | 0.00140938 | 11.0636 | Tekla Common - Finish: 12 deg
4 x RAFTER | Z/431 | +3.280 | +3.773 | 1 | 10.8 | 0 | 87.4 | 1 | 725 | 724.988 | 0.947822 | 0.00140938 | 11.0636 | Tekla Common - Finish: 12 deg
2 x RAFTER | Z/2606 | +3.280 | +3.773 | 1 | 10.8 | 0 | 87.4 | 1 | 725 | 724.99 | 0.947825 | 0.00140938 | 11.0636 | Tekla Common - Finish: 12 deg
2 x RAFTER | Z/2606 | +3.299 | +3.792 | 1 | 10.8 | 0 | 87.4 | 1 | 725 | 724.99 | 0.947825 | 0.00140938 | 11.0636 | Tekla Common - Finish: 12 deg
2 x RAFTER | Z/2606 | +3.316 | +3.809 | 1 | 10.8 | 0 | 87.4 | 1 | 725 | 724.99 | 0.947825 | 0.00140938 | 11.0636 | Tekla Common - Finish: 12 deg
BEAM | B/78 | +3.280 | +3.630 | 5 | 27.7 | 0.2 | 87.1 | 2.4 | 1855 | 1855 | 2.4191 | 0.00360612 | 28.308
BEAM | B/99 | +3.280 | +3.630 | 5 | 27.7 | 0.2 | 87.1 | 2.4 | 1855 | 1855 | 2.4191 | 0.00360612 | 28.308
BEAM | B/78 | +3.298 | +3.648 | 5 | 27.7 | 0.2 | 87.1 | 2.4 | 1855 | 1855 | 2.4191 | 0.00360612 | 28.308
BEAM | B/99 | +3.298 | +3.648 | 5 | 27.7 | 0.2 | 87.1 | 2.4 | 1855 | 1855 | 2.4191 | 0.00360612 | 28.308
BEAM | B/78 | +3.314 | +3.664 | 5 | 27.7 | 0.2 | 87.1 | 2.4 | 1855 | 1855 | 2.4191 | 0.00360612 | 28.308
BEAM | B/99 | +3.314 | +3.664 | 5 | 27.7 | 0.2 | 87.1 | 2.4 | 1855 | 1855 | 2.4191 | 0.00360612 | 28.308
BEAM | B/75 | +3.319 | +3.669 | 5 | 28.2 | 0.2 | 87.1 | 2.4 | 1884 | 1884 | 2.45686 | 0.0036625 | 28.7506
BEAM | B/98(?) | +3.319 | +3.669 | 5 | 28.2 | 0.2 | 87.1 | 2.4 | 1884 | 1884 | 2.45686 | 0.0036625 | 28.7506
BEAM | B/75(?) | +3.315 | +3.665 | 5 | 28.2 | 0.2 | 87.1 | 2.4 | 1884 | 1884 | 2.45686 | 0.0036625 | 28.7506
BEAM | B/98(?) | +3.315 | +3.665 | 5 | 28.2 | 0.2 | 87.1 | 2.4 | 1884 | 1884 | 2.45686 | 0.0036625 | 28.7506
BEAM | B/75 | +3.270 | +3.620 | 5 | 28.2 | 0.2 | 87.1 | 2.4 | 1884 | 1884 | 2.45686 | 0.0036625 | 28.7506
BEAM | B/98 | +3.270 | +3.620 | 5 | 28.2 | 0.2 | 87.1 | 2.4 | 1884 | 1884 | 2.45686 | 0.0036625 | 28.7506
BEAM | B/104 | +3.353 | +3.703 | 5 | 28.5 | 0.2 | 87.1 | 2.4 | 1904 | 1904 | 2.4829 | 0.00370138 | 29.0558
BEAM | B/103(?) | +3.353 | +3.703 | 5 | 28.5 | 0.2 | 87.1 | 2.4 | 1904 | 1904 | 2.4829 | 0.00370138 | 29.0558
BEAM | B/104 | +3.338 | +3.688 | 5 | 28.5 | 0.2 | 87.1 | 2.4 | 1904 | 1904 | 2.4829 | 0.00370138 | 29.0558
BEAM | B/103 | +3.338 | +3.688 | 5 | 28.5 | 0.2 | 87.1 | 2.4 | 1904 | 1904 | 2.4829 | 0.00370138 | 29.0558
BEAM | B/104 | +3.315 | +3.665 | 5 | 28.5 | 0.2 | 87.1 | 2.4 | 1904 | 1904 | 2.4829 | 0.00370138 | 29.0558
BEAM | B/103 | +3.315 | +3.665 | 5 | 28.5 | 0.2 | 87.1 | 2.4 | 1904 | 1904 | 2.4829 | 0.00370138 | 29.0558
BEAM | B/78 | +3.278 | +3.628 | 5 | 27.7 | 0.2 | 87.1 | 2.4 | 1855 | 1855 | 2.4191 | 0.00360612 | 28.308
BEAM | B/99 | +3.278 | +3.628 | 5 | 27.7 | 0.2 | 87.1 | 2.4 | 1855 | 1855 | 2.4191 | 0.00360612 | 28.308
2 x BEAM | B/78 | +3.293 | +3.643 | 5 | 27.7 | 0.2 | 87.1 | 2.4 | 1855 | 1855 | 2.4191 | 0.00360612 | 28.308
2 x BEAM | B/99 | +3.293 | +3.643 | 5 | 27.7 | 0.2 | 87.1 | 2.4 | 1855 | 1855 | 2.4191 | 0.00360612 | 28.308
BEAM | B/101 | +3.294 | +3.644 | 5 | 28.2 | 0.2 | 87.1 | 2.4 | 1884 | 1884 | 2.45686 | 0.0036625 | 28.7506
BEAM | B/98 | +3.294 | +3.644 | 5 | 28.2 | 0.2 | 87.1 | 2.4 | 1884 | 1884 | 2.45686 | 0.0036625 | 28.7506
BEAM | B/101 | +3.269 | +3.619 | 5 | 28.2 | 0.2 | 87.1 | 2.4 | 1884 | 1884 | 2.45686 | 0.0036625 | 28.7506
BEAM | B/98 | +3.269 | +3.619 | 5 | 28.2 | 0.2 | 87.1 | 2.4 | 1884 | 1884 | 2.45686 | 0.0036625 | 28.7506
BEAM | B/101 | +3.248 | +3.598 | 5 | 28.2 | 0.2 | 87.1 | 2.4 | 1884 | 1884 | 2.45686 | 0.0036625 | 28.7506
BEAM | B/98 | +3.248 | +3.598 | 5 | 28.2 | 0.2 | 87.1 | 2.4 | 1884 | 1884 | 2.45686 | 0.0036625 | 28.7506
3 x BEAM | B/100 | +3.293 | +3.643 | 5 | 28.5 | 0.2 | 87.1 | 2.4 | 1904 | 1904 | 2.4829 | 0.00370138 | 29.0558
3 x BEAM | B/94 | +3.293 | +3.643 | 5 | 28.5 | 0.2 | 87.1 | 2.4 | 1904 | 1904 | 2.4829 | 0.00370138 | 29.0558

# IfcBeam: PLT1.6*60 (144)
In: Undefined
Description: PLT1.6*60; Material: STEEL/250
Tekla Common - Phase: 1; Class: 12
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 60 mm; Width: 1.6 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x FASCIA BRACKET | Z/2533 | +3.555 | +3.712 | 0.4 | 164.1 | 0.1 | 553.9 | 553.901 | 0.0687224 | 0.0000533587 | 0.418866
FASCIA BRACKET | Z/3088 | +3.555 | +3.712 | 0.4 | 164.1 | 0.1 | 553.9 | 553.901 | 0.0687224 | 0.0000533587 | 0.418866
2 x FASCIA BRACKET | Z/2515 | +3.533 | +3.690 | 0.4 | 164.1 | 0.1 | 451.9 | 451.901 | 0.056156 | 0.0000435667 | 0.341999
FASCIA BRACKET | Z/3087 | +3.533 | +3.690 | 0.4 | 164.1 | 0.1 | 451.9 | 451.901 | 0.056156 | 0.0000435667 | 0.341999
2 x FASCIA BRACKET | Z/2514 | +3.510 | +3.667 | 0.4 | 164.4 | 0 | 351.9 | 351.901 | 0.043836 | 0.0000339667 | 0.266639
FASCIA BRACKET | Z/3086 | +3.510 | +3.667 | 0.4 | 164.4 | 0 | 351.9 | 351.901 | 0.043836 | 0.0000339667 | 0.266639
13 x FASCIA BRACKET | Z/2533 | +3.556 | +3.713 | 0.4 | 164.1 | 0.1 | 553.9 | 553.881 | 0.0687199 | 0.0000533568 | 0.418851
5 x FASCIA BRACKET | Z/3088 | +3.556 | +3.713 | 0.4 | 164.1 | 0.1 | 553.9 | 553.881 | 0.0687199 | 0.0000533568 | 0.418851
5 x FASCIA BRACKET | Z/2515 | +3.510 | +3.667 | 0.4 | 164.1 | 0.1 | 451.9 | 451.881 | 0.0561535 | 0.0000435648 | 0.341984
FASCIA BRACKET | Z/3087 | +3.510 | +3.667 | 0.4 | 164.1 | 0.1 | 451.9 | 451.881 | 0.0561535 | 0.0000435648 | 0.341984
8 x FASCIA BRACKET | Z/2514 | +3.465 | +3.622 | 0.4 | 164.4 | 0 | 351.9 | 351.881 | 0.0438335 | 0.0000339648 | 0.266624
FASCIA BRACKET | Z/3086 | +3.465 | +3.622 | 0.4 | 164.4 | 0 | 351.9 | 351.881 | 0.0438335 | 0.0000339648 | 0.266624
2 x FASCIA BRACKET | Z/2515 | +3.534 | +3.692 | 0.4 | 164.1 | 0.1 | 451.9 | 451.881 | 0.0561535 | 0.0000435648 | 0.341984
FASCIA BRACKET | Z/3087 | +3.534 | +3.692 | 0.4 | 164.1 | 0.1 | 451.9 | 451.881 | 0.0561535 | 0.0000435648 | 0.341984
8 x FASCIA BRACKET | Z/2514 | +3.511 | +3.668 | 0.4 | 164.4 | 0 | 351.9 | 351.881 | 0.0438335 | 0.0000339648 | 0.266624
4 x FASCIA BRACKET | Z/3086 | +3.511 | +3.668 | 0.4 | 164.4 | 0 | 351.9 | 351.881 | 0.0438335 | 0.0000339648 | 0.266624
6 x FASCIA BRACKET | Z/2515 | +3.534 | +3.691 | 0.4 | 164.1 | 0.1 | 451.9 | 451.881 | 0.0561535 | 0.0000435648 | 0.341984
3 x FASCIA BRACKET | Z/3087 | +3.534 | +3.691 | 0.4 | 164.1 | 0.1 | 451.9 | 451.881 | 0.0561535 | 0.0000435648 | 0.341984
3 x FASCIA BRACKET | Z/2533 | +3.510 | +3.667 | 0.4 | 164.1 | 0.1 | 553.9 | 553.881 | 0.0687199 | 0.0000533568 | 0.418851
3 x FASCIA BRACKET | Z/2515 | +3.488 | +3.645 | 0.4 | 164.1 | 0.1 | 451.9 | 451.881 | 0.0561535 | 0.0000435648 | 0.341984
3 x FASCIA BRACKET | Z/2531 | +3.488 | +3.645 | 0.4 | 164.4 | 0 | 387.9 | 387.901 | 0.0482712 | 0.0000374227 | 0.293768
3 x FASCIA BRACKET | Z/2520 | +3.488 | +3.645 | 0.4 | 164.4 | 0 | 339.9 | 339.901 | 0.0423576 | 0.0000328147 | 0.257596
3 x FASCIA BRACKET | Z/52 | +3.488 | +3.645 | 0.2 | 164.6 | 0 | 297.9 | 297.881 | 0.0371807 | 0.0000287808 | 0.225929
18 x FASCIA BRACKET | Z/2531 | +3.489 | +3.646 | 0.4 | 164.4 | 0 | 387.9 | 387.881 | 0.0482687 | 0.0000374208 | 0.293753
3 x FASCIA BRACKET | Z/2520 | +3.464 | +3.622 | 0.4 | 164.4 | 0 | 339.9 | 339.881 | 0.0423551 | 0.0000328128 | 0.25758
9 x FASCIA BRACKET | Z/52 | +3.443 | +3.600 | 0.2 | 164.6 | 0 | 297.9 | 297.881 | 0.0371807 | 0.0000287808 | 0.225929
12 x FASCIA BRACKET | Z/2520 | +3.489 | +3.646 | 0.4 | 164.4 | 0 | 339.9 | 339.881 | 0.0423551 | 0.0000328128 | 0.25758
12 x FASCIA BRACKET | Z/52 | +3.489 | +3.646 | 0.2 | 164.6 | 0 | 297.9 | 297.881 | 0.0371807 | 0.0000287808 | 0.225929
3 x FASCIA BRACKET | Z/2520 | +3.464 | +3.621 | 0.4 | 164.4 | 0 | 339.9 | 339.881 | 0.0423551 | 0.0000328128 | 0.25758
3 x FASCIA BRACKET | Z/2531 | +3.443 | +3.600 | 0.4 | 164.4 | 0 | 387.9 | 387.881 | 0.0482687 | 0.0000374208 | 0.293753
3 x FASCIA BRACKET | Z/2520 | +3.443 | +3.600 | 0.4 | 164.4 | 0 | 339.9 | 339.881 | 0.0423551 | 0.0000328128 | 0.25758

# IfcBeam: PLT3*60 (54)
In: Undefined
Description: PLT3*60; Material: STEEL/250
Tekla Common - Phase: 1; Class: 12
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 60 mm; Width: 3 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
6 x FASCIA BRACKET | Z/2954 | +3.554 | +3.715 | 0.8 | 89.7 | 0.1 | 552.4 | 552.425 | 0.0705361 | 0.00010017 | 0.786334
3 x FASCIA BRACKET | Z/2994 | +3.554 | +3.715 | 0.8 | 89.7 | 0.1 | 552.4 | 552.425 | 0.0705361 | 0.00010017 | 0.786334
7 x FASCIA BRACKET | Z/2953 | +3.532 | +3.693 | 0.6 | 89.8 | 0.1 | 450.4 | 450.425 | 0.0576841 | 0.00008181 | 0.642208
2 x FASCIA BRACKET | Z/2981 | +3.532 | +3.693 | 0.6 | 89.8 | 0.1 | 450.4 | 450.425 | 0.0576841 | 0.00008181 | 0.642208
6 x FASCIA BRACKET | Z/2951 | +3.509 | +3.670 | 0.4 | 90 | 0 | 350.4 | 350.425 | 0.0450841 | 0.00006381 | 0.500908
3 x FASCIA BRACKET | Z/2980 | +3.509 | +3.670 | 0.4 | 90 | 0 | 350.4 | 350.425 | 0.0450841 | 0.00006381 | 0.500908
9 x FASCIA BRACKET | Z/2556 | +3.487 | +3.648 | 0.6 | 89.8 | 0 | 386.4 | 386.425 | 0.0496201 | 0.00007029 | 0.551776
9 x FASCIA BRACKET | Z/2554 | +3.487 | +3.648 | 0.4 | 90 | 0 | 338.4 | 338.425 | 0.0435721 | 0.00006165 | 0.483952
9 x FASCIA BRACKET | Z/2553 | +3.487 | +3.648 | 0.4 | 90.2 | 0 | 296.4 | 296.425 | 0.0382801 | 0.00005409 | 0.424606

# IfcBeam: TH:120-95 (22)
In: Undefined
Description: TH:120-95
Tekla Common - Phase: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 0 m2; Height: 120 mm; Width: 165 mm
Pset_BeamCommon - LoadBearing: no
Name | Material | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Class | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
TH | STEEL/300PLUS | B/59 | +2.946 | +3.111 | 4 | 3 | 1.1 | 1600 | 7.29632e-07 | 0.000561926 | 4.41112
TH | STEEL/300PLUS | B/59 | +3.756 | +3.895 | 4 | 3 | 1.1 | 1600 | 7.29632e-07 | 0.000561926 | 4.41112
2 x TH | STEEL/300PLUS | B/65 | +2.981 | +3.146 | 4 | 3 | 1.2 | 1696 | 7.7341e-07 | 0.000595642 | 4.67579
TH | STEEL/300PLUS | B/65 | +3.744 | +3.883 | 4 | 3 | 1.2 | 1696 | 7.7341e-07 | 0.000595642 | 4.67579
TH | STEEL/300PLUS | B/65 | +3.732 | +3.871 | 4 | 3 | 1.2 | 1696 | 7.7341e-07 | 0.000595642 | 4.67579
3 x TH | STEEL/300PLUS | B/64 | +3.088 | +3.253 | 4 | 3 | 1.2 | 1676 | 7.64289e-07 | 0.000588618 | 4.62065
2 x TH | STEEL/300PLUS | B/64 | +3.737 | +3.876 | 4 | 3 | 1.2 | 1676 | 7.64289e-07 | 0.000588618 | 4.62065
TH | STEEL/300PLUS | B/64 | +3.703 | +3.842 | 4 | 3 | 1.2 | 1676 | 7.64289e-07 | 0.000588618 | 4.62065
3 x GIRT | STEEL/G450 | G/5 | +3.056 | +3.221 | 4 | 4.6 | 1.7 | 2600 | 0.00000118565 | 0.00091313 | 7.16807
3 x PURLIN | STEEL/G450 | PU/6 | +3.689 | +3.828 | 3 | 4.6 | 1.7 | 2600 | 0.00000118565 | 0.00091313 | 7.16807
2 x TH | STEEL/300PLUS | B/62 | +3.097 | +3.262 | 4 | 3 | 1.2 | 1664 | 7.58817e-07 | 0.000584403 | 4.58757
TH | STEEL/300PLUS | B/62 | +3.660 | +3.799 | 4 | 3 | 1.2 | 1664 | 7.58817e-07 | 0.000584403 | 4.58757
TH | STEEL/300PLUS | B/62 | +3.614 | +3.753 | 4 | 3 | 1.2 | 1664 | 7.58817e-07 | 0.000584403 | 4.58757

# IfcBeam: TH:75-95 (22)
In: Undefined
Description: TH:75-95
Tekla Common - Phase: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 0 m2; Height: 75 mm; Width: 125 mm
Pset_BeamCommon - LoadBearing: no
Name | Material | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Class | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
TH | STEEL/300PLUS | B/28 | +2.966 | +3.091 | 4 | 3 | 0.7 | 1600 | 7.29632e-07 | 0.000371041 | 2.91267
TH | STEEL/300PLUS | B/28 | +3.796 | +3.886 | 4 | 3 | 0.7 | 1600 | 7.29632e-07 | 0.000371041 | 2.91267
2 x TH | STEEL/300PLUS | B/30 | +3.001 | +3.126 | 4 | 3 | 0.7 | 1696 | 7.7341e-07 | 0.000393303 | 3.08743
TH | STEEL/300PLUS | B/30 | +3.739 | +3.829 | 4 | 3 | 0.7 | 1696 | 7.7341e-07 | 0.000393303 | 3.08743
TH | STEEL/300PLUS | B/30 | +3.772 | +3.863 | 4 | 3 | 0.7 | 1696 | 7.7341e-07 | 0.000393303 | 3.08743
3 x TH | STEEL/300PLUS | B/29 | +3.108 | +3.233 | 4 | 3 | 0.7 | 1676 | 7.64289e-07 | 0.000388665 | 3.05102
2 x TH | STEEL/300PLUS | B/29 | +3.777 | +3.867 | 4 | 3 | 0.7 | 1676 | 7.64289e-07 | 0.000388665 | 3.05102
TH | STEEL/300PLUS | B/29 | +3.744 | +3.834 | 4 | 3 | 0.7 | 1676 | 7.64289e-07 | 0.000388665 | 3.05102
3 x GIRT | STEEL/G450 | G/3 | +3.076 | +3.201 | 4 | 4.6 | 1.2 | 2600 | 0.00000118565 | 0.000602942 | 4.73309
3 x PURLIN | STEEL/G450 | PU/4 | +3.729 | +3.819 | 3 | 4.6 | 1.2 | 2600 | 0.00000118565 | 0.000602942 | 4.73309
2 x TH | STEEL/300PLUS | B/27 | +3.117 | +3.242 | 4 | 3 | 0.7 | 1664 | 7.58817e-07 | 0.000385883 | 3.02918
2 x TH | STEEL/300PLUS | B/27 | +3.655 | +3.745 | 4 | 3 | 0.7 | 1664 | 7.58817e-07 | 0.000385883 | 3.02918

# IfcBeam: TH:96-95 (22)
In: Undefined
Description: TH:96-95
Tekla Common - Phase: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 0 m2; Height: 96 mm; Width: 150 mm
Pset_BeamCommon - LoadBearing: no
Name | Material | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Class | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
TH | STEEL/300PLUS | B/44 | +2.953 | +3.103 | 4 | 3 | 1 | 1600 | 7.29632e-07 | 0.000459476 | 3.60689
TH | STEEL/300PLUS | B/44 | +3.777 | +3.890 | 4 | 3 | 1 | 1600 | 7.29632e-07 | 0.000459476 | 3.60689
2 x TH | STEEL/300PLUS | B/54 | +2.988 | +3.138 | 4 | 3 | 1 | 1696 | 7.7341e-07 | 0.000487044 | 3.8233
TH | STEEL/300PLUS | B/54 | +3.741 | +3.854 | 4 | 3 | 1 | 1696 | 7.7341e-07 | 0.000487044 | 3.8233
TH | STEEL/300PLUS | B/54 | +3.753 | +3.866 | 4 | 3 | 1 | 1696 | 7.7341e-07 | 0.000487044 | 3.8233
3 x TH | STEEL/300PLUS | B/45 | +3.096 | +3.246 | 4 | 3 | 1 | 1676 | 7.64289e-07 | 0.000481301 | 3.77821
2 x TH | STEEL/300PLUS | B/45 | +3.758 | +3.871 | 4 | 3 | 1 | 1676 | 7.64289e-07 | 0.000481301 | 3.77821
TH | STEEL/300PLUS | B/45 | +3.724 | +3.838 | 4 | 3 | 1 | 1676 | 7.64289e-07 | 0.000481301 | 3.77821
3 x GIRT | STEEL/G450 | G/4 | +3.063 | +3.213 | 4 | 4.6 | 1.4 | 2600 | 0.00000118565 | 0.000746648 | 5.86119
3 x PURLIN | STEEL/G450 | PU/5 | +3.710 | +3.823 | 3 | 4.6 | 1.4 | 2600 | 0.00000118565 | 0.000746648 | 5.86119
2 x TH | STEEL/300PLUS | B/35 | +3.104 | +3.254 | 4 | 3 | 1 | 1664 | 7.58817e-07 | 0.000477855 | 3.75116
TH | STEEL/300PLUS | B/35 | +3.656 | +3.770 | 4 | 3 | 1 | 1664 | 7.58817e-07 | 0.000477855 | 3.75116
TH | STEEL/300PLUS | B/35 | +3.635 | +3.749 | 4 | 3 | 1 | 1664 | 7.58817e-07 | 0.000477855 | 3.75116

# IfcBeam: Z:100-15 (22)
In: Undefined
Description: Z:100-15; Material: STEEL/G450
Tekla Common - Phase: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 102 mm; Width: 100.5 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Class | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
GIRT | G/18 | +2.976 | +3.077 | 4 | 4.1 | 179.1 | 0.7 | 1600 | 0.725475 | 0.00054 | 4.239
PURLIN | PU/19 | +3.799 | +3.920 | 4 | 4.1 | 179.1 | 0.7 | 1600 | 0.725475 | 0.00054 | 4.239
2 x GIRT | G/15 | +3.011 | +3.112 | 4 | 4.3 | 179.1 | 0.7 | 1696 | 0.768963 | 0.0005724 | 4.49334
PURLIN | PU/16 | +3.742 | +3.862 | 4 | 4.3 | 179.1 | 0.7 | 1696 | 0.768963 | 0.0005724 | 4.49334
PURLIN | PU/16 | +3.775 | +3.896 | 4 | 4.3 | 179.1 | 0.7 | 1696 | 0.768963 | 0.0005724 | 4.49334
3 x GIRT | G/12 | +3.123 | +3.223 | 4 | 4.1 | 179.1 | 0.7 | 1676 | 0.759903 | 0.00056565 | 4.44035
2 x PURLIN | PU/13 | +3.780 | +3.901 | 4 | 4.1 | 179.1 | 0.7 | 1676 | 0.759903 | 0.00056565 | 4.44035
PURLIN | PU/13 | +3.747 | +3.867 | 4 | 4.1 | 179.1 | 0.7 | 1676 | 0.759903 | 0.00056565 | 4.44035
3 x GIRT | G/9 | +3.090 | +3.190 | 4 | 6.6 | 179 | 1.2 | 2600 | 1.17847 | 0.0008775 | 6.88838
3 x PURLIN | PU/10 | +3.732 | +3.853 | 3 | 6.6 | 179 | 1.2 | 2600 | 1.17848 | 0.0008775 | 6.88838
2 x GIRT | G/6 | +3.131 | +3.232 | 4 | 4.1 | 179.1 | 0.7 | 1664 | 0.754467 | 0.0005616 | 4.40856
2 x PURLIN | PU/7 | +3.658 | +3.778 | 4 | 4.1 | 179.1 | 0.7 | 1664 | 0.754467 | 0.0005616 | 4.40856

# IfcBeam: Z:150-15 (22)
In: Undefined
Description: Z:150-15; Material: STEEL/G450
Tekla Common - Phase: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 176.6 m2; Height: 152 mm; Width: 124.5 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Class | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
GIRT | G/19 | +2.964 | +3.089 | 4 | 5.6 | 1 | 1600 | 0.981715 | 0.000732 | 5.7462
PURLIN | PU/20 | +3.780 | +3.954 | 4 | 5.6 | 1 | 1600 | 0.981715 | 0.000732 | 5.7462
2 x GIRT | G/16 | +2.999 | +3.124 | 4 | 5.9 | 1 | 1696 | 1.04056 | 0.00077592 | 6.09097
PURLIN | PU/17 | +3.744 | +3.918 | 4 | 5.9 | 1 | 1696 | 1.04056 | 0.00077592 | 6.09097
PURLIN | PU/17 | +3.756 | +3.930 | 4 | 5.9 | 1 | 1696 | 1.04056 | 0.00077592 | 6.09097
3 x GIRT | G/13 | +3.111 | +3.235 | 4 | 5.9 | 1 | 1676 | 1.0283 | 0.00076677 | 6.01914
2 x PURLIN | PU/14 | +3.761 | +3.935 | 4 | 5.9 | 1 | 1676 | 1.0283 | 0.00076677 | 6.01914
PURLIN | PU/14 | +3.727 | +3.902 | 4 | 5.9 | 1 | 1676 | 1.0283 | 0.00076677 | 6.01914
3 x GIRT | G/10 | +3.078 | +3.202 | 4 | 9 | 1.6 | 2600 | 1.59472 | 0.0011895 | 9.33757
3 x PURLIN | PU/11 | +3.713 | +3.887 | 3 | 9 | 1.6 | 2600 | 1.59472 | 0.0011895 | 9.33758
2 x GIRT | G/7 | +3.119 | +3.244 | 4 | 5.9 | 1 | 1664 | 1.02095 | 0.00076128 | 5.97605
PURLIN | PU/8 | +3.660 | +3.834 | 4 | 5.9 | 1 | 1664 | 1.02095 | 0.00076128 | 5.97605
PURLIN | PU/8 | +3.638 | +3.813 | 4 | 5.9 | 1 | 1664 | 1.02095 | 0.00076128 | 5.97605

# IfcBeam: Z:200-15 (22)
In: Undefined
Description: Z:200-15; Material: STEEL/G450
Tekla Common - Phase: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 175.3 m2; Height: 203 mm; Width: 151.5 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Class | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
GIRT | G/20 | +2.950 | +3.102 | 4 | 7 | 1.2 | 1600 | 1.22194 | 0.000912 | 7.1592
PURLIN | PU/21 | +3.757 | +3.988 | 4 | 7 | 1.2 | 1600 | 1.22194 | 0.000912 | 7.1592
2 x GIRT | G/17 | +2.985 | +3.137 | 4 | 7.4 | 1.2 | 1696 | 1.29519 | 0.00096672 | 7.58875
PURLIN | PU/18 | +3.746 | +3.976 | 4 | 7.4 | 1.2 | 1696 | 1.29519 | 0.00096672 | 7.58875
PURLIN | PU/18 | +3.734 | +3.964 | 4 | 7.4 | 1.2 | 1696 | 1.29519 | 0.00096672 | 7.58875
3 x GIRT | G/14 | +3.098 | +3.249 | 4 | 7.4 | 1.2 | 1676 | 1.27993 | 0.00095532 | 7.49926
2 x PURLIN | PU/15 | +3.739 | +3.969 | 4 | 7.4 | 1.2 | 1676 | 1.27993 | 0.00095532 | 7.49926
PURLIN | PU/15 | +3.705 | +3.935 | 4 | 7.4 | 1.2 | 1676 | 1.27993 | 0.00095532 | 7.49926
3 x GIRT | G/11 | +3.065 | +3.216 | 4 | 11.3 | 2 | 2600 | 1.98494 | 0.001482 | 11.6337
3 x PURLIN | PU/12 | +3.690 | +3.921 | 3 | 11.3 | 2 | 2600 | 1.98494 | 0.001482 | 11.6337
2 x GIRT | G/8 | +3.106 | +3.258 | 4 | 7.2 | 1.2 | 1664 | 1.27077 | 0.00094848 | 7.44557
PURLIN | PU/9 | +3.662 | +3.892 | 4 | 7.2 | 1.2 | 1664 | 1.27077 | 0.00094848 | 7.44557
PURLIN | PU/9 | +3.616 | +3.846 | 4 | 7.2 | 1.2 | 1664 | 1.27077 | 0.00094848 | 7.44557

# IfcColumn: C:150-24 (24)
In: Undefined
Description: C:150-24; Material: STEEL/G450
Tekla Common - Finish: 25 deg; Bottom elevation: +0.000; Phase: 1; Class: 10
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 111.2 m2; Height: 152 mm; Width: 64 mm
Pset_ColumnCommon - LoadBearing: no
Name | Top elevation | ASSEMBLY_POS = Reference | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
COLUMN | +3.711 | Z/2641 | 20.7 | 2.3 | 3710.6 | 3710.62 | 2.30057 | 0.00273754 | 21.4897
COLUMN | +3.711 | Z/2596(?) | 20.7 | 2.3 | 3710.6 | 3710.62 | 2.30057 | 0.00273754 | 21.4897
COLUMN | +3.664 | Z/2640 | 20.4 | 2.3 | 3664.2 | 3664.21 | 2.27182 | 0.00270331 | 21.2209
COLUMN | +3.664 | Z/2572 | 20.4 | 2.3 | 3664.2 | 3664.21 | 2.27182 | 0.00270331 | 21.2209
2 x COLUMN | +3.619 | Z/1584 | 20.2 | 2.2 | 3619.3 | 3619.26 | 2.24397 | 0.00267014 | 20.9606
2 x COLUMN | +3.619 | Z/2575 | 20.2 | 2.2 | 3619.3 | 3619.26 | 2.24397 | 0.00267014 | 20.9606
COLUMN | +3.665 | Z/2639 | 20.4 | 2.3 | 3664.7 | 3664.62 | 2.27207 | 0.00270361 | 21.2233
COLUMN | +3.665 | Z/2571 | 20.4 | 2.3 | 3664.7 | 3664.62 | 2.27207 | 0.00270361 | 21.2233
COLUMN | +3.643 | Z/2638 | 20.2 | 2.3 | 3642.7 | 3642.75 | 2.25852 | 0.00268747 | 21.0967
COLUMN | +3.643 | Z/2532 | 20.2 | 2.3 | 3642.7 | 3642.75 | 2.25852 | 0.00268747 | 21.0967
COLUMN | +3.643 | Z/1593 | 20.2 | 2.3 | 3643.3 | 3643.4 | 2.25893 | 0.00268795 | 21.1004
COLUMN | +3.643 | Z/2576 | 20.2 | 2.3 | 3643.3 | 3643.4 | 2.25893 | 0.00268795 | 21.1004
COLUMN | +3.619 | Z/1584 | 20.2 | 2.2 | 3618.9 | 3618.86 | 2.24372 | 0.00266985 | 20.9583
COLUMN | +3.619 | Z/2575 | 20.2 | 2.2 | 3618.9 | 3618.86 | 2.24372 | 0.00266985 | 20.9583
2 x COLUMN | +3.597 | Z/368 | 20.1 | 2.2 | 3597.4 | 3597.4 | 2.23042 | 0.00265402 | 20.834
2 x COLUMN | +3.597 | Z/2570 | 20.1 | 2.2 | 3597.4 | 3597.4 | 2.23042 | 0.00265402 | 20.834
COLUMN | +3.597 | Z/1582 | 20.1 | 2.2 | 3597.4 | 3597.4 | 2.23042 | 0.00265402 | 20.834
COLUMN | +3.597 | Z/2574 | 20.1 | 2.2 | 3597.4 | 3597.4 | 2.23042 | 0.00265402 | 20.834
COLUMN | +3.597 | Z/377 | 20.1 | 2.2 | 3597.4 | 3597.4 | 2.23042 | 0.00265402 | 20.834
COLUMN | +3.597 | Z/2573 | 20.1 | 2.2 | 3597.4 | 3597.4 | 2.23042 | 0.00265402 | 20.834

# IfcColumn: C:200-24 (36)
In: Undefined
Description: C:200-24; Material: STEEL/G450
Tekla Common - Finish: 25 deg; Bottom elevation: +0.000; Phase: 1; Class: 10
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 110.1 m2; Height: 203 mm; Width: 76 mm
Pset_ColumnCommon - LoadBearing: no
Name | Top elevation | ASSEMBLY_POS = Reference | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
3 x COLUMN | +3.710 | C/67 | 26.3 | 2.9 | 3710.5 | 3710.48 | 2.89455 | 0.00344986 | 27.0814
3 x COLUMN | +3.710 | C/64 | 26.3 | 2.9 | 3710.5 | 3710.48 | 2.89455 | 0.00344986 | 27.0814
3 x COLUMN | +3.689 | C/66 | 26.1 | 2.9 | 3688.6 | 3688.62 | 2.87751 | 0.00342953 | 26.9218
3 x COLUMN | +3.689 | C/63 | 26.1 | 2.9 | 3688.6 | 3688.62 | 2.87751 | 0.00342953 | 26.9218
2 x COLUMN | +3.665 | C/65 | 26 | 2.9 | 3665.1 | 3665.13 | 2.8592 | 0.00340769 | 26.7504
2 x COLUMN | +3.665 | C/62 | 26 | 2.9 | 3665.1 | 3665.13 | 2.8592 | 0.00340769 | 26.7504
COLUMN | +3.665 | C/65 | 26 | 2.9 | 3665.1 | 3665.11 | 2.85918 | 0.00340767 | 26.7502
COLUMN | +3.665 | C/62 | 26 | 2.9 | 3665.1 | 3665.11 | 2.85918 | 0.00340767 | 26.7502
COLUMN | +3.643 | C/58 | 25.8 | 2.8 | 3643.3 | 3643.27 | 2.84215 | 0.00338737 | 26.5908
3 x COLUMN | +3.643 | C/61 | 25.8 | 2.8 | 3643.3 | 3643.27 | 2.84215 | 0.00338737 | 26.5908
COLUMN | +3.643 | C/57 | 25.8 | 2.8 | 3643.3 | 3643.27 | 2.84215 | 0.00338737 | 26.5908
3 x COLUMN | +3.643 | C/60 | 25.8 | 2.8 | 3643.3 | 3643.27 | 2.84215 | 0.00338737 | 26.5908
COLUMN | +3.643 | C/56 | 25.8 | 2.8 | 3643.3 | 3643.27 | 2.84215 | 0.00338737 | 26.5908
3 x COLUMN | +3.643 | C/59 | 25.8 | 2.8 | 3643.3 | 3643.27 | 2.84215 | 0.00338737 | 26.5908
2 x COLUMN | +3.643 | C/55 | 25.8 | 2.8 | 3643.3 | 3643.27 | 2.84215 | 0.00338737 | 26.5908
2 x COLUMN | +3.643 | C/54 | 25.8 | 2.8 | 3643.3 | 3643.27 | 2.84215 | 0.00338737 | 26.5908
2 x COLUMN | +3.643 | C/53 | 25.8 | 2.8 | 3643.3 | 3643.27 | 2.84215 | 0.00338737 | 26.5908

# IfcColumn: C:250-24 (36)
In: Undefined
Description: C:250-24; Material: STEEL/G450
Tekla Common - Finish: 25 deg; Bottom elevation: +0.000; Phase: 1; Class: 10
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 109.7 m2; Height: 254 mm; Width: 76 mm
Pset_ColumnCommon - LoadBearing: no
Name | Top elevation | ASSEMBLY_POS = Reference | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x COLUMN | +3.710 | Z/3115 | 29.8 | 3.3 | 3710.3 | 3710.3 | 3.26568 | 0.00389493 | 30.5752
2 x COLUMN | +3.710 | Z/3044(?) | 29.8 | 3.3 | 3710.3 | 3710.3 | 3.26568 | 0.00389493 | 30.5752
2 x COLUMN | +3.688 | Z/3114 | 29.6 | 3.2 | 3688.4 | 3688.43 | 3.24645 | 0.00387197 | 30.395
2 x COLUMN | +3.688 | Z/3043(?) | 29.6 | 3.2 | 3688.4 | 3688.43 | 3.24645 | 0.00387197 | 30.395
2 x COLUMN | +3.665 | Z/3113 | 29.4 | 3.2 | 3665 | 3664.95 | 3.22579 | 0.00384732 | 30.2015
2 x COLUMN | +3.665 | Z/3042(?) | 29.4 | 3.2 | 3665 | 3664.95 | 3.22579 | 0.00384732 | 30.2015
COLUMN | +3.710 | Z/3115 | 29.8 | 3.3 | 3710.5 | 3710.48 | 3.26584 | 0.00389511 | 30.5766
COLUMN | +3.710 | Z/3044 | 29.8 | 3.3 | 3710.5 | 3710.48 | 3.26584 | 0.00389511 | 30.5766
COLUMN | +3.689 | Z/3114 | 29.6 | 3.2 | 3688.6 | 3688.62 | 3.24661 | 0.00387217 | 30.3965
COLUMN | +3.689 | Z/3043 | 29.6 | 3.2 | 3688.6 | 3688.62 | 3.24661 | 0.00387217 | 30.3965
COLUMN | +3.665 | Z/3113 | 29.4 | 3.2 | 3665.1 | 3665.14 | 3.22596 | 0.00384752 | 30.203
COLUMN | +3.665 | Z/3042 | 29.4 | 3.2 | 3665.1 | 3665.14 | 3.22596 | 0.00384752 | 30.203
COLUMN | +3.643 | Z/2580 | 29.2 | 3.2 | 3643.1 | 3643.09 | 3.20656 | 0.00382437 | 30.0213
2 x COLUMN | +3.643 | Z/2584 | 29.2 | 3.2 | 3643.1 | 3643.09 | 3.20656 | 0.00382437 | 30.0213
COLUMN | +3.643 | Z/2579 | 29.2 | 3.2 | 3643.1 | 3643.09 | 3.20656 | 0.00382437 | 30.0213
2 x COLUMN | +3.643 | Z/2578 | 29.2 | 3.2 | 3643.1 | 3643.09 | 3.20656 | 0.00382437 | 30.0213
COLUMN | +3.643 | Z/2557 | 29.2 | 3.2 | 3643.1 | 3643.09 | 3.20656 | 0.00382437 | 30.0213
2 x COLUMN | +3.643 | Z/2577 | 29.2 | 3.2 | 3643.1 | 3643.09 | 3.20656 | 0.00382437 | 30.0213
COLUMN | +3.643 | Z/2583 | 29.2 | 3.2 | 3643.1 | 3643.09 | 3.20656 | 0.00382437 | 30.0213
COLUMN | +3.643 | Z/2582 | 29.2 | 3.2 | 3643.1 | 3643.09 | 3.20656 | 0.00382437 | 30.0213
COLUMN | +3.643 | Z/2581 | 29.2 | 3.2 | 3643.1 | 3643.09 | 3.20656 | 0.00382437 | 30.0213
COLUMN | +3.643 | Z/2580 | 29.2 | 3.2 | 3643.3 | 3643.27 | 3.20672 | 0.00382456 | 30.0228
COLUMN | +3.643 | Z/2584 | 29.2 | 3.2 | 3643.3 | 3643.27 | 3.20672 | 0.00382456 | 30.0228
COLUMN | +3.643 | Z/2579 | 29.2 | 3.2 | 3643.3 | 3643.27 | 3.20672 | 0.00382456 | 30.0228
COLUMN | +3.643 | Z/2578 | 29.2 | 3.2 | 3643.3 | 3643.27 | 3.20672 | 0.00382456 | 30.0228
COLUMN | +3.643 | Z/2557 | 29.2 | 3.2 | 3643.3 | 3643.27 | 3.20672 | 0.00382456 | 30.0228
COLUMN | +3.643 | Z/2577 | 29.2 | 3.2 | 3643.3 | 3643.27 | 3.20672 | 0.00382456 | 30.0228

# IfcColumn: C:300-30 (24)
In: Undefined
Description: C:300-30; Material: STEEL/G450
Tekla Common - Finish: 25 deg; Bottom elevation: +0.000; Phase: 1; Class: 10
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.4 m2; Height: 300 mm; Width: 96 mm
Pset_ColumnCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Top elevation | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
COLUMN | Z/3185 | +3.711 | 46.4 | 4.1 | 3711.1 | 3711.13 | 4.05582 | 0.00604544 | 47.4567
COLUMN | Z/3135 | +3.711 | 46.4 | 4.1 | 3711.1 | 3711.13 | 4.05582 | 0.00604544 | 47.4567
COLUMN | Z/3198 | +3.665 | 45.8 | 4 | 3664.7 | 3664.72 | 4.00514 | 0.00596984 | 46.8632
COLUMN | Z/3136 | +3.665 | 45.8 | 4 | 3664.7 | 3664.72 | 4.00514 | 0.00596984 | 46.8632
COLUMN | Z/3190 | +3.620 | 45.3 | 4 | 3619.8 | 3619.78 | 3.95605 | 0.00589661 | 46.2884
COLUMN | Z/304 | +3.620 | 45.3 | 4 | 3619.8 | 3619.78 | 3.95605 | 0.00589661 | 46.2884
COLUMN | Z/3185 | +3.711 | 46.4 | 4.1 | 3711.1 | 3711.13 | 4.05581 | 0.00604543 | 47.4567
COLUMN | Z/3135 | +3.711 | 46.4 | 4.1 | 3711.1 | 3711.13 | 4.05581 | 0.00604543 | 47.4567
COLUMN | Z/3173 | +3.689 | 46.1 | 4 | 3689.3 | 3689.27 | 4.03194 | 0.00600983 | 47.1771
COLUMN | Z/3122 | +3.689 | 46.1 | 4 | 3689.3 | 3689.27 | 4.03194 | 0.00600983 | 47.1771
COLUMN | Z/3172 | +3.666 | 45.8 | 4 | 3665.8 | 3665.78 | 4.00629 | 0.00597156 | 46.8768
COLUMN | Z/3121 | +3.666 | 45.8 | 4 | 3665.8 | 3665.78 | 4.00629 | 0.00597156 | 46.8768
2 x COLUMN | Z/2593 | +3.644 | 45.6 | 4 | 3643.9 | 3643.92 | 3.98242 | 0.00593595 | 46.5972
2 x COLUMN | Z/2587 | +3.644 | 45.6 | 4 | 3643.9 | 3643.92 | 3.98242 | 0.00593595 | 46.5972
COLUMN | Z/2594 | +3.619 | 45.3 | 4 | 3619.3 | 3619.38 | 3.95562 | 0.00589597 | 46.2834
COLUMN | Z/2588 | +3.619 | 45.3 | 4 | 3619.3 | 3619.38 | 3.95562 | 0.00589597 | 46.2834
COLUMN | Z/2569 | +3.598 | 45 | 4 | 3597.9 | 3597.91 | 3.93218 | 0.005861 | 46.0088
COLUMN | Z/225 | +3.598 | 45 | 4 | 3597.9 | 3597.91 | 3.93218 | 0.005861 | 46.0088
COLUMN | Z/2592 | +3.644 | 45.6 | 4 | 3643.9 | 3643.92 | 3.98242 | 0.00593595 | 46.5972
COLUMN | Z/2586 | +3.644 | 45.6 | 4 | 3643.9 | 3643.92 | 3.98242 | 0.00593595 | 46.5972
COLUMN | Z/2568 | +3.644 | 45.6 | 4 | 3643.9 | 3643.92 | 3.98242 | 0.00593595 | 46.5972
COLUMN | Z/2585 | +3.644 | 45.6 | 4 | 3643.9 | 3643.92 | 3.98242 | 0.00593595 | 46.5972

# IfcColumn: C:350-30 (12)
In: Undefined
Description: C:350-30; Material: STEEL/G450
Tekla Common - Finish: 25 deg; Bottom elevation: +0.000; Phase: 1; Class: 10
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.1 m2; Height: 350 mm; Width: 125 mm
Pset_ColumnCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Top elevation | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
COLUMN | Z/3639 | +3.710 | 55.5 | 4.8 | 3709.9 | 3709.86 | 4.83412 | 0.00721196 | 56.6139
COLUMN | Z/3618 | +3.710 | 55.5 | 4.8 | 3709.9 | 3709.86 | 4.83412 | 0.00721196 | 56.6139
COLUMN | Z/3638 | +3.688 | 55.2 | 4.8 | 3688 | 3687.99 | 4.80565 | 0.00716945 | 56.2802
COLUMN | Z/3617 | +3.688 | 55.2 | 4.8 | 3688 | 3687.99 | 4.80565 | 0.00716945 | 56.2802
COLUMN | Z/3637 | +3.664 | 54.8 | 4.8 | 3664.5 | 3664.5 | 4.77506 | 0.00712378 | 55.9217
COLUMN | Z/3616 | +3.664 | 54.8 | 4.8 | 3664.5 | 3664.5 | 4.77506 | 0.00712378 | 55.9217
COLUMN | Z/2602 | +3.643 | 54.5 | 4.7 | 3642.7 | 3642.64 | 4.74661 | 0.00708129 | 55.5881
COLUMN | Z/2595 | +3.643 | 54.5 | 4.7 | 3642.7 | 3642.64 | 4.74661 | 0.00708129 | 55.5881
COLUMN | Z/2601 | +3.643 | 54.5 | 4.7 | 3642.7 | 3642.64 | 4.74661 | 0.00708129 | 55.5881
COLUMN | Z/2590 | +3.643 | 54.5 | 4.7 | 3642.7 | 3642.64 | 4.74661 | 0.00708129 | 55.5881
COLUMN | Z/2600 | +3.643 | 54.5 | 4.7 | 3642.7 | 3642.64 | 4.74661 | 0.00708129 | 55.5881
COLUMN | Z/2589 | +3.643 | 54.5 | 4.7 | 3642.7 | 3642.64 | 4.74661 | 0.00708129 | 55.5881

# IfcDiscreteAccessory: FASCIA STIFFENER (66)
In: Undefined
Description: PLT3*120; Material: STEEL/250
Tekla Common - Phase: 1; Class: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.1 m2; Height: 120 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.00036 m2
Name | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Length (mm) | Reference | NetArea (m2) = GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
FASCIA STIFFENER | +3.280 | +3.630 | 1 | 87.8 | 350 | PL/116 | 0.08682 | 0.000126
FASCIA STIFFENER | +3.298 | +3.648 | 1 | 87.8 | 350 | PL/116 | 0.08682 | 0.000126
2 x FASCIA STIFFENER | +3.314 | +3.664 | 1 | 87.8 | 350 | PL/116 | 0.08682 | 0.000126
FASCIA STIFFENER | +3.319 | +3.669 | 1 | 87.8 | 350 | PL/116 | 0.08682 | 0.000126
FASCIA STIFFENER | +3.270 | +3.620 | 1 | 87.8 | 350 | PL/116 | 0.08682 | 0.000126
FASCIA STIFFENER | +3.318 | +3.618 | 0.8 | 87.8 | 300 | PL/113 | 0.07452 | 0.000108
FASCIA STIFFENER | +3.338 | +3.638 | 0.8 | 87.8 | 300 | PL/113 | 0.07452 | 0.000108
FASCIA STIFFENER | +3.356 | +3.656 | 0.8 | 87.8 | 300 | PL/113 | 0.07452 | 0.000108
FASCIA STIFFENER | +3.353 | +3.703 | 1 | 87.8 | 350 | PL/116 | 0.08682 | 0.000126
FASCIA STIFFENER | +3.338 | +3.688 | 1 | 87.8 | 350 | PL/116 | 0.08682 | 0.000126
FASCIA STIFFENER | +3.315 | +3.665 | 1 | 87.8 | 350 | PL/116 | 0.08682 | 0.000126
FASCIA STIFFENER | +3.352 | +3.652 | 0.8 | 87.8 | 300 | PL/113 | 0.07452 | 0.000108
FASCIA STIFFENER | +3.368 | +3.668 | 0.8 | 87.8 | 300 | PL/113 | 0.07452 | 0.000108
2 x FASCIA STIFFENER | +3.365 | +3.665 | 0.8 | 87.8 | 300 | PL/113 | 0.07452 | 0.000108
FASCIA STIFFENER | +3.353 | +3.607 | 0.8 | 88.1 | 254 | PL/128 | 0.063204 | 0.00009144
FASCIA STIFFENER | +3.373 | +3.627 | 0.8 | 88.1 | 254 | PL/128 | 0.063204 | 0.00009144
FASCIA STIFFENER | +3.386 | +3.640 | 0.8 | 88.1 | 254 | PL/128 | 0.063204 | 0.00009144
FASCIA STIFFENER | +3.385 | +3.685 | 0.8 | 87.8 | 300 | PL/113 | 0.07452 | 0.000108
FASCIA STIFFENER | +3.389 | +3.689 | 0.8 | 87.8 | 300 | PL/113 | 0.07452 | 0.000108
FASCIA STIFFENER | +3.391 | +3.645 | 0.6 | 88.1 | 254 | PL/128 | 0.063204 | 0.00009144
2 x FASCIA STIFFENER | +3.411 | +3.665 | 0.6 | 88.1 | 254 | PL/128 | 0.063204 | 0.00009144
FASCIA STIFFENER | +3.392 | +3.595 | 0.6 | 88.3 | 203 | PL/156 | 0.050658 | 0.00007308
FASCIA STIFFENER | +3.411 | +3.614 | 0.6 | 88.3 | 203 | PL/156 | 0.050658 | 0.00007308
FASCIA STIFFENER | +3.428 | +3.631 | 0.6 | 88.3 | 203 | PL/156 | 0.050658 | 0.00007308
FASCIA STIFFENER | +3.432 | +3.686 | 0.6 | 88.1 | 254 | PL/128 | 0.063204 | 0.00009144
FASCIA STIFFENER | +3.410 | +3.664 | 0.6 | 88.1 | 254 | PL/128 | 0.063204 | 0.00009144
2 x FASCIA STIFFENER | +3.365 | +3.619 | 0.6 | 88.1 | 254 | PL/128 | 0.063204 | 0.00009144
FASCIA STIFFENER | +3.386 | +3.589 | 0.6 | 88.3 | 203 | PL/156 | 0.050658 | 0.00007308
FASCIA STIFFENER | +3.405 | +3.608 | 0.6 | 88.3 | 203 | PL/156 | 0.050658 | 0.00007308
FASCIA STIFFENER | +3.416 | +3.619 | 0.6 | 88.3 | 203 | PL/156 | 0.050658 | 0.00007308
3 x FASCIA STIFFENER | +3.291 | +3.641 | 1 | 87.8 | 350 | PL/116 | 0.08682 | 0.000126
FASCIA STIFFENER | +3.294 | +3.644 | 1 | 87.8 | 350 | PL/116 | 0.08682 | 0.000126
FASCIA STIFFENER | +3.269 | +3.619 | 1 | 87.8 | 350 | PL/116 | 0.08682 | 0.000126
FASCIA STIFFENER | +3.248 | +3.598 | 1 | 87.8 | 350 | PL/116 | 0.08682 | 0.000126
FASCIA STIFFENER | +3.319 | +3.619 | 0.8 | 87.8 | 300 | PL/113 | 0.07452 | 0.000108
FASCIA STIFFENER | +3.339 | +3.639 | 0.8 | 87.8 | 300 | PL/113 | 0.07452 | 0.000108
FASCIA STIFFENER | +3.344 | +3.644 | 0.8 | 87.8 | 300 | PL/113 | 0.07452 | 0.000108
3 x FASCIA STIFFENER | +3.293 | +3.643 | 1 | 87.8 | 350 | PL/116 | 0.08682 | 0.000126
6 x FASCIA STIFFENER | +3.343 | +3.643 | 0.8 | 87.8 | 300 | PL/113 | 0.07452 | 0.000108
FASCIA STIFFENER | +3.354 | +3.608 | 0.6 | 88.1 | 254 | PL/128 | 0.063204 | 0.00009144
FASCIA STIFFENER | +3.369 | +3.623 | 0.6 | 88.1 | 254 | PL/128 | 0.063204 | 0.00009144
4 x FASCIA STIFFENER | +3.389 | +3.643 | 0.6 | 88.1 | 254 | PL/128 | 0.063204 | 0.00009144
FASCIA STIFFENER | +3.379 | +3.633 | 0.6 | 88.1 | 254 | PL/128 | 0.063204 | 0.00009144
FASCIA STIFFENER | +3.390 | +3.593 | 0.6 | 88.3 | 203 | PL/156 | 0.050658 | 0.00007308
FASCIA STIFFENER | +3.410 | +3.613 | 0.6 | 88.3 | 203 | PL/156 | 0.050658 | 0.00007308
FASCIA STIFFENER | +3.430 | +3.633 | 0.6 | 88.3 | 203 | PL/156 | 0.050658 | 0.00007308
FASCIA STIFFENER | +3.343 | +3.597 | 0.6 | 88.1 | 254 | PL/128 | 0.063204 | 0.00009144
FASCIA STIFFENER | +3.384 | +3.587 | 0.6 | 88.3 | 203 | PL/156 | 0.050658 | 0.00007308
2 x FASCIA STIFFENER | +3.394 | +3.597 | 0.6 | 88.3 | 203 | PL/156 | 0.050658 | 0.00007308

# IfcElementAssembly (1452)
In: Undefined
PredefinedType: RIGID_FRAME
Name | ASSEMBLY_POSITION_CODE = Assembly/Cast unit position code | ASSEMBLY_POS = Assembly/Cast unit Mark | Assembly/Cast unit weight (kg) | Assembly/Cast unit bottom elevation | Assembly/Cast unit top elevation | Width (mm)
BRIDGING U-PLATE | C300-C300/BB300(Z150) | PL/2030 | 3.6 | +3.334 | +3.642 | 100
BEAM | C300-C300/BB300(Z150) | B/97 | 23.6 | +3.338 | +3.638 | 96
BRIDGING U-PLATE | C300-C300/BB350(Z150) | PL/2046(?) | 4.4 | +3.311 | +3.669 | 129
BEAM | C300-C300/BB350(Z150) | B/98(?) | 28.2 | +3.315 | +3.665 | 125
BRIDGING U-PLATE | C300-C300/BB300(Z200) | PL/2030 | 3.6 | +3.314 | +3.622 | 100
BEAM | C300-C300/BB300(Z200) | B/97 | 23.6 | +3.318 | +3.618 | 96
BRIDGING U-PLATE | C300-C300/BB350(Z200) | PL/2046 | 4.4 | +3.315 | +3.673 | 129
BEAM | C300-C300/BB350(Z200) | B/98(?) | 28.2 | +3.319 | +3.669 | 125
BRIDGING U-PLATE | C300-C300/BB350(Z100) | PL/2045 | 4.4 | +3.266 | +3.624 | 129
BEAM | C300-C300/BB350(Z100) | B/98 | 28.2 | +3.270 | +3.620 | 125
BEAM | C300-C300/BB300(Z100) | B/97 | 23.6 | +3.356 | +3.656 | 96
BRIDGING U-PLATE | C300-C300/BB300(Z100) | PL/1992 | 3.6 | +3.352 | +3.660 | 100
COLUMN | C350/BB350(Z200) | Z/3618 | 55.5 | +0.000 | +3.710 | 125
COLUMN | C350/BB350(Z150) | Z/3617 | 55.2 | +0.000 | +3.688 | 125
COLUMN | C350/BB350(Z100) | Z/3616 | 54.8 | +0.000 | +3.664 | 125
COLUMN | C300/BB350(Z200) | Z/3135 | 46.4 | +0.000 | +3.711 | 96
COLUMN | C300/BB350(Z150) | Z/3136 | 45.8 | +0.000 | +3.665 | 96
COLUMN | C300/BB350(Z100) | Z/304 | 45.3 | +0.000 | +3.620 | 96
COLUMN | C300/BB300(Z200) | Z/3135 | 46.4 | +0.000 | +3.711 | 96
COLUMN | C300/BB300(Z150) | Z/3122 | 46.1 | +0.000 | +3.689 | 96
COLUMN | C300/BB300(Z100) | Z/3121 | 45.8 | +0.000 | +3.666 | 96
COLUMN | C250/BB350(Z200) | Z/3044(?) | 29.8 | +0.000 | +3.710 | 76
COLUMN | C250/BB350(Z150) | Z/3043(?) | 29.6 | +0.000 | +3.688 | 76
COLUMN | C250/BB350(Z100) | Z/3042(?) | 29.4 | +0.000 | +3.665 | 76
COLUMN | C250/BB300(Z200) | Z/3044(?) | 29.8 | +0.000 | +3.710 | 76
COLUMN | C250/BB300(Z150) | Z/3043(?) | 29.6 | +0.000 | +3.688 | 76
COLUMN | C250/BB300(Z100) | Z/3042(?) | 29.4 | +0.000 | +3.665 | 76
COLUMN | C250/BB250(Z200) | Z/3044 | 29.8 | +0.000 | +3.710 | 76
COLUMN | C250/BB250(Z150) | Z/3043 | 29.6 | +0.000 | +3.689 | 76
COLUMN | C250/BB250(Z100) | Z/3042 | 29.4 | +0.000 | +3.665 | 76
BEAM | C250-C250/BB300(Z100) | B/93 | 19 | +3.365 | +3.665 | 96
BEAM | C250-C250/BB300(Z150) | B/93 | 19 | +3.368 | +3.668 | 96
BEAM | C250-C250/BB300(Z200) | B/93 | 19 | +3.352 | +3.652 | 96
BEAM | C250-C250/BB350(Z100) | B/103 | 28.5 | +3.315 | +3.665 | 125
BEAM | C250-C250/BB350(Z150) | B/103 | 28.5 | +3.338 | +3.688 | 125
BEAM | C250-C250/BB350(Z200) | B/103(?) | 28.5 | +3.353 | +3.703 | 125
BEAM | C350-C350/BB350(Z100) | B/99 | 27.7 | +3.314 | +3.664 | 125
BEAM | C350-C350/BB350(Z150) | B/99 | 27.7 | +3.298 | +3.648 | 125
BEAM | C350-C350/BB350(Z200) | B/99 | 27.7 | +3.280 | +3.630 | 125
BRIDGING U-PLATE | C350-C350/BB350(Z150) | PL/2034 | 4.4 | +3.294 | +3.652 | 358
BRIDGING U-PLATE | C350-C350/BB350(Z100) | PL/2034 | 4.4 | +3.310 | +3.668 | 358
BRIDGING U-PLATE | C350-C350/BB350(Z200) | PL/2047 | 4.4 | +3.276 | +3.634 | 358
RAFTER | C350-C350/BB350(Z200)> | Z/2606 | 10.8 | +3.280 | +3.773 | 125
RAFTER | C350-C350/BB350(Z150)-BB350(Z200) | Z/2606 | 10.8 | +3.299 | +3.792 | 125
RAFTER | C300-C300/BB350(Z200)> | Z/2599 | 8.9 | +3.319 | +3.761 | 96
RAFTER | C300-C300/BB350(Z150)-BB350(Z200) | Z/2599 | 8.9 | +3.314 | +3.756 | 96
RAFTER | C300-C300/BB350(Z100)-BB350(Z150) | Z/2599 | 8.9 | +3.310 | +3.752 | 96
RAFTER | C300-C300/BB300(Z200)-BB350(Z100) | Z/2599 | 8.9 | +3.319 | +3.761 | 96
RAFTER | C300-C300/BB300(Z150)-BB300(Z200) | Z/2599 | 8.9 | +3.339 | +3.781 | 96
BRIDGING U-PLATE | C250-C250/BB350(Z200) | PL/2044 | 4.4 | +3.349 | +3.707 | 129
BRIDGING U-PLATE | C250-C250/BB350(Z150) | PL/2043 | 4.4 | +3.334 | +3.692 | 129
BRIDGING U-PLATE | C250-C250/BB350(Z100) | PL/2042 | 4.4 | +3.311 | +3.669 | 129
BRIDGING U-PLATE | C250-C250/BB300(Z200) | PL/2041 | 3.6 | +3.348 | +3.656 | 100
BRIDGING U-PLATE | C250-C250/BB300(Z150) | PL/2040 | 3.6 | +3.364 | +3.672 | 100
BRIDGING U-PLATE | C250-C250/BB300(Z100) | PL/2039 | 3.6 | +3.361 | +3.669 | 100
BRIDGING U-PLATE | C250-C250/BB250(Z200) | PL/1985 | 3 | +3.349 | +3.611 | 80
BEAM | C250-C250/BB250(Z200) | B/92 | 15.3 | +3.353 | +3.607 | 76
BRIDGING U-PLATE | C250-C250/BB250(Z150) | PL/1985 | 3 | +3.369 | +3.631 | 80
BEAM | C250-C250/BB250(Z150) | B/92 | 15.3 | +3.373 | +3.627 | 76
BEAM | C250-C250/BB250(Z100) | B/92 | 15.3 | +3.386 | +3.640 | 76
