Properties of the parts of a building model (IFC2X3), part 3 of 4

# IfcElementAssembly (1452)
Name | ASSEMBLY_POSITION_CODE = Assembly/Cast unit position code | ASSEMBLY_POS = Assembly/Cast unit Mark | Assembly/Cast unit weight (kg) | Assembly/Cast unit bottom elevation | Assembly/Cast unit top elevation | Width (mm)
FASCIA STIFFENER | C350-C350/BB350(TH96) | PL/116 | 1 | +3.291 | +3.641 | 3
COLUMN | C350/BB350(TH96) | Z/2601 | 54.5 | +0.000 | +3.643 | 125
2 x FASCIA BRACKET | C350/BB350(TH75) | Z/52 | 0.2 | +3.488 | +3.645 | 157.2
FASCIA BRACKET | C350-C350/BB350(TH75) | Z/52 | 0.2 | +3.488 | +3.645 | 157.2
FASCIA STIFFENER | C350-C350/BB350(TH75) | PL/116 | 1 | +3.291 | +3.641 | 3
COLUMN | C350/BB350(TH75) | Z/2600 | 54.5 | +0.000 | +3.643 | 125
2 x PLATE | C350/BB350(TH75)-BB350(TH96) | Z/1432 | 10.1 | +3.159 | +3.746 | 128
2 x PLATE | C350/BB350(TH96)-BB350(TH120) | Z/1432 | 10.1 | +3.142 | +3.729 | 128
2 x PLATE | C350/BB350(TH120)> | Z/1432 | 10.1 | +3.123 | +3.709 | 128
BB TRUSS BRACKET | C350-C350/BB350(TH75)-BB350(TH96) | PL/1995 | 5.4 | +3.314 | +3.736 | 147.699
BB TRUSS BRACKET | C350-C350/BB350(TH75)-BB350(TH96) | PL/1996 | 5.4 | +3.314 | +3.736 | 147.699
TH | C350-C350/BB350(TH120)> | B/59 | 3 | +3.756 | +3.895 | 165
FASCIA | C350-C350/BB350(TH120) | F/16 | 8.9 | +3.491 | +3.643 | 64
BEAM | C350-C350/BB350(TH120) | B/78 | 27.7 | +3.278 | +3.628 | 125
TH | C350-C350/BB350(TH96)-BB350(TH120) | B/44 | 3 | +3.777 | +3.890 | 150
FASCIA | C350-C350/BB350(TH96) | F/16 | 8.9 | +3.491 | +3.643 | 64
BEAM | C350-C350/BB350(TH96) | B/78 | 27.7 | +3.293 | +3.643 | 125
TH | C350-C350/BB350(TH75)-BB350(TH96) | B/28 | 3 | +3.796 | +3.886 | 125
FASCIA | C350-C350/BB350(TH75) | F/16 | 8.9 | +3.491 | +3.643 | 64
BEAM | C350-C350/BB350(TH75) | B/78 | 27.7 | +3.293 | +3.643 | 125
TH | C300-C300/BB350(TH120) | B/65 | 3 | +2.981 | +3.146 | 165
TH | C300-C300/BB350(TH96) | B/54 | 3 | +2.988 | +3.138 | 150
TH | C300-C300/BB350(TH75) | B/30 | 3 | +3.001 | +3.126 | 125
TH | C300-C300/BB300(TH120) | B/65 | 3 | +2.981 | +3.146 | 165
TH | C300-C300/BB300(TH96) | B/54 | 3 | +2.988 | +3.138 | 150
TH | C300-C300/BB300(TH75) | B/30 | 3 | +3.001 | +3.126 | 125
2 x RAFTER | C300/BB350(TH120)> | Z/430 | 8.9 | +3.319 | +3.761 | 96
2 x RAFTER | C300/BB350(TH96)-BB350(TH120) | Z/430 | 8.9 | +3.314 | +3.756 | 96
2 x RAFTER | C300/BB350(TH75)-BB350(TH96) | Z/430 | 8.9 | +3.310 | +3.752 | 96
RAFTER | C300-C300/BB350(TH75)-BB350(TH96) | Z/2599 | 8.9 | +3.310 | +3.752 | 96
2 x FASCIA BRACKET | C300/BB350(TH120) | Z/2531 | 0.4 | +3.489 | +3.646 | 157.2
FASCIA BRACKET | C300-C300/BB350(TH120) | Z/2531 | 0.4 | +3.489 | +3.646 | 157.2
FASCIA STIFFENER | C300-C300/BB350(TH120) | PL/116 | 1 | +3.294 | +3.644 | 3
COLUMN | C300/BB350(TH120) | Z/2593 | 45.6 | +0.000 | +3.644 | 96
2 x FASCIA BRACKET | C300/BB350(TH96) | Z/2520 | 0.4 | +3.464 | +3.622 | 157.2
FASCIA BRACKET | C300-C300/BB350(TH96) | Z/2520 | 0.4 | +3.464 | +3.622 | 157.2
FASCIA STIFFENER | C300-C300/BB350(TH96) | PL/116 | 1 | +3.269 | +3.619 | 3
COLUMN | C300/BB350(TH96) | Z/2594 | 45.3 | +0.000 | +3.619 | 96
2 x FASCIA BRACKET | C300/BB350(TH75) | Z/52 | 0.2 | +3.443 | +3.600 | 157.2
FASCIA BRACKET | C300-C300/BB350(TH75) | Z/52 | 0.2 | +3.443 | +3.600 | 157.2
FASCIA STIFFENER | C300-C300/BB350(TH75) | PL/116 | 1 | +3.248 | +3.598 | 3
COLUMN | C300/BB350(TH75) | Z/2569 | 45 | +0.000 | +3.598 | 96
2 x PLATE | C300/BB350(TH120)> | Z/1543 | 8.9 | +3.124 | +3.700 | 99
2 x PLATE | C300/BB350(TH96)-BB350(TH120) | Z/1543 | 8.9 | +3.119 | +3.695 | 99
2 x PLATE | C300/BB350(TH75)-BB350(TH96) | Z/1543 | 8.9 | +3.115 | +3.690 | 99
BB TRUSS BRACKET | C300-C300/BB350(TH75)-BB350(TH96) | PL/1993 | 4.3 | +3.295 | +3.681 | 147.699
TH | C300-C300/BB350(TH120)> | B/65 | 3 | +3.744 | +3.883 | 165
FASCIA | C300-C300/BB350(TH120) | F/15 | 9.4 | +3.492 | +3.644 | 64
BEAM | C300-C300/BB350(TH120) | B/101 | 28.2 | +3.294 | +3.644 | 125
TH | C300-C300/BB350(TH96)-BB350(TH120) | B/54 | 3 | +3.741 | +3.854 | 150
FASCIA | C300-C300/BB350(TH96) | F/15 | 9.4 | +3.467 | +3.619 | 64
BEAM | C300-C300/BB350(TH96) | B/101 | 28.2 | +3.269 | +3.619 | 125
TH | C300-C300/BB350(TH75)-BB350(TH96) | B/30 | 3 | +3.739 | +3.829 | 125
FASCIA | C300-C300/BB350(TH75) | F/15 | 9.4 | +3.446 | +3.598 | 64
BEAM | C300-C300/BB350(TH75) | B/101 | 28.2 | +3.248 | +3.598 | 125
FASCIA STIFFENER | C300-C300/BB300(TH120) | PL/113 | 0.8 | +3.319 | +3.619 | 3
FASCIA STIFFENER | C300-C300/BB300(TH96) | PL/113 | 0.8 | +3.339 | +3.639 | 3
FASCIA STIFFENER | C300-C300/BB300(TH75) | PL/113 | 0.8 | +3.344 | +3.644 | 3
2 x RAFTER | C300/BB300(TH120)-BB350(TH75) | Z/430 | 8.9 | +3.319 | +3.761 | 96
2 x FASCIA BRACKET | C300/BB300(TH120) | Z/2531 | 0.4 | +3.489 | +3.646 | 157.2
FASCIA BRACKET | C300-C300/BB300(TH120) | Z/2531 | 0.4 | +3.489 | +3.646 | 157.2
COLUMN | C300/BB300(TH120) | Z/2593 | 45.6 | +0.000 | +3.644 | 96
2 x RAFTER | C300/BB300(TH96)-BB300(TH120) | Z/430 | 8.9 | +3.339 | +3.781 | 96
2 x FASCIA BRACKET | C300/BB300(TH96) | Z/2520 | 0.4 | +3.489 | +3.646 | 157.2
FASCIA BRACKET | C300-C300/BB300(TH96) | Z/2520 | 0.4 | +3.489 | +3.646 | 157.2
COLUMN | C300/BB300(TH96) | Z/2592 | 45.6 | +0.000 | +3.644 | 96
2 x RAFTER | C300/BB300(TH75)-BB300(TH96) | Z/430 | 8.9 | +3.356 | +3.798 | 96
RAFTER | C300-C300/BB300(TH75)-BB300(TH96) | Z/2599 | 8.9 | +3.356 | +3.798 | 96
2 x FASCIA BRACKET | C300/BB300(TH75) | Z/52 | 0.2 | +3.489 | +3.646 | 157.2
FASCIA BRACKET | C300-C300/BB300(TH75) | Z/52 | 0.2 | +3.489 | +3.646 | 157.2
COLUMN | C300/BB300(TH75) | Z/2568 | 45.6 | +0.000 | +3.644 | 96
BEAM | C300-C300/BB300(TH120) | B/102 | 23.6 | +3.319 | +3.619 | 96
2 x PLATE | C300/BB300(TH120)-BB350(TH75) | Z/1543 | 8.9 | +3.124 | +3.700 | 99
TH | C300-C300/BB300(TH120)-BB350(TH75) | B/65 | 3 | +3.732 | +3.871 | 165
FASCIA | C300-C300/BB300(TH120) | F/15 | 9.4 | +3.492 | +3.644 | 64
BEAM | C300-C300/BB300(TH96) | B/106 | 23.6 | +3.339 | +3.639 | 96
2 x PLATE | C300/BB300(TH96)-BB300(TH120) | Z/1543 | 8.9 | +3.144 | +3.719 | 99
TH | C300-C300/BB300(TH96)-BB300(TH120) | B/54 | 3 | +3.753 | +3.866 | 150
FASCIA | C300-C300/BB300(TH96) | F/15 | 9.4 | +3.492 | +3.644 | 64
BEAM | C300-C300/BB300(TH75) | B/102 | 23.6 | +3.344 | +3.644 | 96
2 x PLATE | C300/BB300(TH75)-BB300(TH96) | Z/1543 | 8.9 | +3.161 | +3.736 | 99
BB TRUSS BRACKET | C300-C300/BB300(TH75)-BB300(TH96) | PL/1991 | 4.6 | +3.355 | +3.727 | 147.699
BB TRUSS BRACKET | C300-C300/BB300(TH75)-BB300(TH96) | PL/1994 | 4.6 | +3.355 | +3.727 | 147.699
TH | C300-C300/BB300(TH75)-BB300(TH96) | B/30 | 3 | +3.772 | +3.863 | 125
FASCIA | C300-C300/BB300(TH75) | F/15 | 9.4 | +3.492 | +3.644 | 64
TH | C250-C250/BB350(TH120) | B/64 | 3 | +3.088 | +3.253 | 165
TH | C250-C250/BB350(TH96) | B/45 | 3 | +3.096 | +3.246 | 150
TH | C250-C250/BB350(TH75) | B/29 | 3 | +3.108 | +3.233 | 125
TH | C250-C250/BB300(TH120) | B/64 | 3 | +3.088 | +3.253 | 165
TH | C250-C250/BB300(TH96) | B/45 | 3 | +3.096 | +3.246 | 150
TH | C250-C250/BB300(TH75) | B/29 | 3 | +3.108 | +3.233 | 125
TH | C250-C250/BB250(TH120) | B/64 | 3 | +3.088 | +3.253 | 165
TH | C250-C250/BB250(TH96) | B/45 | 3 | +3.096 | +3.246 | 150
TH | C250-C250/BB250(TH75) | B/29 | 3 | +3.108 | +3.233 | 125
2 x RAFTER | C250/BB350(TH75)-BB350(TH96) | Z/289 | 5.9 | +3.390 | +3.790 | 76
2 x RAFTER | C250/BB350(TH96)-BB350(TH120) | Z/289 | 5.9 | +3.373 | +3.773 | 76
2 x RAFTER | C250/BB350(TH120)> | Z/289 | 5.9 | +3.354 | +3.754 | 76
RAFTER | C250-C250/BB350(TH75)-BB350(TH96) | Z/2591 | 5.9 | +3.390 | +3.790 | 76
2 x FASCIA BRACKET | C250/BB350(TH120) | Z/2531 | 0.4 | +3.489 | +3.646 | 157.2
FASCIA BRACKET | C250-C250/BB350(TH120) | Z/2531 | 0.4 | +3.489 | +3.646 | 157.2
COLUMN | C250/BB350(TH120) | Z/2580 | 29.2 | +0.000 | +3.643 | 76
FASCIA STIFFENER | C250-C250/BB350(TH120) | PL/116 | 1 | +3.293 | +3.643 | 3
2 x FASCIA BRACKET | C250/BB350(TH96) | Z/2520 | 0.4 | +3.489 | +3.646 | 157.2
FASCIA BRACKET | C250-C250/BB350(TH96) | Z/2520 | 0.4 | +3.489 | +3.646 | 157.2
COLUMN | C250/BB350(TH96) | Z/2579 | 29.2 | +0.000 | +3.643 | 76
FASCIA STIFFENER | C250-C250/BB350(TH96) | PL/116 | 1 | +3.293 | +3.643 | 3
2 x FASCIA BRACKET | C250/BB350(TH75) | Z/52 | 0.2 | +3.489 | +3.646 | 157.2
FASCIA BRACKET | C250-C250/BB350(TH75) | Z/52 | 0.2 | +3.489 | +3.646 | 157.2
COLUMN | C250/BB350(TH75) | Z/2557 | 29.2 | +0.000 | +3.643 | 76
FASCIA STIFFENER | C250-C250/BB350(TH75) | PL/116 | 1 | +3.293 | +3.643 | 3
2 x PLATE | C250/BB350(TH75) | Z/1289 | 5.2 | +3.275 | +3.702 | 79
2 x PLATE | C250/BB350(TH96) | Z/1289 | 5.2 | +3.258 | +3.685 | 79
2 x PLATE | C250/BB350(TH120) | Z/1289 | 5.2 | +3.238 | +3.665 | 79
FASCIA | C250-C250/BB350(TH120) | F/14 | 8.1 | +3.491 | +3.643 | 64
TH | C250-C250/BB350(TH120)> | B/64 | 3 | +3.737 | +3.876 | 165
BEAM | C250-C250/BB350(TH120) | B/100 | 28.5 | +3.293 | +3.643 | 125
FASCIA | C250-C250/BB350(TH96) | F/14 | 8.1 | +3.491 | +3.643 | 64
TH | C250-C250/BB350(TH96)-BB350(TH120) | B/45 | 3 | +3.758 | +3.871 | 150
BEAM | C250-C250/BB350(TH96) | B/100 | 28.5 | +3.293 | +3.643 | 125
TH | C250-C250/BB350(TH75)-BB350(TH96) | B/29 | 3 | +3.777 | +3.867 | 125
FASCIA | C250-C250/BB350(TH75) | F/14 | 8.1 | +3.491 | +3.643 | 64
BEAM | C250-C250/BB350(TH75) | B/100 | 28.5 | +3.293 | +3.643 | 125
2 x RAFTER | C250/BB300(TH75)-BB300(TH96) | Z/289 | 5.9 | +3.390 | +3.790 | 76
2 x RAFTER | C250/BB300(TH96)-BB300(TH120) | Z/289 | 5.9 | +3.373 | +3.773 | 76
2 x RAFTER | C250/BB300(TH120)-BB350(TH75) | Z/289 | 5.9 | +3.354 | +3.754 | 76
RAFTER | C250-C250/BB300(TH75)-BB300(TH96) | Z/2591 | 5.9 | +3.390 | +3.790 | 76
2 x FASCIA BRACKET | C250/BB300(TH120) | Z/2531 | 0.4 | +3.489 | +3.646 | 157.2
FASCIA BRACKET | C250-C250/BB300(TH120) | Z/2531 | 0.4 | +3.489 | +3.646 | 157.2
COLUMN | C250/BB300(TH120) | Z/2583 | 29.2 | +0.000 | +3.643 | 76
FASCIA STIFFENER | C250-C250/BB300(TH120) | PL/113 | 0.8 | +3.343 | +3.643 | 3
2 x FASCIA BRACKET | C250/BB300(TH96) | Z/2520 | 0.4 | +3.489 | +3.646 | 157.2
FASCIA BRACKET | C250-C250/BB300(TH96) | Z/2520 | 0.4 | +3.489 | +3.646 | 157.2
COLUMN | C250/BB300(TH96) | Z/2582 | 29.2 | +0.000 | +3.643 | 76
FASCIA STIFFENER | C250-C250/BB300(TH96) | PL/113 | 0.8 | +3.343 | +3.643 | 3
2 x FASCIA BRACKET | C250/BB300(TH75) | Z/52 | 0.2 | +3.489 | +3.646 | 157.2
FASCIA BRACKET | C250-C250/BB300(TH75) | Z/52 | 0.2 | +3.489 | +3.646 | 157.2
COLUMN | C250/BB300(TH75) | Z/2581 | 29.2 | +0.000 | +3.643 | 76
FASCIA STIFFENER | C250-C250/BB300(TH75) | PL/113 | 0.8 | +3.343 | +3.643 | 3
2 x PLATE | C250/BB300(TH75) | Z/1289 | 5.2 | +3.275 | +3.702 | 79
2 x PLATE | C250/BB300(TH96) | Z/1289 | 5.2 | +3.258 | +3.685 | 79
2 x PLATE | C250/BB300(TH120) | Z/1289 | 5.2 | +3.238 | +3.665 | 79
BB TRUSS BRACKET | C250-C250/BB300(TH75) | PL/1983 | 3 | +3.377 | +3.690 | 147.999
BB TRUSS BRACKET | C250-C250/BB300(TH75) | PL/1988 | 3 | +3.377 | +3.690 | 147.999
TH | C250-C250/BB300(TH120)-BB350(TH75) | B/64 | 3 | +3.737 | +3.876 | 165
FASCIA | C250-C250/BB300(TH120) | F/14 | 8.1 | +3.491 | +3.643 | 64
BEAM | C250-C250/BB300(TH120) | B/72 | 19 | +3.343 | +3.643 | 96
TH | C250-C250/BB300(TH96)-BB300(TH120) | B/45 | 3 | +3.758 | +3.871 | 150
FASCIA | C250-C250/BB300(TH96) | F/14 | 8.1 | +3.491 | +3.643 | 64
BEAM | C250-C250/BB300(TH96) | B/72 | 19 | +3.343 | +3.643 | 96
TH | C250-C250/BB300(TH75)-BB300(TH96) | B/29 | 3 | +3.777 | +3.867 | 125
FASCIA | C250-C250/BB300(TH75) | F/14 | 8.1 | +3.491 | +3.643 | 64
BEAM | C250-C250/BB300(TH75) | B/72 | 19 | +3.343 | +3.643 | 96
BEAM | C250-C250/BB250(TH75) | B/92 | 15.3 | +3.389 | +3.643 | 76
BEAM | C250-C250/BB250(TH96) | B/92 | 15.3 | +3.369 | +3.623 | 76
BEAM | C250-C250/BB250(TH120) | B/92 | 15.3 | +3.354 | +3.608 | 76
2 x FASCIA BRACKET | C250/BB250(TH120) | Z/2531 | 0.4 | +3.489 | +3.646 | 157.2
FASCIA BRACKET | C250-C250/BB250(TH120) | Z/2531 | 0.4 | +3.489 | +3.646 | 157.2
COLUMN | C250/BB250(TH120) | Z/2580 | 29.2 | +0.000 | +3.643 | 76
2 x RAFTER | C250/BB250(TH120)-BB300(TH75) | Z/289 | 5.9 | +3.354 | +3.754 | 76
FASCIA STIFFENER | C250-C250/BB250(TH120) | PL/128 | 0.6 | +3.354 | +3.608 | 3
2 x FASCIA BRACKET | C250/BB250(TH96) | Z/2520 | 0.4 | +3.489 | +3.646 | 157.2
FASCIA BRACKET | C250-C250/BB250(TH96) | Z/2520 | 0.4 | +3.489 | +3.646 | 157.2
COLUMN | C250/BB250(TH96) | Z/2579 | 29.2 | +0.000 | +3.643 | 76
2 x RAFTER | C250/BB250(TH96)-BB250(TH120) | Z/289 | 5.9 | +3.373 | +3.773 | 76
FASCIA STIFFENER | C250-C250/BB250(TH96) | PL/128 | 0.6 | +3.369 | +3.623 | 3
2 x FASCIA BRACKET | C250/BB250(TH75) | Z/52 | 0.2 | +3.489 | +3.646 | 157.2
FASCIA BRACKET | C250-C250/BB250(TH75) | Z/52 | 0.2 | +3.489 | +3.646 | 157.2
RAFTER | C250-C250/BB250(TH75)-BB250(TH96) | Z/2591 | 5.9 | +3.390 | +3.790 | 76
COLUMN | C250/BB250(TH75) | Z/2557 | 29.2 | +0.000 | +3.643 | 76
2 x RAFTER | C250/BB250(TH75)-BB250(TH96) | Z/289 | 5.9 | +3.390 | +3.790 | 76
FASCIA STIFFENER | C250-C250/BB250(TH75) | PL/128 | 0.6 | +3.389 | +3.643 | 3
FASCIA | C250-C250/BB250(TH120) | F/12 | 7.9 | +3.491 | +3.643 | 64
TH | C250-C250/BB250(TH120)-BB300(TH75) | B/64 | 3 | +3.703 | +3.842 | 165
2 x PLATE | C250/BB250(TH120) | Z/1289 | 5.2 | +3.238 | +3.666 | 79
2 x BRIDGING BRACKET | C250/BB250(TH120) | PL/152 | 1.5 | +3.371 | +3.591 | 6
BEAM | C250-C250/BB250(TH120) | B/70 | 15.3 | +3.354 | +3.608 | 76
FASCIA | C250-C250/BB250(TH96) | F/12 | 7.9 | +3.491 | +3.643 | 64
TH | C250-C250/BB250(TH96)-BB250(TH120) | B/45 | 3 | +3.724 | +3.838 | 150
2 x PLATE | C250/BB250(TH96) | Z/1289 | 5.2 | +3.258 | +3.685 | 79
2 x BRIDGING BRACKET | C250/BB250(TH96) | PL/152 | 1.5 | +3.386 | +3.606 | 6
BEAM | C250-C250/BB250(TH96) | B/70 | 15.3 | +3.369 | +3.623 | 76
FASCIA | C250-C250/BB250(TH75) | F/12 | 7.9 | +3.491 | +3.643 | 64
BB TRUSS BRACKET | C250-C250/BB250(TH75) | PL/1982 | 3.1 | +3.389 | +3.690 | 147.999
TH | C250-C250/BB250(TH75)-BB250(TH96) | B/29 | 3 | +3.744 | +3.834 | 125
2 x PLATE | C250/BB250(TH75) | Z/1289 | 5.2 | +3.275 | +3.702 | 79
2 x BRIDGING BRACKET | C250/BB250(TH75) | PL/152 | 1.5 | +3.406 | +3.626 | 6
BEAM | C250-C250/BB250(TH75) | B/70 | 15.3 | +3.389 | +3.643 | 76
GIRT | C200-C200/BB300(TH120) | G/5 | 4.6 | +3.056 | +3.221 | 165
GIRT | C200-C200/BB300(TH96) | G/4 | 4.6 | +3.063 | +3.213 | 150
GIRT | C200-C200/BB300(TH75) | G/3 | 4.6 | +3.076 | +3.201 | 125
GIRT | C200-C200/BB250(TH120) | G/5 | 4.6 | +3.056 | +3.221 | 165
GIRT | C200-C200/BB250(TH96) | G/4 | 4.6 | +3.063 | +3.213 | 150
GIRT | C200-C200/BB250(TH75) | G/3 | 4.6 | +3.076 | +3.201 | 125
GIRT | C200-C200/BB200(TH120) | G/5 | 4.6 | +3.056 | +3.221 | 165
GIRT | C200-C200/BB200(TH96) | G/4 | 4.6 | +3.063 | +3.213 | 150
GIRT | C200-C200/BB200(TH75) | G/3 | 4.6 | +3.076 | +3.201 | 125
2 x RAFTER | C200/BB300(TH120)-BB350(TH75) | R/92 | 3.9 | +3.393 | +3.706 | 76
2 x RAFTER | C200/BB300(TH96)-BB300(TH120) | R/92 | 3.9 | +3.412 | +3.725 | 76
2 x RAFTER | C200/BB300(TH75)-BB300(TH96) | R/92 | 3.9 | +3.429 | +3.742 | 76
COLUMN | C200/BB300(TH120) | C/58 | 25.8 | +0.000 | +3.643 | 76
FASCIA STIFFENER | C200-C200/BB300(TH120) | PL/113 | 0.8 | +3.343 | +3.643 | 3
COLUMN | C200/BB300(TH96) | C/57 | 25.8 | +0.000 | +3.643 | 76
FASCIA STIFFENER | C200-C200/BB300(TH96) | PL/113 | 0.8 | +3.343 | +3.643 | 3
COLUMN | C200/BB300(TH75) | C/56 | 25.8 | +0.000 | +3.643 | 76
FASCIA STIFFENER | C200-C200/BB300(TH75) | PL/113 | 0.8 | +3.343 | +3.643 | 3
2 x PLATE | C200/BB300(TH120) | Z/227 | 3.1 | +3.323 | +3.637 | 79
2 x PLATE | C200/BB300(TH96) | Z/227 | 3.1 | +3.343 | +3.657 | 79
2 x PLATE | C200/BB300(TH75) | Z/227 | 3.1 | +3.360 | +3.674 | 79
PURLIN | C200-C200/BB300(TH120)-BB350(TH75) | PU/6 | 4.6 | +3.689 | +3.828 | 165
FASCIA | C200-C200/BB300(TH120) | F/75 | 8.9 | +3.491 | +3.643 | 64
BRIDGING BEAM | C200-C200/BB300(TH120) | BB/6 | 19 | +3.343 | +3.643 | 96
PURLIN | C200-C200/BB300(TH96)-BB300(TH120) | PU/5 | 4.6 | +3.710 | +3.823 | 150
FASCIA | C200-C200/BB300(TH96) | F/75 | 8.9 | +3.491 | +3.643 | 64
BRIDGING BEAM | C200-C200/BB300(TH96) | BB/6 | 19 | +3.343 | +3.643 | 96
PURLIN | C200-C200/BB300(TH75)-BB300(TH96) | PU/4 | 4.6 | +3.729 | +3.819 | 125
FASCIA | C200-C200/BB300(TH75) | F/75 | 8.9 | +3.491 | +3.643 | 64
BRIDGING BEAM | C200-C200/BB300(TH75) | BB/6 | 19 | +3.343 | +3.643 | 96
2 x RAFTER | C200/BB250(TH120)-BB300(TH75) | R/92 | 3.9 | +3.393 | +3.706 | 76
2 x RAFTER | C200/BB250(TH96)-BB250(TH120) | R/92 | 3.9 | +3.412 | +3.725 | 76
2 x RAFTER | C200/BB250(TH75)-BB250(TH96) | R/92 | 3.9 | +3.429 | +3.742 | 76
BRIDGING BEAM | C200-C200/BB250(TH120) | BB/3 | 15.3 | +3.379 | +3.633 | 76
BRIDGING BEAM | C200-C200/BB250(TH96) | BB/3 | 15.3 | +3.389 | +3.643 | 76
BRIDGING BEAM | C200-C200/BB250(TH75) | BB/3 | 15.3 | +3.389 | +3.643 | 76
COLUMN | C200/BB250(TH120) | C/55 | 25.8 | +0.000 | +3.643 | 76
FASCIA STIFFENER | C200-C200/BB250(TH120) | PL/128 | 0.6 | +3.379 | +3.633 | 3
COLUMN | C200/BB250(TH96) | C/54 | 25.8 | +0.000 | +3.643 | 76
FASCIA STIFFENER | C200-C200/BB250(TH96) | PL/128 | 0.6 | +3.389 | +3.643 | 3
COLUMN | C200/BB250(TH75) | C/53 | 25.8 | +0.000 | +3.643 | 76
FASCIA STIFFENER | C200-C200/BB250(TH75) | PL/128 | 0.6 | +3.389 | +3.643 | 3
2 x PLATE | C200/BB250(TH120) | Z/227 | 3.1 | +3.323 | +3.637 | 79
2 x PLATE | C200/BB250(TH96) | Z/227 | 3.1 | +3.343 | +3.657 | 79
2 x PLATE | C200/BB250(TH75) | Z/227 | 3.1 | +3.360 | +3.674 | 79
2 x BRIDGING BRACKET | C200/BB250(TH120) | PL/152 | 1.5 | +3.396 | +3.616 | 6
2 x BRIDGING BRACKET | C200/BB250(TH96) | PL/152 | 1.5 | +3.406 | +3.626 | 6
2 x BRIDGING BRACKET | C200/BB250(TH75) | PL/152 | 1.5 | +3.406 | +3.626 | 6
PURLIN | C200-C200/BB250(TH120)-BB300(TH75) | PU/6 | 4.6 | +3.689 | +3.828 | 165
FASCIA | C200-C200/BB250(TH120) | F/75 | 8.9 | +3.491 | +3.643 | 64
BRIDGING BEAM | C200-C200/BB250(TH120) | BB/4 | 15.3 | +3.379 | +3.633 | 76
PURLIN | C200-C200/BB250(TH96)-BB250(TH120) | PU/5 | 4.6 | +3.710 | +3.823 | 150
FASCIA | C200-C200/BB250(TH96) | F/75 | 8.9 | +3.491 | +3.643 | 64
BRIDGING BEAM | C200-C200/BB250(TH96) | BB/4 | 15.3 | +3.389 | +3.643 | 76
PURLIN | C200-C200/BB250(TH75)-BB250(TH96) | PU/4 | 4.6 | +3.729 | +3.819 | 125
FASCIA | C200-C200/BB250(TH75) | F/75 | 8.9 | +3.491 | +3.643 | 64
BRIDGING BEAM | C200-C200/BB250(TH75) | BB/4 | 15.3 | +3.389 | +3.643 | 76
BRIDGING BEAM | C200-C200/BB200(TH75) | BB/1 | 13.5 | +3.430 | +3.633 | 76
BRIDGING BEAM | C200-C200/BB200(TH96) | BB/1 | 13.5 | +3.410 | +3.613 | 76
BRIDGING BEAM | C200-C200/BB200(TH120) | BB/1 | 13.5 | +3.390 | +3.593 | 76
RAFTER | C200-C200/BB200(TH75)-BB200(TH96) | R/93 | 3.9 | +3.429 | +3.742 | 76
BRIDGING U-PLATE | C200-C200/BB200(TH75) | PL/2002 | 2.6 | +3.426 | +3.637 | 211
FASCIA STIFFENER | C200-C200/BB200(TH120) | PL/156 | 0.6 | +3.390 | +3.593 | 3
2 x RAFTER | C200/BB200(TH120)-BB250(TH75) | R/92 | 3.9 | +3.393 | +3.706 | 76
COLUMN | C200/BB200(TH120) | C/55 | 25.8 | +0.000 | +3.643 | 76
FASCIA STIFFENER | C200-C200/BB200(TH96) | PL/156 | 0.6 | +3.410 | +3.613 | 3
2 x RAFTER | C200/BB200(TH96)-BB200(TH120) | R/92 | 3.9 | +3.412 | +3.725 | 76
COLUMN | C200/BB200(TH96) | C/54 | 25.8 | +0.000 | +3.643 | 76
FASCIA STIFFENER | C200-C200/BB200(TH75) | PL/156 | 0.6 | +3.430 | +3.633 | 3
2 x RAFTER | C200/BB200(TH75)-BB200(TH96) | R/92 | 3.9 | +3.429 | +3.742 | 76
COLUMN | C200/BB200(TH75) | C/53 | 25.8 | +0.000 | +3.643 | 76
BB TRUSS BRACKET | C200-C200/BB200(TH75) | PL/1975 | 1.8 | +3.430 | +3.662 | 147.999
BB TRUSS BRACKET | C200-C200/BB200(TH75) | PL/1979 | 1.8 | +3.430 | +3.662 | 147.999
2 x BRIDGING BRACKET | C200/BB200(TH120) | PL/214 | 1.2 | +3.407 | +3.577 | 6
2 x PLATE | C200/BB200(TH120) | Z/227 | 3.1 | +3.323 | +3.637 | 79
PURLIN | C200-C200/BB200(TH120)-BB250(TH75) | PU/6 | 4.6 | +3.689 | +3.828 | 165
FASCIA | C200-C200/BB200(TH120) | F/75 | 8.9 | +3.491 | +3.643 | 64
BRIDGING BEAM | C200-C200/BB200(TH120) | BB/2 | 13.5 | +3.390 | +3.593 | 76
2 x BRIDGING BRACKET | C200/BB200(TH96) | PL/214 | 1.2 | +3.427 | +3.597 | 6
2 x PLATE | C200/BB200(TH96) | Z/227 | 3.1 | +3.343 | +3.657 | 79
PURLIN | C200-C200/BB200(TH96)-BB200(TH120) | PU/5 | 4.6 | +3.710 | +3.823 | 150
FASCIA | C200-C200/BB200(TH96) | F/75 | 8.9 | +3.491 | +3.643 | 64
BRIDGING BEAM | C200-C200/BB200(TH96) | BB/2 | 13.5 | +3.410 | +3.613 | 76
2 x BRIDGING BRACKET | C200/BB200(TH75) | PL/214 | 1.2 | +3.447 | +3.617 | 6
2 x PLATE | C200/BB200(TH75) | Z/227 | 3.1 | +3.360 | +3.674 | 79
PURLIN | C200-C200/BB200(TH75)-BB200(TH96) | PU/4 | 4.6 | +3.729 | +3.819 | 125
FASCIA | C200-C200/BB200(TH75) | F/75 | 8.9 | +3.491 | +3.643 | 64
BRIDGING BEAM | C200-C200/BB200(TH75) | BB/2 | 13.5 | +3.430 | +3.633 | 76
TH | C150-C150/BB250(TH120) | B/62 | 3 | +3.097 | +3.262 | 165
TH | C150-C150/BB250(TH96) | B/35 | 3 | +3.104 | +3.254 | 150
TH | C150-C150/BB250(TH75) | B/27 | 3 | +3.117 | +3.242 | 125
TH | C150-C150/BB200(TH120) | B/62 | 3 | +3.097 | +3.262 | 165
TH | C150-C150/BB200(TH96) | B/35 | 3 | +3.104 | +3.254 | 150
TH | C150-C150/BB200(TH75) | B/27 | 3 | +3.117 | +3.242 | 125
BEAM | C150-C150/BB250(TH120) | B/80 | 15.3 | +3.389 | +3.643 | 76
BEAM | C150-C150/BB250(TH96) | B/80 | 15.3 | +3.365 | +3.619 | 76
BEAM | C150-C150/BB250(TH75) | B/80 | 15.3 | +3.343 | +3.597 | 76
2 x RAFTER | C150/BB250(TH75)-BB250(TH96) | Z/222 | 2.6 | +3.422 | +3.668 | 64
2 x RAFTER | C150/BB250(TH96)-BB250(TH120) | Z/222 | 2.6 | +3.427 | +3.672 | 64
2 x RAFTER | C150/BB250(TH120)-BB300(TH75) | Z/222 | 2.6 | +3.432 | +3.677 | 64
BEAM | C150-C150/BB250(TH120) | B/91 | 15.3 | +3.389 | +3.643 | 76
BEAM | C150-C150/BB250(TH96) | B/91 | 15.3 | +3.365 | +3.619 | 76
BEAM | C150-C150/BB250(TH75) | B/91 | 15.3 | +3.343 | +3.597 | 76
FASCIA STIFFENER | C150-C150/BB250(TH120) | PL/128 | 0.6 | +3.389 | +3.643 | 3
2 x FASCIA BRACKET | C150/BB250(TH120) | Z/2531 | 0.4 | +3.489 | +3.646 | 157.2
FASCIA BRACKET | C150-C150/BB250(TH120) | Z/2531 | 0.4 | +3.489 | +3.646 | 157.2
COLUMN | C150/BB250(TH120) | Z/1593 | 20.2 | +0.000 | +3.643 | 64
FASCIA STIFFENER | C150-C150/BB250(TH96) | PL/128 | 0.6 | +3.365 | +3.619 | 3
2 x FASCIA BRACKET | C150/BB250(TH96) | Z/2520 | 0.4 | +3.464 | +3.621 | 157.2
FASCIA BRACKET | C150-C150/BB250(TH96) | Z/2520 | 0.4 | +3.464 | +3.621 | 157.2
COLUMN | C150/BB250(TH96) | Z/1584 | 20.2 | +0.000 | +3.619 | 64
FASCIA STIFFENER | C150-C150/BB250(TH75) | PL/128 | 0.6 | +3.343 | +3.597 | 3
2 x FASCIA BRACKET | C150/BB250(TH75) | Z/52 | 0.2 | +3.443 | +3.600 | 157.2
FASCIA BRACKET | C150-C150/BB250(TH75) | Z/52 | 0.2 | +3.443 | +3.600 | 157.2
COLUMN | C150/BB250(TH75) | Z/368 | 20.1 | +0.000 | +3.597 | 64
2 x PLATE | C150/BB250(TH75) | Z/220 | 2.5 | +3.314 | +3.617 | 67
2 x PLATE | C150/BB250(TH96) | Z/2518 | 2.5 | +3.319 | +3.621 | 67
2 x PLATE | C150/BB250(TH120) | Z/2519 | 2.5 | +3.324 | +3.626 | 67
2 x BRIDGING BRACKET | C150/BB250(TH120) | PL/152 | 1.5 | +3.406 | +3.626 | 6
2 x BRIDGING BRACKET | C150/BB250(TH96) | PL/152 | 1.5 | +3.382 | +3.602 | 6
2 x BRIDGING BRACKET | C150/BB250(TH75) | PL/152 | 1.5 | +3.360 | +3.580 | 6
TH | C150-C150/BB250(TH75)-BB250(TH96) | B/27 | 3 | +3.655 | +3.745 | 125
TH | C150-C150/BB250(TH120)-BB300(TH75) | B/62 | 3 | +3.660 | +3.799 | 165
FASCIA | C150-C150/BB250(TH120) | F/11 | 7.7 | +3.491 | +3.643 | 64
TH | C150-C150/BB250(TH96)-BB250(TH120) | B/35 | 3 | +3.656 | +3.770 | 150
FASCIA | C150-C150/BB250(TH96) | F/11 | 7.7 | +3.467 | +3.619 | 64
FASCIA | C150-C150/BB250(TH75) | F/11 | 7.7 | +3.445 | +3.597 | 64
BEAM | C150-C150/BB200(TH120) | B/15 | 13.6 | +3.384 | +3.587 | 76
BEAM | C150-C150/BB200(TH96) | B/15 | 13.6 | +3.394 | +3.597 | 76
BEAM | C150-C150/BB200(TH75) | B/15 | 13.6 | +3.394 | +3.597 | 76
BRIDGING U-PLATE | C150-C150/BB200(TH75) | PL/1660 | 2.6 | +3.390 | +3.601 | 211
RAFTER | C150-C150/BB200(TH75)-BB200(TH96) | Z/2555 | 2.6 | +3.422 | +3.668 | 64
BEAM | C150-C150/BB200(TH120) | B/38 | 13.6 | +3.384 | +3.587 | 76
2 x RAFTER | C150/BB200(TH120)-BB250(TH75) | Z/222 | 2.6 | +3.386 | +3.631 | 64
FASCIA STIFFENER | C150-C150/BB200(TH120) | PL/156 | 0.6 | +3.384 | +3.587 | 3
2 x FASCIA BRACKET | C150/BB200(TH120) | Z/2531 | 0.4 | +3.443 | +3.600 | 157.2
FASCIA BRACKET | C150-C150/BB200(TH120) | Z/2531 | 0.4 | +3.443 | +3.600 | 157.2
COLUMN | C150/BB200(TH120) | Z/1582 | 20.1 | +0.000 | +3.597 | 64
BEAM | C150-C150/BB200(TH96) | B/38 | 13.6 | +3.394 | +3.597 | 76
2 x RAFTER | C150/BB200(TH96)-BB200(TH120) | Z/222 | 2.6 | +3.405 | +3.651 | 64
FASCIA STIFFENER | C150-C150/BB200(TH96) | PL/156 | 0.6 | +3.394 | +3.597 | 3
2 x FASCIA BRACKET | C150/BB200(TH96) | Z/2520 | 0.4 | +3.443 | +3.600 | 157.2
FASCIA BRACKET | C150-C150/BB200(TH96) | Z/2520 | 0.4 | +3.443 | +3.600 | 157.2
COLUMN | C150/BB200(TH96) | Z/377 | 20.1 | +0.000 | +3.597 | 64
BEAM | C150-C150/BB200(TH75) | B/38 | 13.6 | +3.394 | +3.597 | 76
2 x RAFTER | C150/BB200(TH75)-BB200(TH96) | Z/222 | 2.6 | +3.422 | +3.668 | 64
FASCIA STIFFENER | C150-C150/BB200(TH75) | PL/156 | 0.6 | +3.394 | +3.597 | 3
2 x FASCIA BRACKET | C150/BB200(TH75) | Z/52 | 0.2 | +3.443 | +3.600 | 157.2
FASCIA BRACKET | C150-C150/BB200(TH75) | Z/52 | 0.2 | +3.443 | +3.600 | 157.2
COLUMN | C150/BB200(TH75) | Z/368 | 20.1 | +0.000 | +3.597 | 64
2 x BRIDGING BRACKET | C150/BB200(TH120) | PL/214 | 1.2 | +3.401 | +3.571 | 6
2 x PLATE | C150/BB200(TH120) | Z/2519 | 2.5 | +3.278 | +3.580 | 67
TH | C150-C150/BB200(TH120)-BB250(TH75) | B/62 | 3 | +3.614 | +3.753 | 165
FASCIA | C150-C150/BB200(TH120) | F/11 | 7.7 | +3.445 | +3.597 | 64
2 x BRIDGING BRACKET | C150/BB200(TH96) | PL/214 | 1.2 | +3.411 | +3.581 | 6
2 x PLATE | C150/BB200(TH96) | Z/2518 | 2.5 | +3.297 | +3.600 | 67
TH | C150-C150/BB200(TH96)-BB200(TH120) | B/35 | 3 | +3.635 | +3.749 | 150
FASCIA | C150-C150/BB200(TH96) | F/11 | 7.7 | +3.445 | +3.597 | 64
2 x BRIDGING BRACKET | C150/BB200(TH75) | PL/214 | 1.2 | +3.411 | +3.581 | 6
2 x PLATE | C150/BB200(TH75) | Z/220 | 2.5 | +3.314 | +3.617 | 67
TH | C150-C150/BB200(TH75)-BB200(TH96) | B/27 | 3 | +3.655 | +3.745 | 125
FASCIA | C150-C150/BB200(TH75) | F/11 | 7.7 | +3.445 | +3.597 | 64

# IfcMechanicalFastener: Bolt assembly (1596)
In: Undefined
Tekla Bolt - Location: Site
Name | NominalDiameter (mm) = Washer diameter (mm) = Bolt size (mm) | NominalLength (mm) = Bolt length (mm) | Material = Bolt standard | Washer count | Washer type | Washer name | Nut count = Bolt count | Nut type | Nut name | Slotted hole y (mm) | Slotted hole x (mm) | Bolt hole diameter (mm) | Bolt Name
72 x Bolt assembly | 16 | 35 | 8.8S | 4 | HARD | WASHERM16-HARD | 4 | 8.8-HEX | NUTM16-8.8-HEX | 8 | 4 | 22 | BOLTM16*35
108 x Bolt assembly | 16 | 40 | 8.8S | 3 | HARD | WASHERM16-HARD | 3 | 8.8-HEX | NUTM16-8.8-HEX | 0 | 0 | 22 | BOLTM16*40
72 x Bolt assembly | 16 | 35 | 8.8S | 3 | HARD | WASHERM16-HARD | 3 | 8.8-HEX | NUTM16-8.8-HEX | 0 | 0 | 18 | BOLTM16*35
126 x Bolt assembly | 16 | 40 | 8.8S | 4 | HARD | WASHERM16-HARD | 4 | 8.8-HEX | NUTM16-8.8-HEX | 0 | 0 | 18 | BOLTM16*40
18 x Bolt assembly | 16 | 40 | 8.8S | 6 | HARD | WASHERM16-HARD | 6 | 8.8-HEX | NUTM16-8.8-HEX | 0 | 0 | 18 | BOLTM16*40
36 x Bolt assembly | 16 | 40 | 8.8S | 6 | HARD | WASHERM16-HARD | 6 | 8.8-HEX | NUTM16-8.8-HEX | 4 | 8 | 18 | BOLTM16*40
36 x Bolt assembly | 16 | 40 | 8.8S | 6 | HARD | WASHERM16-HARD | 6 | 8.8-HEX | NUTM16-8.8-HEX | 8 | 4 | 18 | BOLTM16*40
354 x Bolt assembly | 5 | 25 | TEK_16TPIM | 4 | UNDEF_WASH | UNDEFINED_WASHER5 | 2 | UNDEF_NUT | UNDEFINED_NUT10G | 0 | 0 | 7 | TEKSCREW_M5*25
127 x Bolt assembly | 5 | 25 | TEK_16TPIM | 8 | UNDEF_WASH | UNDEFINED_WASHER5 | 4 | UNDEF_NUT | UNDEFINED_NUT10G | 0 | 0 | 7 | TEKSCREW_M5*25
132 x Bolt assembly | 5 | 25 | TEK_16TPIM | 2 | UNDEF_WASH | UNDEFINED_WASHER5 | 2 | UNDEF_NUT | UNDEFINED_NUT10G | 0 | 0 | 7 | TEKSCREW_M5*25
36 x Bolt assembly | 16 | 35 | 8.8S | 4 | HARD | WASHERM16-HARD | 4 | 8.8-HEX | NUTM16-8.8-HEX | 4 | 8 | 18 | BOLTM16*35
36 x Bolt assembly | 16 | 35 | 8.8S | 4 | HARD | WASHERM16-HARD | 4 | 8.8-HEX | NUTM16-8.8-HEX | 8 | 4 | 18 | BOLTM16*35
18 x Bolt assembly | 5 | 25 | TEK_16TPIM | 16 | UNDEF_WASH | UNDEFINED_WASHER5 | 4 | UNDEF_NUT | UNDEFINED_NUT10G | 0 | 0 | 7 | TEKSCREW_M5*25
36 x Bolt assembly | 12 | 30 | PB1230 | 3 | FLAT | WASHERM12-FLAT | 3 | 4.6-HEX | NUTM12-4.6-HEX | 0 | 0 | 14 | BOLTPB1230
60 x Bolt assembly | 12 | 25 | 8.8S | 4 | HARD | WASHERM12-HARD | 4 | 8.8-HEX | NUTM12-8.8-HEX | 8 | 4 | 18 | BOLTM12*25
24 x Bolt assembly | 12 | 30 | PB1230 | 3 | FLAT | WASHERM12-FLAT | 3 | 4.6-HEX | NUTM12-4.6-HEX | 0 | 0 | 18 | BOLTPB1230
30 x Bolt assembly | 12 | 35 | 8.8S | 4 | HARD | WASHERM12-HARD | 4 | 8.8-HEX | NUTM12-8.8-HEX | 0 | 0 | 14 | BOLTM12*35
60 x Bolt assembly | 12 | 30 | 8.8S | 4 | HARD | WASHERM12-HARD | 4 | 8.8-HEX | NUTM12-8.8-HEX | 4 | 8 | 14 | BOLTM12*30
60 x Bolt assembly | 12 | 30 | 8.8S | 4 | HARD | WASHERM12-HARD | 4 | 8.8-HEX | NUTM12-8.8-HEX | 8 | 4 | 14 | BOLTM12*30
36 x Bolt assembly | 12 | 30 | PB1230 | 4 | FLAT | WASHERM12-FLAT | 4 | 4.6-HEX | NUTM12-4.6-HEX | 4 | 0 | 14 | BOLTPB1230
24 x Bolt assembly | 12 | 30 | PB1230 | 3 | FLAT | WASHERM12-FLAT | 3 | 4.6-HEX | NUTM12-4.6-HEX | 4 | 8 | 14 | BOLTPB1230
53 x Bolt assembly | 5 | 11.6 | TEK_16TPIM | 8 | UNDEF_WASH | UNDEFINED_WASHER5 | 4 | UNDEF_NUT | UNDEFINED_NUT10G | 0 | 0 | 7 | TEKSCREW_M5*25
30 x Bolt assembly | 5 | 25 | TEK_16TPIM | 8 | UNDEF_WASH | UNDEFINED_WASHER5 | 2 | UNDEF_NUT | UNDEFINED_NUT10G | 0 | 0 | 7 | TEKSCREW_M5*25
12 x Bolt assembly | 5 | 11.6 | TEK_16TPIM | 4 | UNDEF_WASH | UNDEFINED_WASHER5 | 2 | UNDEF_NUT | UNDEFINED_NUT10G | 0 | 0 | 7 | TEKSCREW_M5*25

# IfcPlate: PLT3*159.7 (24)
In: Undefined
Description: PLT3*159.7; Material: STEEL/450
Tekla Common - Phase: 1; Class: 9
Tekla Quantity - Weight: 1.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.7 m2; Net surface area: 0.1 m2; Height: 159.7 mm; Width: 3 mm; Length: 392.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 159.663 mm; NetArea: 0.103751 m2; GrossArea: 0.0626777 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000150671 m3; GrossVolume: 0.000150671 m3
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation
BB TRUSS BRACKET | PL/2050 | +3.436 | +3.616
BB TRUSS BRACKET | PL/2051 | +3.436 | +3.616
BB TRUSS BRACKET | PL/2050 | +3.431 | +3.611
BB TRUSS BRACKET | PL/2051 | +3.431 | +3.611
2 x BB TRUSS BRACKET | PL/2050 | +3.426 | +3.606
2 x BB TRUSS BRACKET | PL/2051 | +3.426 | +3.606
BB TRUSS BRACKET | PL/2050 | +3.390 | +3.570
BB TRUSS BRACKET | PL/2051 | +3.390 | +3.570
BB TRUSS BRACKET | PL/2050 | +3.409 | +3.589
BB TRUSS BRACKET | PL/2051 | +3.409 | +3.589
BB TRUSS BRACKET | PL/1974 | +3.436 | +3.616
BB TRUSS BRACKET | PL/1641 | +3.436 | +3.616
BB TRUSS BRACKET | PL/1974 | +3.431 | +3.611
BB TRUSS BRACKET | PL/1641 | +3.431 | +3.611
2 x BB TRUSS BRACKET | PL/1974 | +3.426 | +3.606
2 x BB TRUSS BRACKET | PL/1641 | +3.426 | +3.606
BB TRUSS BRACKET | PL/1974 | +3.390 | +3.570
BB TRUSS BRACKET | PL/1641 | +3.390 | +3.570
BB TRUSS BRACKET | PL/1974 | +3.409 | +3.589
BB TRUSS BRACKET | PL/1641 | +3.409 | +3.589

# IfcPlate: PLT3*209.7 (36)
In: Undefined
Description: PLT3*209.7; Material: STEEL/450
Tekla Common - Phase: 1; Class: 9
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.1 m2; Height: 209.7 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Net surface area (m2) | Length (mm) | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) | GrossVolume (m3)
BB TRUSS BRACKET | PL/2057 | +3.393 | +3.626 | 1.8 | 0.1 | 414.5 | 209.669 | 0.148878 | 0.0869167 | 0.00021763 | 0.00021763
BB TRUSS BRACKET | PL/2054 | +3.393 | +3.626 | 1.8 | 0.1 | 414.5 | 209.667 | 0.148877 | 0.0869155 | 0.000217629 | 0.000217629
BB TRUSS BRACKET | PL/2057 | +3.412 | +3.645 | 1.8 | 0.1 | 414.5 | 209.669 | 0.148878 | 0.0869167 | 0.00021763 | 0.00021763
BB TRUSS BRACKET | PL/2054 | +3.412 | +3.645 | 1.8 | 0.1 | 414.5 | 209.667 | 0.148877 | 0.0869155 | 0.000217629 | 0.000217629
BB TRUSS BRACKET | PL/2057 | +3.429 | +3.662 | 1.8 | 0.1 | 414.5 | 209.669 | 0.148878 | 0.0869167 | 0.00021763 | 0.00021763
BB TRUSS BRACKET | PL/2054 | +3.429 | +3.662 | 1.8 | 0.1 | 414.5 | 209.667 | 0.148877 | 0.0869155 | 0.000217629 | 0.000217629
BB TRUSS BRACKET | PL/2056 | +3.384 | +3.626 | 1.9 | 0.2 | 455.4 | 209.667 | 0.163842 | 0.0954891 | 0.000239709 | 0.000239709
BB TRUSS BRACKET | PL/2053 | +3.384 | +3.626 | 1.9 | 0.2 | 455.4 | 209.665 | 0.163841 | 0.095488 | 0.000239708 | 0.000239708
BB TRUSS BRACKET | PL/2056 | +3.404 | +3.645 | 1.9 | 0.2 | 455.4 | 209.667 | 0.163842 | 0.0954891 | 0.000239709 | 0.000239709
BB TRUSS BRACKET | PL/2053 | +3.404 | +3.645 | 1.9 | 0.2 | 455.4 | 209.665 | 0.163841 | 0.095488 | 0.000239708 | 0.000239708
BB TRUSS BRACKET | PL/2056 | +3.421 | +3.662 | 1.9 | 0.2 | 455.4 | 209.667 | 0.163842 | 0.0954891 | 0.000239709 | 0.000239709
BB TRUSS BRACKET | PL/2053 | +3.421 | +3.662 | 1.9 | 0.2 | 455.4 | 209.665 | 0.163841 | 0.095488 | 0.000239708 | 0.000239708
BB TRUSS BRACKET | PL/2055 | +3.394 | +3.626 | 1.8 | 0.2 | 453.4 | 209.667 | 0.160559 | 0.0950655 | 0.000234854 | 0.000239709
BB TRUSS BRACKET | PL/2052 | +3.394 | +3.626 | 1.8 | 0.2 | 453.4 | 209.665 | 0.160558 | 0.0950644 | 0.000234853 | 0.000239708
BB TRUSS BRACKET | PL/2055 | +3.413 | +3.645 | 1.8 | 0.2 | 453.4 | 209.667 | 0.160559 | 0.0950655 | 0.000234854 | 0.000239709
BB TRUSS BRACKET | PL/2052 | +3.413 | +3.645 | 1.8 | 0.2 | 453.4 | 209.665 | 0.160558 | 0.0950644 | 0.000234853 | 0.000239708
BB TRUSS BRACKET | PL/2055 | +3.430 | +3.662 | 1.8 | 0.2 | 453.4 | 209.667 | 0.160559 | 0.0950655 | 0.000234854 | 0.000239709
BB TRUSS BRACKET | PL/2052 | +3.430 | +3.662 | 1.8 | 0.2 | 453.4 | 209.665 | 0.160558 | 0.0950644 | 0.000234853 | 0.000239708
BB TRUSS BRACKET | PL/1977 | +3.393 | +3.626 | 1.8 | 0.1 | 414.5 | 209.669 | 0.148878 | 0.0869167 | 0.00021763 | 0.00021763
BB TRUSS BRACKET | PL/1981 | +3.393 | +3.626 | 1.8 | 0.1 | 414.5 | 209.667 | 0.148877 | 0.0869155 | 0.000217629 | 0.000217629
BB TRUSS BRACKET | PL/1977 | +3.412 | +3.645 | 1.8 | 0.1 | 414.5 | 209.669 | 0.148878 | 0.0869167 | 0.00021763 | 0.00021763
BB TRUSS BRACKET | PL/1981 | +3.412 | +3.645 | 1.8 | 0.1 | 414.5 | 209.667 | 0.148877 | 0.0869155 | 0.000217629 | 0.000217629
BB TRUSS BRACKET | PL/1977 | +3.429 | +3.662 | 1.8 | 0.1 | 414.5 | 209.669 | 0.148878 | 0.0869167 | 0.00021763 | 0.00021763
BB TRUSS BRACKET | PL/1981 | +3.429 | +3.662 | 1.8 | 0.1 | 414.5 | 209.667 | 0.148877 | 0.0869155 | 0.000217629 | 0.000217629
BB TRUSS BRACKET | PL/1976 | +3.384 | +3.626 | 1.9 | 0.2 | 455.4 | 209.667 | 0.163842 | 0.0954891 | 0.000239709 | 0.000239709
BB TRUSS BRACKET | PL/1980 | +3.384 | +3.626 | 1.9 | 0.2 | 455.4 | 209.665 | 0.163841 | 0.095488 | 0.000239708 | 0.000239708
BB TRUSS BRACKET | PL/1976 | +3.404 | +3.645 | 1.9 | 0.2 | 455.4 | 209.667 | 0.163842 | 0.0954891 | 0.000239709 | 0.000239709
BB TRUSS BRACKET | PL/1980 | +3.404 | +3.645 | 1.9 | 0.2 | 455.4 | 209.665 | 0.163841 | 0.095488 | 0.000239708 | 0.000239708
BB TRUSS BRACKET | PL/1976 | +3.421 | +3.662 | 1.9 | 0.2 | 455.4 | 209.667 | 0.163842 | 0.0954891 | 0.000239709 | 0.000239709
BB TRUSS BRACKET | PL/1980 | +3.421 | +3.662 | 1.9 | 0.2 | 455.4 | 209.665 | 0.163841 | 0.095488 | 0.000239708 | 0.000239708
BB TRUSS BRACKET | PL/1975 | +3.394 | +3.626 | 1.8 | 0.2 | 453.4 | 209.667 | 0.160559 | 0.0950655 | 0.000234854 | 0.000239709
BB TRUSS BRACKET | PL/1979 | +3.394 | +3.626 | 1.8 | 0.2 | 453.4 | 209.665 | 0.160558 | 0.0950644 | 0.000234853 | 0.000239708
BB TRUSS BRACKET | PL/1975 | +3.413 | +3.645 | 1.8 | 0.2 | 453.4 | 209.667 | 0.160559 | 0.0950655 | 0.000234854 | 0.000239709
BB TRUSS BRACKET | PL/1979 | +3.413 | +3.645 | 1.8 | 0.2 | 453.4 | 209.665 | 0.160558 | 0.0950644 | 0.000234853 | 0.000239708
BB TRUSS BRACKET | PL/1975 | +3.430 | +3.662 | 1.8 | 0.2 | 453.4 | 209.667 | 0.160559 | 0.0950655 | 0.000234854 | 0.000239709
BB TRUSS BRACKET | PL/1979 | +3.430 | +3.662 | 1.8 | 0.2 | 453.4 | 209.665 | 0.160558 | 0.0950644 | 0.000234853 | 0.000239708

# IfcPlate: PLT3*232.9 (12)
In: Undefined
Description: PLT3*232.9; Material: STEEL/450
Tekla Common - Phase: 1; Class: 2
Tekla Quantity - Weight: 1.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.4 m2; Net surface area: 0.2 m2; Height: 232.9 mm; Width: 3 mm; Length: 350 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 232.879 mm; NetArea: 0.169434 m2; GrossArea: 0.0815076 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000247169 m3; GrossVolume: 0.000247169 m3
Name | Bottom elevation | Top elevation | ASSEMBLY_POS = Reference
BRIDGING-COLUMN STIFF | +3.361 | +3.711 | PL/91(?)
BRIDGING-COLUMN STIFF | +3.314 | +3.664 | PL/91
3 x BRIDGING-COLUMN STIFF | +3.269 | +3.619 | PL/91
BRIDGING-COLUMN STIFF | +3.315 | +3.665 | PL/91
2 x BRIDGING-COLUMN STIFF | +3.293 | +3.643 | PL/91
4 x BRIDGING-COLUMN STIFF | +3.247 | +3.597 | PL/91

# IfcPlate: PLT3*259.7 (18)
In: Undefined
Description: PLT3*259.7; Material: STEEL/450
Tekla Common - Phase: 1; Class: 9
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.7 m2; Net surface area: 0.3 m2; Height: 259.7 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 259.65 mm; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) | GrossVolume (m3)
BB TRUSS BRACKET | PL/2062 | +3.341 | +3.654 | 3 | 562.4 | 0.25599 | 0.146032 | 0.000376436 | 0.000376436
BB TRUSS BRACKET | PL/2059 | +3.341 | +3.654 | 3 | 562.4 | 0.25599 | 0.146032 | 0.000376436 | 0.000376436
BB TRUSS BRACKET | PL/2062 | +3.360 | +3.673 | 3 | 562.4 | 0.25599 | 0.146032 | 0.000376436 | 0.000376436
BB TRUSS BRACKET | PL/2059 | +3.360 | +3.673 | 3 | 562.4 | 0.25599 | 0.146032 | 0.000376436 | 0.000376436
BB TRUSS BRACKET | PL/2061 | +3.353 | +3.654 | 3.1 | 599.1 | 0.267147 | 0.155553 | 0.000392952 | 0.000404657
BB TRUSS BRACKET | PL/2061 | +3.372 | +3.673 | 3.1 | 599.1 | 0.267147 | 0.155553 | 0.000392952 | 0.000404657
BB TRUSS BRACKET | PL/2062 | +3.377 | +3.690 | 3 | 562.4 | 0.25599 | 0.146032 | 0.000376436 | 0.000376436
BB TRUSS BRACKET | PL/2059 | +3.377 | +3.690 | 3 | 562.4 | 0.25599 | 0.146032 | 0.000376436 | 0.000376436
BB TRUSS BRACKET | PL/2061 | +3.389 | +3.690 | 3.1 | 599.1 | 0.267147 | 0.155553 | 0.000392952 | 0.000404657
BB TRUSS BRACKET | PL/1983 | +3.341 | +3.654 | 3 | 562.4 | 0.25599 | 0.146032 | 0.000376436 | 0.000376436
BB TRUSS BRACKET | PL/1988 | +3.341 | +3.654 | 3 | 562.4 | 0.25599 | 0.146032 | 0.000376436 | 0.000376436
BB TRUSS BRACKET | PL/1983 | +3.360 | +3.673 | 3 | 562.4 | 0.25599 | 0.146032 | 0.000376436 | 0.000376436
BB TRUSS BRACKET | PL/1988 | +3.360 | +3.673 | 3 | 562.4 | 0.25599 | 0.146032 | 0.000376436 | 0.000376436
BB TRUSS BRACKET | PL/1982 | +3.353 | +3.654 | 3.1 | 599.1 | 0.267147 | 0.155553 | 0.000392952 | 0.000404657
BB TRUSS BRACKET | PL/1982 | +3.372 | +3.673 | 3.1 | 599.1 | 0.267147 | 0.155553 | 0.000392952 | 0.000404657
BB TRUSS BRACKET | PL/1983 | +3.377 | +3.690 | 3 | 562.4 | 0.25599 | 0.146032 | 0.000376436 | 0.000376436
BB TRUSS BRACKET | PL/1988 | +3.377 | +3.690 | 3 | 562.4 | 0.25599 | 0.146032 | 0.000376436 | 0.000376436
BB TRUSS BRACKET | PL/1982 | +3.389 | +3.690 | 3.1 | 599.1 | 0.267147 | 0.155553 | 0.000392952 | 0.000404657

# IfcPlate: PLT3*300.6 (12)
In: Undefined
Description: PLT3*300.6; Material: STEEL/450
Tekla Common - Phase: 1; Class: 9
Tekla Quantity - Weight: 2.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.7 m2; Net surface area: 0.2 m2; Height: 300.6 mm; Width: 3 mm; Length: 498.3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 300.572 mm; NetArea: 0.228357 m2; GrossArea: 0.149772 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00033552 m3; GrossVolume: 0.00033552 m3
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation
BB TRUSS BRACKET | PL/2060 | +3.353 | +3.654
BB TRUSS BRACKET | PL/2063 | +3.353 | +3.654
BB TRUSS BRACKET | PL/2060 | +3.373 | +3.673
BB TRUSS BRACKET | PL/2063 | +3.373 | +3.673
BB TRUSS BRACKET | PL/2060 | +3.390 | +3.690
BB TRUSS BRACKET | PL/2063 | +3.390 | +3.690
BB TRUSS BRACKET | PL/1989 | +3.353 | +3.654
BB TRUSS BRACKET | PL/1984 | +3.353 | +3.654
BB TRUSS BRACKET | PL/1989 | +3.373 | +3.673
BB TRUSS BRACKET | PL/1984 | +3.373 | +3.673
BB TRUSS BRACKET | PL/1989 | +3.390 | +3.690
BB TRUSS BRACKET | PL/1984 | +3.390 | +3.690

# IfcPlate: PLT3*301 (6)
In: Undefined
Description: PLT3*301; Material: STEEL/450
Tekla Common - Phase: 1; Class: 9
Tekla Quantity - Weight: 3.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.7 m2; Net surface area: 0.3 m2; Height: 301 mm; Width: 3 mm; Length: 596.3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 301.049 mm; NetArea: 0.267147 m2; GrossArea: 0.179515 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000392954 m3; GrossVolume: 0.000404657 m3
Name | Bottom elevation | Top elevation | ASSEMBLY_POS = Reference
BB TRUSS BRACKET | +3.353 | +3.654 | PL/2058
BB TRUSS BRACKET | +3.372 | +3.673 | PL/2058
BB TRUSS BRACKET | +3.389 | +3.690 | PL/2058
BB TRUSS BRACKET | +3.353 | +3.654 | PL/1987
BB TRUSS BRACKET | +3.372 | +3.673 | PL/1987
BB TRUSS BRACKET | +3.389 | +3.690 | PL/1987

# IfcPlate: PLT3*307.9 (18)
In: Undefined
Description: PLT3*307.9; Material: STEEL/450
Tekla Common - Phase: 1; Class: 2
Default - ASSEMBLY_POS: PL/111
Tekla Quantity - Weight: 2.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.9 m2; Net surface area: 0.2 m2; Height: 307.9 mm; Width: 3 mm; Length: 350 mm
Pset_PlateCommon - LoadBearing: no; Reference: PL/111
BaseQuantities - Width: 307.879 mm; NetArea: 0.222384 m2; GrossArea: 0.107758 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000325919 m3; GrossVolume: 0.000325919 m3
Name | Bottom elevation | Top elevation
3 x BRIDGING-COLUMN STIFF | +3.360 | +3.710
3 x BRIDGING-COLUMN STIFF | +3.339 | +3.689
3 x BRIDGING-COLUMN STIFF | +3.315 | +3.665
9 x BRIDGING-COLUMN STIFF | +3.293 | +3.643

# IfcPlate: PLT3*308.7 (24)
In: Undefined
Description: PLT3*308.7; Material: STEEL/450
Tekla Common - Phase: 1; Class: 11
Tekla Quantity - Weight: 2.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.7 m2; Net surface area: 0.2 m2; Height: 308.7 mm; Width: 3 mm; Length: 451.2 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 308.662 mm; NetArea: 0.216526 m2; GrossArea: 0.139258 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000318536 m3; GrossVolume: 0.000318536 m3
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation
8 x PLATE | Z/220 | +3.314 | +3.617
4 x PLATE | Z/2518 | +3.319 | +3.621
4 x PLATE | Z/2519 | +3.324 | +3.626
4 x PLATE | Z/2519 | +3.278 | +3.580
4 x PLATE | Z/2518 | +3.297 | +3.600

# IfcPlate: PLT3*309.6 (18)
In: Undefined
Description: PLT3*309.6; Material: STEEL/450
Tekla Common - Phase: 1; Class: 9
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.3 m2; Height: 309.6 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000009 m2
Name | Bottom elevation | Top elevation | ASSEMBLY_POS = Reference | Weight (kg) | Length (mm) | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) | GrossVolume (m3)
BB TRUSS BRACKET | +3.305 | +3.690 | PL/2065 | 4.3 | 675.1 | 309.6 | 0.371675 | 0.209004 | 0.000548417 | 0.000548417
BB TRUSS BRACKET | +3.300 | +3.685 | PL/2065 | 4.3 | 675.1 | 309.6 | 0.371675 | 0.209004 | 0.000548417 | 0.000548417
BB TRUSS BRACKET | +3.319 | +3.690 | PL/2066 | 4.6 | 728.9 | 309.63 | 0.394272 | 0.225683 | 0.000581973 | 0.000598234
BB TRUSS BRACKET | +3.319 | +3.690 | PL/2064 | 4.6 | 728.9 | 309.63 | 0.394272 | 0.225683 | 0.000581973 | 0.000598234
BB TRUSS BRACKET | +3.338 | +3.710 | PL/2066 | 4.6 | 728.9 | 309.63 | 0.394272 | 0.225683 | 0.000581973 | 0.000598234
BB TRUSS BRACKET | +3.338 | +3.710 | PL/2064 | 4.6 | 728.9 | 309.63 | 0.394272 | 0.225683 | 0.000581973 | 0.000598234
BB TRUSS BRACKET | +3.295 | +3.681 | PL/2065 | 4.3 | 675.1 | 309.6 | 0.371675 | 0.209004 | 0.000548417 | 0.000548417
BB TRUSS BRACKET | +3.355 | +3.727 | PL/2066 | 4.6 | 728.9 | 309.63 | 0.394272 | 0.225683 | 0.000581973 | 0.000598234
BB TRUSS BRACKET | +3.355 | +3.727 | PL/2064 | 4.6 | 728.9 | 309.63 | 0.394272 | 0.225683 | 0.000581973 | 0.000598234
BB TRUSS BRACKET | +3.305 | +3.690 | PL/1993 | 4.3 | 675.1 | 309.6 | 0.371675 | 0.209004 | 0.000548417 | 0.000548417
BB TRUSS BRACKET | +3.300 | +3.685 | PL/1993 | 4.3 | 675.1 | 309.6 | 0.371675 | 0.209004 | 0.000548417 | 0.000548417
BB TRUSS BRACKET | +3.319 | +3.690 | PL/1991 | 4.6 | 728.9 | 309.63 | 0.394272 | 0.225683 | 0.000581973 | 0.000598234
BB TRUSS BRACKET | +3.319 | +3.690 | PL/1994 | 4.6 | 728.9 | 309.63 | 0.394272 | 0.225683 | 0.000581973 | 0.000598234
BB TRUSS BRACKET | +3.338 | +3.710 | PL/1991 | 4.6 | 728.9 | 309.63 | 0.394272 | 0.225683 | 0.000581973 | 0.000598234
BB TRUSS BRACKET | +3.338 | +3.710 | PL/1994 | 4.6 | 728.9 | 309.63 | 0.394272 | 0.225683 | 0.000581973 | 0.000598234
BB TRUSS BRACKET | +3.295 | +3.681 | PL/1993 | 4.3 | 675.1 | 309.6 | 0.371675 | 0.209004 | 0.000548417 | 0.000548417
BB TRUSS BRACKET | +3.355 | +3.727 | PL/1991 | 4.6 | 728.9 | 309.63 | 0.394272 | 0.225683 | 0.000581973 | 0.000598234
BB TRUSS BRACKET | +3.355 | +3.727 | PL/1994 | 4.6 | 728.9 | 309.63 | 0.394272 | 0.225683 | 0.000581973 | 0.000598234

# IfcPlate: PLT3*310 (66)
In: Undefined
Description: PLT3*310; Material: STEEL/450
Tekla Common - Phase: 1; Class: 11
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 310 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 310.001 mm; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
BRIDGING U-PLATE | PL/2030 | +3.334 | +3.642 | 3.6 | 86.5 | 0.3 | 491.3 | 0.311989 | 0.152296 | 0.000459232
BRIDGING U-PLATE | PL/2046(?) | +3.311 | +3.669 | 4.4 | 86.5 | 0.3 | 599.3 | 0.379597 | 0.185776 | 0.000559672
BRIDGING U-PLATE | PL/2030 | +3.314 | +3.622 | 3.6 | 86.5 | 0.3 | 491.3 | 0.311989 | 0.152296 | 0.000459232
BRIDGING U-PLATE | PL/2046 | +3.315 | +3.673 | 4.4 | 86.5 | 0.3 | 599.3 | 0.379597 | 0.185776 | 0.000559672
BRIDGING U-PLATE | PL/2045 | +3.266 | +3.624 | 4.4 | 86.5 | 0.3 | 599.3 | 0.379597 | 0.185776 | 0.000559672
BRIDGING U-PLATE | PL/1992 | +3.352 | +3.660 | 3.6 | 86.5 | 0.3 | 491.3 | 0.311989 | 0.152296 | 0.000459232
BRIDGING U-PLATE | PL/2034 | +3.294 | +3.652 | 4.4 | 86.5 | 0.3 | 599.3 | 0.379597 | 0.185776 | 0.000559672
BRIDGING U-PLATE | PL/2034 | +3.310 | +3.668 | 4.4 | 86.5 | 0.3 | 599.3 | 0.379597 | 0.185776 | 0.000559672
BRIDGING U-PLATE | PL/2044 | +3.349 | +3.707 | 4.4 | 86.3 | 0.3 | 599.3 | 0.379597 | 0.185776 | 0.000559672
BRIDGING U-PLATE | PL/2043 | +3.334 | +3.692 | 4.4 | 86.3 | 0.3 | 599.3 | 0.379597 | 0.185776 | 0.000559672
BRIDGING U-PLATE | PL/2042 | +3.311 | +3.669 | 4.4 | 86.3 | 0.3 | 599.3 | 0.379597 | 0.185776 | 0.000559672
BRIDGING U-PLATE | PL/2041 | +3.348 | +3.656 | 3.6 | 86.5 | 0.3 | 491.3 | 0.311989 | 0.152296 | 0.000459232
BRIDGING U-PLATE | PL/2040 | +3.364 | +3.672 | 3.6 | 86.5 | 0.3 | 491.3 | 0.311989 | 0.152296 | 0.000459232
BRIDGING U-PLATE | PL/2039 | +3.361 | +3.669 | 3.6 | 86.5 | 0.3 | 491.3 | 0.311989 | 0.152296 | 0.000459232
BRIDGING U-PLATE | PL/1985 | +3.349 | +3.611 | 3 | 86.7 | 0.3 | 405.3 | 0.258153 | 0.125636 | 0.000379252
BRIDGING U-PLATE | PL/1985 | +3.369 | +3.631 | 3 | 86.7 | 0.3 | 405.3 | 0.258153 | 0.125636 | 0.000379252
BRIDGING U-PLATE | PL/2018 | +3.382 | +3.644 | 3 | 86.7 | 0.3 | 405.3 | 0.258153 | 0.125636 | 0.000379252
BRIDGING U-PLATE | PL/2047 | +3.276 | +3.634 | 4.4 | 86.3 | 0.3 | 599.3 | 0.379597 | 0.185776 | 0.000559672
BRIDGING U-PLATE | PL/2038 | +3.381 | +3.689 | 3.6 | 86.5 | 0.3 | 491.3 | 0.311989 | 0.152296 | 0.000459232
BRIDGING U-PLATE | PL/2037 | +3.385 | +3.693 | 3.6 | 86.5 | 0.3 | 491.3 | 0.311989 | 0.152296 | 0.000459232
BRIDGING U-PLATE | PL/2031 | +3.361 | +3.669 | 3.6 | 86.5 | 0.3 | 491.3 | 0.311989 | 0.152296 | 0.000459232
BRIDGING U-PLATE | PL/2026 | +3.387 | +3.649 | 3 | 86.7 | 0.3 | 405.3 | 0.258153 | 0.125636 | 0.000379252
BRIDGING U-PLATE | PL/2026 | +3.407 | +3.669 | 3 | 86.7 | 0.3 | 405.3 | 0.258153 | 0.125636 | 0.000379252
BRIDGING U-PLATE | PL/2025 | +3.407 | +3.669 | 3 | 86.7 | 0.3 | 405.3 | 0.258153 | 0.125636 | 0.000379252
BRIDGING U-PLATE | PL/2017 | +3.388 | +3.599 | 2.6 | 86.9 | 0.2 | 354.3 | 0.226227 | 0.109826 | 0.000331822
BRIDGING U-PLATE | PL/2035 | +3.407 | +3.618 | 2.6 | 86.9 | 0.2 | 354.3 | 0.226227 | 0.109826 | 0.000331822
BRIDGING U-PLATE | PL/2035 | +3.424 | +3.635 | 2.6 | 86.9 | 0.2 | 354.3 | 0.226227 | 0.109826 | 0.000331822
BRIDGING U-PLATE | PL/2016 | +3.428 | +3.690 | 3 | 86.7 | 0.3 | 405.3 | 0.258153 | 0.125636 | 0.000379252
BRIDGING U-PLATE | PL/2015 | +3.406 | +3.668 | 3 | 86.7 | 0.3 | 405.3 | 0.258153 | 0.125636 | 0.000379252
BRIDGING U-PLATE | PL/2014 | +3.361 | +3.623 | 3 | 86.7 | 0.3 | 405.3 | 0.258153 | 0.125636 | 0.000379252
BRIDGING U-PLATE | PL/2007 | +3.382 | +3.593 | 2.6 | 86.9 | 0.2 | 354.3 | 0.226227 | 0.109826 | 0.000331822
BRIDGING U-PLATE | PL/1999 | +3.401 | +3.612 | 2.6 | 86.9 | 0.2 | 354.3 | 0.226227 | 0.109826 | 0.000331822
BRIDGING U-PLATE | PL/2005 | +3.412 | +3.623 | 2.6 | 86.9 | 0.2 | 354.3 | 0.226227 | 0.109826 | 0.000331822
BRIDGING U-PLATE | PL/2029 | +3.335 | +3.643 | 3.6 | 86.5 | 0.3 | 491.3 | 0.311989 | 0.152296 | 0.000459232
BRIDGING U-PLATE | PL/2028 | +3.265 | +3.623 | 4.4 | 86.3 | 0.3 | 599.3 | 0.379597 | 0.185776 | 0.000559672
BRIDGING U-PLATE | PL/2030 | +3.315 | +3.623 | 3.6 | 86.5 | 0.3 | 491.3 | 0.311989 | 0.152296 | 0.000459232
BRIDGING U-PLATE | PL/2027 | +3.290 | +3.648 | 4.4 | 86.3 | 0.3 | 599.3 | 0.379597 | 0.185776 | 0.000559672
BRIDGING U-PLATE | PL/2036 | +3.244 | +3.602 | 4.4 | 86.3 | 0.3 | 599.3 | 0.379597 | 0.185776 | 0.000559672
BRIDGING U-PLATE | PL/1992 | +3.340 | +3.648 | 3.6 | 86.5 | 0.3 | 491.3 | 0.311989 | 0.152296 | 0.000459232
BRIDGING U-PLATE | PL/2033 | +3.289 | +3.647 | 4.4 | 86.3 | 0.3 | 599.3 | 0.379597 | 0.185776 | 0.000559672
BRIDGING U-PLATE | PL/2032 | +3.289 | +3.647 | 4.4 | 86.3 | 0.3 | 599.3 | 0.379597 | 0.185776 | 0.000559672
BRIDGING U-PLATE | PL/2024 | +3.289 | +3.647 | 4.4 | 86.3 | 0.3 | 599.3 | 0.379597 | 0.185776 | 0.000559672
BRIDGING U-PLATE | PL/2023 | +3.289 | +3.647 | 4.4 | 86.3 | 0.3 | 599.3 | 0.379597 | 0.185776 | 0.000559672
BRIDGING U-PLATE | PL/1986 | +3.289 | +3.647 | 4.4 | 86.3 | 0.3 | 599.3 | 0.379597 | 0.185776 | 0.000559672
BRIDGING U-PLATE | PL/2022 | +3.339 | +3.647 | 3.6 | 86.5 | 0.3 | 491.3 | 0.311989 | 0.152296 | 0.000459232
BRIDGING U-PLATE | PL/2021 | +3.339 | +3.647 | 3.6 | 86.5 | 0.3 | 491.3 | 0.311989 | 0.152296 | 0.000459232
BRIDGING U-PLATE | PL/2020 | +3.339 | +3.647 | 3.6 | 86.5 | 0.3 | 491.3 | 0.311989 | 0.152296 | 0.000459232
BRIDGING U-PLATE | PL/2019 | +3.350 | +3.612 | 3 | 86.7 | 0.3 | 405.3 | 0.258153 | 0.125636 | 0.000379252
BRIDGING U-PLATE | PL/2018 | +3.365 | +3.627 | 3 | 86.7 | 0.3 | 405.3 | 0.258153 | 0.125636 | 0.000379252
BRIDGING U-PLATE | PL/1985 | +3.385 | +3.647 | 3 | 86.7 | 0.3 | 405.3 | 0.258153 | 0.125636 | 0.000379252
BRIDGING U-PLATE | PL/2013 | +3.339 | +3.647 | 3.6 | 86.5 | 0.3 | 491.3 | 0.311989 | 0.152296 | 0.000459232
BRIDGING U-PLATE | PL/2012 | +3.339 | +3.647 | 3.6 | 86.5 | 0.3 | 491.3 | 0.311989 | 0.152296 | 0.000459232
BRIDGING U-PLATE | PL/1978 | +3.339 | +3.647 | 3.6 | 86.5 | 0.3 | 491.3 | 0.311989 | 0.152296 | 0.000459232
BRIDGING U-PLATE | PL/2010 | +3.375 | +3.637 | 3 | 86.7 | 0.3 | 405.3 | 0.258153 | 0.125636 | 0.000379252
BRIDGING U-PLATE | PL/2009 | +3.385 | +3.647 | 3 | 86.7 | 0.3 | 405.3 | 0.258153 | 0.125636 | 0.000379252
BRIDGING U-PLATE | PL/2008 | +3.385 | +3.647 | 3 | 86.7 | 0.3 | 405.3 | 0.258153 | 0.125636 | 0.000379252
BRIDGING U-PLATE | PL/2004 | +3.386 | +3.597 | 2.6 | 86.9 | 0.2 | 354.3 | 0.226227 | 0.109826 | 0.000331822
BRIDGING U-PLATE | PL/2035 | +3.406 | +3.617 | 2.6 | 86.9 | 0.2 | 354.3 | 0.226227 | 0.109826 | 0.000331822
BRIDGING U-PLATE | PL/2034 | +3.274 | +3.632 | 4.4 | 86.3 | 0.3 | 599.3 | 0.379597 | 0.185776 | 0.000559672
BRIDGING U-PLATE | PL/2002 | +3.426 | +3.637 | 2.6 | 86.9 | 0.2 | 354.3 | 0.226227 | 0.109826 | 0.000331822
BRIDGING U-PLATE | PL/2001 | +3.385 | +3.647 | 3 | 86.7 | 0.3 | 405.3 | 0.258153 | 0.125636 | 0.000379252
BRIDGING U-PLATE | PL/2000 | +3.361 | +3.623 | 3 | 86.7 | 0.3 | 405.3 | 0.258153 | 0.125636 | 0.000379252
BRIDGING U-PLATE | PL/1973 | +3.339 | +3.601 | 3 | 86.7 | 0.3 | 405.3 | 0.258153 | 0.125636 | 0.000379252
BRIDGING U-PLATE | PL/1999 | +3.380 | +3.591 | 2.6 | 86.9 | 0.2 | 354.3 | 0.226227 | 0.109826 | 0.000331822
BRIDGING U-PLATE | PL/1997 | +3.390 | +3.601 | 2.6 | 86.9 | 0.2 | 354.3 | 0.226227 | 0.109826 | 0.000331822
BRIDGING U-PLATE | PL/1660 | +3.390 | +3.601 | 2.6 | 86.9 | 0.2 | 354.3 | 0.226227 | 0.109826 | 0.000331822

# IfcPlate: PLT3*333.3 (36)
In: Undefined
Description: PLT3*333.3; Material: STEEL/450
Default - ASSEMBLY_POS: Z/227
Tekla Common - Phase: 1; Class: 11
Tekla Quantity - Weight: 3.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.3 m2; Height: 333.3 mm; Width: 3 mm; Length: 496.9 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/227
BaseQuantities - Width: 333.291 mm; NetArea: 0.266193 m2; GrossArea: 0.165615 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000392276 m3; GrossVolume: 0.000392276 m3
Name | Bottom elevation | Top elevation
12 x PLATE | +3.323 | +3.637
12 x PLATE | +3.343 | +3.657
12 x PLATE | +3.360 | +3.674

# IfcPlate: PLT3*350 (36)
In: Undefined
Description: PLT3*350; Material: STEEL/450
Tekla Common - Phase: 1; Class: 2
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.3 m2; Height: 350 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 350 mm; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
BRIDGING-COLUMN STIFF | PL/118 | +3.360 | +3.710 | 4.4 | 86.5 | 549.3 | 0.392812 | 0.192248 | 0.000579389
BRIDGING-COLUMN STIFF | PL/118 | +3.338 | +3.688 | 4.4 | 86.5 | 549.3 | 0.392812 | 0.192248 | 0.000579389
BRIDGING-COLUMN STIFF | PL/118 | +3.314 | +3.664 | 4.4 | 86.5 | 549.3 | 0.392812 | 0.192248 | 0.000579389
2 x BRIDGING-COLUMN STIFF | PL/117 | +3.361 | +3.711 | 3.7 | 86.5 | 441.3 | 0.316564 | 0.154448 | 0.000465989
BRIDGING-COLUMN STIFF | PL/117 | +3.315 | +3.665 | 3.7 | 86.5 | 441.3 | 0.316564 | 0.154448 | 0.000465989
BRIDGING-COLUMN STIFF | PL/117 | +3.270 | +3.620 | 3.7 | 86.5 | 441.3 | 0.316564 | 0.154448 | 0.000465989
BRIDGING-COLUMN STIFF | PL/117 | +3.339 | +3.689 | 3.7 | 86.5 | 441.3 | 0.316564 | 0.154448 | 0.000465989
BRIDGING-COLUMN STIFF | PL/117 | +3.316 | +3.666 | 3.7 | 86.5 | 441.3 | 0.316564 | 0.154448 | 0.000465989
2 x BRIDGING-COLUMN STIFF | PL/114(?) | +3.360 | +3.710 | 3 | 86.7 | 358.9 | 0.25839 | 0.125608 | 0.000379469
2 x BRIDGING-COLUMN STIFF | PL/114(?) | +3.338 | +3.688 | 3 | 86.7 | 358.9 | 0.25839 | 0.125608 | 0.000379469
2 x BRIDGING-COLUMN STIFF | PL/114(?) | +3.315 | +3.665 | 3 | 86.7 | 358.9 | 0.25839 | 0.125608 | 0.000379469
BRIDGING-COLUMN STIFF | PL/114 | +3.360 | +3.710 | 3 | 86.7 | 358.9 | 0.25839 | 0.125608 | 0.000379469
BRIDGING-COLUMN STIFF | PL/114 | +3.339 | +3.689 | 3 | 86.7 | 358.9 | 0.25839 | 0.125608 | 0.000379469
BRIDGING-COLUMN STIFF | PL/114 | +3.315 | +3.665 | 3 | 86.7 | 358.9 | 0.25839 | 0.125608 | 0.000379469
3 x BRIDGING-COLUMN STIFF | PL/118 | +3.293 | +3.643 | 4.4 | 86.3 | 549.3 | 0.392812 | 0.192248 | 0.000579389
4 x BRIDGING-COLUMN STIFF | PL/117 | +3.294 | +3.644 | 3.7 | 86.5 | 441.3 | 0.316564 | 0.154448 | 0.000465989
BRIDGING-COLUMN STIFF | PL/117 | +3.269 | +3.619 | 3.7 | 86.5 | 441.3 | 0.316564 | 0.154448 | 0.000465989
BRIDGING-COLUMN STIFF | PL/117 | +3.248 | +3.598 | 3.7 | 86.5 | 441.3 | 0.316564 | 0.154448 | 0.000465989
9 x BRIDGING-COLUMN STIFF | PL/114 | +3.293 | +3.643 | 3 | 86.7 | 358.9 | 0.25839 | 0.125608 | 0.000379469

# IfcPlate: PLT3*359.6 (12)
In: Undefined
Description: PLT3*359.6; Material: STEEL/450
Tekla Common - Phase: 1; Class: 9
Tekla Quantity - Weight: 5.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.2 m2; Net surface area: 0.5 m2; Height: 359.6 mm; Width: 3 mm; Length: 731.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 359.592 mm; NetArea: 0.464623 m2; GrossArea: 0.263073 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000686935 m3; GrossVolume: 0.000702217 m3
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation
BB TRUSS BRACKET | PL/2069 | +3.278 | +3.700
BB TRUSS BRACKET | PL/2068 | +3.278 | +3.700
BB TRUSS BRACKET | PL/2069 | +3.297 | +3.719
BB TRUSS BRACKET | PL/2068 | +3.297 | +3.719
BB TRUSS BRACKET | PL/2069 | +3.314 | +3.736
BB TRUSS BRACKET | PL/2068 | +3.314 | +3.736
BB TRUSS BRACKET | PL/1995 | +3.278 | +3.700
BB TRUSS BRACKET | PL/1996 | +3.278 | +3.700
BB TRUSS BRACKET | PL/1995 | +3.297 | +3.719
BB TRUSS BRACKET | PL/1996 | +3.297 | +3.719
BB TRUSS BRACKET | PL/1995 | +3.314 | +3.736
BB TRUSS BRACKET | PL/1996 | +3.314 | +3.736

# IfcPlate: PLT3*385.3 (6)
In: Undefined
Description: PLT3*385.3; Material: STEEL/450
Tekla Common - Phase: 1; Class: 9
Tekla Quantity - Weight: 4.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.3 m2; Height: 385.3 mm; Width: 3 mm; Length: 666.5 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 385.311 mm; NetArea: 0.371675 m2; GrossArea: 0.256798 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000548417 m3; GrossVolume: 0.000548417 m3
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation
BB TRUSS BRACKET | PL/2067 | +3.305 | +3.690
BB TRUSS BRACKET | PL/2067 | +3.300 | +3.685
BB TRUSS BRACKET | PL/2067 | +3.295 | +3.681
BB TRUSS BRACKET | PL/1990 | +3.305 | +3.690
BB TRUSS BRACKET | PL/1990 | +3.300 | +3.685
BB TRUSS BRACKET | PL/1990 | +3.295 | +3.681

# IfcPlate: PLT3*426.1 (36)
In: Undefined
Description: PLT3*426.1; Material: STEEL/450
Default - ASSEMBLY_POS: Z/1289
Tekla Common - Phase: 1; Class: 11
Tekla Quantity - Weight: 5.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.2 m2; Net surface area: 0.3 m2; Height: 426.1 mm; Width: 3 mm; Length: 656.1 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/1289
BaseQuantities - Width: 426.082 mm; NetArea: 0.449082 m2; GrossArea: 0.27956 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000664572 m3; GrossVolume: 0.000664572 m3
Name | Bottom elevation | Top elevation
12 x PLATE | +3.275 | +3.702
12 x PLATE | +3.258 | +3.685
8 x PLATE | +3.238 | +3.665
4 x PLATE | +3.238 | +3.666

# IfcPlate: PLT3*565.6 (24)
In: Undefined
Description: PLT3*565.6; Material: STEEL/450
Default - ASSEMBLY_POS: Z/1543
Tekla Common - Phase: 1; Class: 11
Tekla Quantity - Weight: 8.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.7 m2; Height: 565.6 mm; Width: 3 mm; Length: 853.6 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/1543
BaseQuantities - Width: 565.634 mm; NetArea: 0.754232 m2; GrossArea: 0.482802 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00111964 m3; GrossVolume: 0.00111964 m3
Name | Bottom elevation | Top elevation
8 x PLATE | +3.124 | +3.700
4 x PLATE | +3.119 | +3.695
4 x PLATE | +3.115 | +3.690
4 x PLATE | +3.144 | +3.719
4 x PLATE | +3.161 | +3.736

# IfcPlate: PLT3*606.1 (12)
In: Undefined
Description: PLT3*606.1; Material: STEEL/450
Default - ASSEMBLY_POS: Z/1432
Tekla Common - Phase: 1; Class: 11
Tekla Quantity - Weight: 10.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 1 m2; Height: 606.1 mm; Width: 3 mm; Length: 905.1 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/1432
BaseQuantities - Width: 606.062 mm; NetArea: 0.865061 m2; GrossArea: 0.548534 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00128499 m3; GrossVolume: 0.00128499 m3
Name | Bottom elevation | Top elevation
4 x PLATE | +3.159 | +3.746
4 x PLATE | +3.142 | +3.729
4 x PLATE | +3.123 | +3.709

# IfcPlate: PLT6*145 (132)
In: Undefined
