Properties of the parts of a building model (IFC2X3), part 2 of 4

# IfcElementAssembly (1452)
Name | ASSEMBLY_POSITION_CODE = Assembly/Cast unit position code | ASSEMBLY_POS = Assembly/Cast unit Mark | Assembly/Cast unit weight (kg) | Assembly/Cast unit bottom elevation | Assembly/Cast unit top elevation | Width (mm)
BRIDGING U-PLATE | C250-C250/BB250(Z100) | PL/2018 | 3 | +3.382 | +3.644 | 80
RAFTER | C250-C250/BB300(Z200)-BB350(Z100) | Z/2591 | 5.9 | +3.354 | +3.754 | 76
RAFTER | C250-C250/BB300(Z150)-BB300(Z200) | Z/2591 | 5.9 | +3.373 | +3.773 | 76
RAFTER | C250-C250/BB350(Z200)> | Z/2591 | 5.9 | +3.354 | +3.754 | 76
RAFTER | C250-C250/BB350(Z150)-BB350(Z200) | Z/2591 | 5.9 | +3.373 | +3.773 | 76
RAFTER | C250-C250/BB250(Z200)-BB300(Z100) | Z/2591 | 5.9 | +3.354 | +3.754 | 76
RAFTER | C250-C250/BB250(Z150)-BB250(Z200) | Z/2591 | 5.9 | +3.373 | +3.773 | 76
RAFTER | C250-C250/BB350(Z100)-BB350(Z150) | Z/2591 | 5.9 | +3.390 | +3.790 | 76
RAFTER | C250-C250/BB250(Z100)-BB250(Z150) | Z/2591 | 5.9 | +3.390 | +3.790 | 76
2 x RAFTER | C350/BB350(Z100)-BB350(Z150) | Z/431 | 10.8 | +3.316 | +3.809 | 125
2 x RAFTER | C350/BB350(Z150)-BB350(Z200) | Z/431 | 10.8 | +3.299 | +3.792 | 125
2 x RAFTER | C350/BB350(Z200)> | Z/431 | 10.8 | +3.280 | +3.773 | 125
RAFTER | C350-C350/BB350(Z100)-BB350(Z150) | Z/2606 | 10.8 | +3.316 | +3.809 | 125
2 x FASCIA BRACKET | C350/BB350(Z200) | Z/2533 | 0.4 | +3.555 | +3.712 | 157.2
FASCIA BRACKET | C350-C350/BB350(Z200) | Z/3088 | 0.4 | +3.555 | +3.712 | 157.2
FASCIA STIFFENER | C350-C350/BB350(Z200) | PL/116 | 1 | +3.280 | +3.630 | 3
COLUMN | C350/BB350(Z200) | Z/3639 | 55.5 | +0.000 | +3.710 | 125
2 x FASCIA BRACKET | C350/BB350(Z150) | Z/2515 | 0.4 | +3.533 | +3.690 | 157.2
FASCIA BRACKET | C350-C350/BB350(Z150) | Z/3087 | 0.4 | +3.533 | +3.690 | 157.2
FASCIA STIFFENER | C350-C350/BB350(Z150) | PL/116 | 1 | +3.298 | +3.648 | 3
COLUMN | C350/BB350(Z150) | Z/3638 | 55.2 | +0.000 | +3.688 | 125
2 x FASCIA BRACKET | C350/BB350(Z100) | Z/2514 | 0.4 | +3.510 | +3.667 | 157.2
FASCIA BRACKET | C350-C350/BB350(Z100) | Z/3086 | 0.4 | +3.510 | +3.667 | 157.2
FASCIA STIFFENER | C350-C350/BB350(Z100) | PL/116 | 1 | +3.314 | +3.664 | 3
COLUMN | C350/BB350(Z100) | Z/3637 | 54.8 | +0.000 | +3.664 | 125
2 x RAFTER | C300/BB350(Z200)> | Z/430 | 8.9 | +3.319 | +3.761 | 96
2 x RAFTER | C300/BB350(Z150)-BB350(Z200) | Z/430 | 8.9 | +3.314 | +3.756 | 96
2 x RAFTER | C300/BB350(Z100)-BB350(Z150) | Z/430 | 8.9 | +3.310 | +3.752 | 96
2 x FASCIA BRACKET | C300/BB350(Z200) | Z/2533 | 0.4 | +3.556 | +3.713 | 157.2
FASCIA BRACKET | C300-C300/BB350(Z200) | Z/3088 | 0.4 | +3.556 | +3.713 | 157.2
FASCIA STIFFENER | C300-C300/BB350(Z200) | PL/116 | 1 | +3.319 | +3.669 | 3
COLUMN | C300/BB350(Z200) | Z/3185 | 46.4 | +0.000 | +3.711 | 96
2 x FASCIA BRACKET | C300/BB350(Z150) | Z/2515 | 0.4 | +3.510 | +3.667 | 157.2
FASCIA BRACKET | C300-C300/BB350(Z150) | Z/3087 | 0.4 | +3.510 | +3.667 | 157.2
FASCIA STIFFENER | C300-C300/BB350(Z150) | PL/116 | 1 | +3.314 | +3.664 | 3
COLUMN | C300/BB350(Z150) | Z/3198 | 45.8 | +0.000 | +3.665 | 96
2 x FASCIA BRACKET | C300/BB350(Z100) | Z/2514 | 0.4 | +3.465 | +3.622 | 157.2
FASCIA BRACKET | C300-C300/BB350(Z100) | Z/3086 | 0.4 | +3.465 | +3.622 | 157.2
FASCIA STIFFENER | C300-C300/BB350(Z100) | PL/116 | 1 | +3.270 | +3.620 | 3
COLUMN | C300/BB350(Z100) | Z/3190 | 45.3 | +0.000 | +3.620 | 96
FASCIA STIFFENER | C300-C300/BB300(Z200) | PL/113 | 0.8 | +3.318 | +3.618 | 3
FASCIA STIFFENER | C300-C300/BB300(Z150) | PL/113 | 0.8 | +3.338 | +3.638 | 3
FASCIA STIFFENER | C300-C300/BB300(Z100) | PL/113 | 0.8 | +3.356 | +3.656 | 3
2 x RAFTER | C300/BB300(Z200)-BB350(Z100) | Z/430 | 8.9 | +3.319 | +3.761 | 96
2 x FASCIA BRACKET | C300/BB300(Z200) | Z/2533 | 0.4 | +3.556 | +3.713 | 157.2
FASCIA BRACKET | C300-C300/BB300(Z200) | Z/3088 | 0.4 | +3.556 | +3.713 | 157.2
COLUMN | C300/BB300(Z200) | Z/3185 | 46.4 | +0.000 | +3.711 | 96
2 x RAFTER | C300/BB300(Z150)-BB300(Z200) | Z/430 | 8.9 | +3.339 | +3.781 | 96
2 x FASCIA BRACKET | C300/BB300(Z150) | Z/2515 | 0.4 | +3.534 | +3.692 | 157.2
FASCIA BRACKET | C300-C300/BB300(Z150) | Z/3087 | 0.4 | +3.534 | +3.692 | 157.2
COLUMN | C300/BB300(Z150) | Z/3173 | 46.1 | +0.000 | +3.689 | 96
2 x RAFTER | C300/BB300(Z100)-BB300(Z150) | Z/430 | 8.9 | +3.356 | +3.798 | 96
RAFTER | C300-C300/BB300(Z100)-BB300(Z150) | Z/2599 | 8.9 | +3.356 | +3.798 | 96
2 x FASCIA BRACKET | C300/BB300(Z100) | Z/2514 | 0.4 | +3.511 | +3.668 | 157.2
FASCIA BRACKET | C300-C300/BB300(Z100) | Z/3086 | 0.4 | +3.511 | +3.668 | 157.2
COLUMN | C300/BB300(Z100) | Z/3172 | 45.8 | +0.000 | +3.666 | 96
2 x RAFTER | C250/BB350(Z100)-BB350(Z150) | Z/289 | 5.9 | +3.390 | +3.790 | 76
2 x RAFTER | C250/BB350(Z150)-BB350(Z200) | Z/289 | 5.9 | +3.373 | +3.773 | 76
2 x RAFTER | C250/BB350(Z200)> | Z/289 | 5.9 | +3.354 | +3.754 | 76
2 x FASCIA BRACKET | C250/BB350(Z200) | Z/2533 | 0.4 | +3.556 | +3.713 | 157.2
FASCIA BRACKET | C250-C250/BB350(Z200) | Z/3088 | 0.4 | +3.556 | +3.713 | 157.2
COLUMN | C250/BB350(Z200) | Z/3115 | 29.8 | +0.000 | +3.710 | 76
FASCIA STIFFENER | C250-C250/BB350(Z200) | PL/116 | 1 | +3.353 | +3.703 | 3
2 x FASCIA BRACKET | C250/BB350(Z150) | Z/2515 | 0.4 | +3.534 | +3.691 | 157.2
FASCIA BRACKET | C250-C250/BB350(Z150) | Z/3087 | 0.4 | +3.534 | +3.691 | 157.2
COLUMN | C250/BB350(Z150) | Z/3114 | 29.6 | +0.000 | +3.688 | 76
FASCIA STIFFENER | C250-C250/BB350(Z150) | PL/116 | 1 | +3.338 | +3.688 | 3
2 x FASCIA BRACKET | C250/BB350(Z100) | Z/2514 | 0.4 | +3.511 | +3.668 | 157.2
FASCIA BRACKET | C250-C250/BB350(Z100) | Z/3086 | 0.4 | +3.511 | +3.668 | 157.2
COLUMN | C250/BB350(Z100) | Z/3113 | 29.4 | +0.000 | +3.665 | 76
FASCIA STIFFENER | C250-C250/BB350(Z100) | PL/116 | 1 | +3.315 | +3.665 | 3
2 x RAFTER | C250/BB300(Z100)-BB300(Z150) | Z/289 | 5.9 | +3.390 | +3.790 | 76
2 x RAFTER | C250/BB300(Z150)-BB300(Z200) | Z/289 | 5.9 | +3.373 | +3.773 | 76
2 x RAFTER | C250/BB300(Z200)-BB350(Z100) | Z/289 | 5.9 | +3.354 | +3.754 | 76
RAFTER | C250-C250/BB300(Z100)-BB300(Z150) | Z/2591 | 5.9 | +3.390 | +3.790 | 76
2 x FASCIA BRACKET | C250/BB300(Z200) | Z/2533 | 0.4 | +3.556 | +3.713 | 157.2
FASCIA BRACKET | C250-C250/BB300(Z200) | Z/3088 | 0.4 | +3.556 | +3.713 | 157.2
COLUMN | C250/BB300(Z200) | Z/3115 | 29.8 | +0.000 | +3.710 | 76
FASCIA STIFFENER | C250-C250/BB300(Z200) | PL/113 | 0.8 | +3.352 | +3.652 | 3
2 x FASCIA BRACKET | C250/BB300(Z150) | Z/2515 | 0.4 | +3.534 | +3.691 | 157.2
FASCIA BRACKET | C250-C250/BB300(Z150) | Z/3087 | 0.4 | +3.534 | +3.691 | 157.2
COLUMN | C250/BB300(Z150) | Z/3114 | 29.6 | +0.000 | +3.688 | 76
FASCIA STIFFENER | C250-C250/BB300(Z150) | PL/113 | 0.8 | +3.368 | +3.668 | 3
2 x FASCIA BRACKET | C250/BB300(Z100) | Z/2514 | 0.4 | +3.511 | +3.668 | 157.2
FASCIA BRACKET | C250-C250/BB300(Z100) | Z/3086 | 0.4 | +3.511 | +3.668 | 157.2
COLUMN | C250/BB300(Z100) | Z/3113 | 29.4 | +0.000 | +3.665 | 76
FASCIA STIFFENER | C250-C250/BB300(Z100) | PL/113 | 0.8 | +3.365 | +3.665 | 3
2 x FASCIA BRACKET | C250/BB250(Z200) | Z/2533 | 0.4 | +3.556 | +3.713 | 157.2
FASCIA BRACKET | C250-C250/BB250(Z200) | Z/3088 | 0.4 | +3.556 | +3.713 | 157.2
COLUMN | C250/BB250(Z200) | Z/3115 | 29.8 | +0.000 | +3.710 | 76
2 x RAFTER | C250/BB250(Z200)-BB300(Z100) | Z/289 | 5.9 | +3.354 | +3.754 | 76
FASCIA STIFFENER | C250-C250/BB250(Z200) | PL/128 | 0.8 | +3.353 | +3.607 | 3
2 x FASCIA BRACKET | C250/BB250(Z150) | Z/2515 | 0.4 | +3.534 | +3.691 | 157.2
FASCIA BRACKET | C250-C250/BB250(Z150) | Z/3087 | 0.4 | +3.534 | +3.691 | 157.2
COLUMN | C250/BB250(Z150) | Z/3114 | 29.6 | +0.000 | +3.689 | 76
2 x RAFTER | C250/BB250(Z150)-BB250(Z200) | Z/289 | 5.9 | +3.373 | +3.773 | 76
FASCIA STIFFENER | C250-C250/BB250(Z150) | PL/128 | 0.8 | +3.373 | +3.627 | 3
2 x FASCIA BRACKET | C250/BB250(Z100) | Z/2514 | 0.4 | +3.511 | +3.668 | 157.2
FASCIA BRACKET | C250-C250/BB250(Z100) | Z/3086 | 0.4 | +3.511 | +3.668 | 157.2
COLUMN | C250/BB250(Z100) | Z/3113 | 29.4 | +0.000 | +3.665 | 76
2 x RAFTER | C250/BB250(Z100)-BB250(Z150) | Z/289 | 5.9 | +3.390 | +3.790 | 76
FASCIA STIFFENER | C250-C250/BB250(Z100) | PL/128 | 0.8 | +3.386 | +3.640 | 3
BRIDGING-COLUMN STIFF | C350/BB350(Z200) | PL/118 | 4.4 | +3.360 | +3.710 | 112
BRIDGING-COLUMN STIFF | C350/BB350(Z150) | PL/118 | 4.4 | +3.338 | +3.688 | 112
BRIDGING-COLUMN STIFF | C350/BB350(Z100) | PL/118 | 4.4 | +3.314 | +3.664 | 112
BRIDGING-COLUMN STIFF | C300/BB350(Z200) | PL/117 | 3.7 | +3.361 | +3.711 | 83
BRIDGING-COLUMN STIFF | C300/BB350(Z150) | PL/117 | 3.7 | +3.315 | +3.665 | 83
BRIDGING-COLUMN STIFF | C300/BB350(Z100) | PL/117 | 3.7 | +3.270 | +3.620 | 83
BRIDGING-COLUMN STIFF | C300/BB300(Z200) | PL/117 | 3.7 | +3.361 | +3.711 | 83
BRIDGING-COLUMN STIFF | C300/BB300(Z150) | PL/117 | 3.7 | +3.339 | +3.689 | 83
BRIDGING-COLUMN STIFF | C300/BB300(Z100) | PL/117 | 3.7 | +3.316 | +3.666 | 83
BRIDGING-COLUMN STIFF | C250/BB350(Z200) | PL/114(?) | 3 | +3.360 | +3.710 | 64.2
BRIDGING-COLUMN STIFF | C250/BB350(Z150) | PL/114(?) | 3 | +3.338 | +3.688 | 64.2
BRIDGING-COLUMN STIFF | C250/BB350(Z100) | PL/114(?) | 3 | +3.315 | +3.665 | 64.2
BRIDGING-COLUMN STIFF | C250/BB300(Z200) | PL/114(?) | 3 | +3.360 | +3.710 | 64.2
BRIDGING-COLUMN STIFF | C250/BB300(Z150) | PL/114(?) | 3 | +3.338 | +3.688 | 64.2
BRIDGING-COLUMN STIFF | C250/BB300(Z100) | PL/114(?) | 3 | +3.315 | +3.665 | 64.2
BRIDGING-COLUMN STIFF | C250/BB250(Z200) | PL/114 | 3 | +3.360 | +3.710 | 64.2
BRIDGING-COLUMN STIFF | C250/BB250(Z150) | PL/114 | 3 | +3.339 | +3.689 | 64.2
BRIDGING-COLUMN STIFF | C250/BB250(Z100) | PL/114 | 3 | +3.315 | +3.665 | 64.2
2 x BRIDGING BRACKET | C300/BB300(Z200) | PL/218(?) | 1.8 | +3.333 | +3.603 | 6
2 x BRIDGING BRACKET | C300/BB300(Z150) | PL/218(?) | 1.8 | +3.353 | +3.623 | 6
2 x BRIDGING BRACKET | C300/BB300(Z100) | PL/218(?) | 1.8 | +3.371 | +3.641 | 6
2 x BRIDGING BRACKET | C250/BB300(Z100) | PL/218 | 1.8 | +3.380 | +3.650 | 6
2 x BRIDGING BRACKET | C250/BB300(Z150) | PL/218 | 1.8 | +3.383 | +3.653 | 6
2 x BRIDGING BRACKET | C250/BB300(Z200) | PL/218 | 1.8 | +3.367 | +3.637 | 6
2 x BRIDGING BRACKET | C250/BB350(Z100) | PL/1998 | 2.2 | +3.330 | +3.650 | 6
2 x BRIDGING BRACKET | C250/BB350(Z150) | PL/1998 | 2.2 | +3.353 | +3.673 | 6
2 x BRIDGING BRACKET | C250/BB350(Z200) | PL/1998 | 2.2 | +3.368 | +3.688 | 6
2 x BRIDGING BRACKET | C300/BB350(Z200) | PL/1998 | 2.2 | +3.334 | +3.654 | 6
2 x BRIDGING BRACKET | C300/BB350(Z150) | PL/1998(?) | 2.2 | +3.330 | +3.650 | 6
2 x BRIDGING BRACKET | C300/BB350(Z100) | PL/1998 | 2.2 | +3.285 | +3.605 | 6
2 x BRIDGING BRACKET | C350/BB350(Z100) | PL/1998 | 2.2 | +3.329 | +3.649 | 6
2 x BRIDGING BRACKET | C350/BB350(Z150) | PL/1998 | 2.2 | +3.313 | +3.633 | 6
2 x BRIDGING BRACKET | C350/BB350(Z200) | PL/1998 | 2.2 | +3.295 | +3.615 | 6
BB TRUSS BRACKET | C350-C350/BB350(Z200)> | PL/2069 | 5.4 | +3.278 | +3.700 | 147.699
BB TRUSS BRACKET | C350-C350/BB350(Z200)> | PL/2068 | 5.4 | +3.278 | +3.700 | 147.699
BB TRUSS BRACKET | C350-C350/BB350(Z150)-BB350(Z200) | PL/2069 | 5.4 | +3.297 | +3.719 | 147.699
BB TRUSS BRACKET | C350-C350/BB350(Z150)-BB350(Z200) | PL/2068 | 5.4 | +3.297 | +3.719 | 147.699
BB TRUSS BRACKET | C300-C300/BB350(Z200)> | PL/2067 | 4.3 | +3.305 | +3.690 | 527.132
BB TRUSS BRACKET | C300-C300/BB350(Z200)> | PL/2065 | 4.3 | +3.305 | +3.690 | 147.699
BB TRUSS BRACKET | C300-C300/BB350(Z150)-BB350(Z200) | PL/2067 | 4.3 | +3.300 | +3.685 | 527.132
BB TRUSS BRACKET | C300-C300/BB350(Z150)-BB350(Z200) | PL/2065 | 4.3 | +3.300 | +3.685 | 147.699
BB TRUSS BRACKET | C300-C300/BB350(Z100)-BB350(Z150) | PL/2067 | 4.3 | +3.295 | +3.681 | 527.132
BB TRUSS BRACKET | C300-C300/BB300(Z200)-BB350(Z100) | PL/2066 | 4.6 | +3.319 | +3.690 | 147.699
BB TRUSS BRACKET | C300-C300/BB300(Z200)-BB350(Z100) | PL/2064 | 4.6 | +3.319 | +3.690 | 147.699
BB TRUSS BRACKET | C300-C300/BB300(Z150)-BB300(Z200) | PL/2066 | 4.6 | +3.338 | +3.710 | 147.699
BB TRUSS BRACKET | C300-C300/BB300(Z150)-BB300(Z200) | PL/2064 | 4.6 | +3.338 | +3.710 | 147.699
BB TRUSS BRACKET | C250-C250/BB300(Z200) | PL/2062 | 3 | +3.341 | +3.654 | 147.999
BB TRUSS BRACKET | C250-C250/BB300(Z200) | PL/2059 | 3 | +3.341 | +3.654 | 147.999
BB TRUSS BRACKET | C250-C250/BB300(Z150) | PL/2062 | 3 | +3.360 | +3.673 | 147.999
BB TRUSS BRACKET | C250-C250/BB300(Z150) | PL/2059 | 3 | +3.360 | +3.673 | 147.999
BB TRUSS BRACKET | C250-C250/BB350(Z200) | PL/2060 | 2.6 | +3.353 | +3.654 | 358.65
BB TRUSS BRACKET | C250-C250/BB350(Z200) | PL/2063 | 2.6 | +3.353 | +3.654 | 358.65
BB TRUSS BRACKET | C250-C250/BB350(Z150) | PL/2060 | 2.6 | +3.373 | +3.673 | 358.65
BB TRUSS BRACKET | C250-C250/BB350(Z150) | PL/2063 | 2.6 | +3.373 | +3.673 | 358.65
BB TRUSS BRACKET | C250-C250/BB250(Z200) | PL/2058 | 3.1 | +3.353 | +3.654 | 456.661
BB TRUSS BRACKET | C250-C250/BB250(Z200) | PL/2061 | 3.1 | +3.353 | +3.654 | 147.999
BB TRUSS BRACKET | C250-C250/BB250(Z150) | PL/2058 | 3.1 | +3.372 | +3.673 | 456.661
BB TRUSS BRACKET | C250-C250/BB250(Z150) | PL/2061 | 3.1 | +3.372 | +3.673 | 147.999
BB TRUSS BRACKET | C250-C250/BB350(Z100) | PL/2060 | 2.6 | +3.390 | +3.690 | 358.65
BB TRUSS BRACKET | C250-C250/BB350(Z100) | PL/2063 | 2.6 | +3.390 | +3.690 | 358.65
BB TRUSS BRACKET | C250-C250/BB250(Z100) | PL/2058 | 3.1 | +3.389 | +3.690 | 456.661
GIRT | C350-C350/BB350(Z200) | G/20 | 7 | +2.950 | +3.102 | 151.5
GIRT | C350-C350/BB350(Z150) | G/19 | 5.6 | +2.964 | +3.089 | 124.5
GIRT | C350-C350/BB350(Z100) | G/18 | 4.1 | +2.976 | +3.077 | 100.5
2 x PLATE | C350/BB350(Z100)-BB350(Z150) | Z/1432 | 10.1 | +3.159 | +3.746 | 128
2 x PLATE | C350/BB350(Z150)-BB350(Z200) | Z/1432 | 10.1 | +3.142 | +3.729 | 128
2 x PLATE | C350/BB350(Z200)> | Z/1432 | 10.1 | +3.123 | +3.709 | 128
BB TRUSS BRACKET | C350-C350/BB350(Z100)-BB350(Z150) | PL/2069 | 5.4 | +3.314 | +3.736 | 147.699
BB TRUSS BRACKET | C350-C350/BB350(Z100)-BB350(Z150) | PL/2068 | 5.4 | +3.314 | +3.736 | 147.699
PURLIN | C350-C350/BB350(Z200)> | PU/21 | 7 | +3.757 | +3.988 | 151.5
FASCIA | C350-C350/BB350(Z200) | F/16 | 8.9 | +3.558 | +3.710 | 64
BEAM | C350-C350/BB350(Z200) | B/78 | 27.7 | +3.280 | +3.630 | 125
PURLIN | C350-C350/BB350(Z150)-BB350(Z200) | PU/20 | 5.6 | +3.780 | +3.954 | 124.5
FASCIA | C350-C350/BB350(Z150) | F/16 | 8.9 | +3.536 | +3.688 | 64
BEAM | C350-C350/BB350(Z150) | B/78 | 27.7 | +3.298 | +3.648 | 125
PURLIN | C350-C350/BB350(Z100)-BB350(Z150) | PU/19 | 4.1 | +3.799 | +3.920 | 100.5
FASCIA | C350-C350/BB350(Z100) | F/16 | 8.9 | +3.512 | +3.664 | 64
BEAM | C350-C350/BB350(Z100) | B/78 | 27.7 | +3.314 | +3.664 | 125
GIRT | C300-C300/BB350(Z200) | G/17 | 7.4 | +2.985 | +3.137 | 151.5
GIRT | C300-C300/BB350(Z150) | G/16 | 5.9 | +2.999 | +3.124 | 124.5
GIRT | C300-C300/BB350(Z100) | G/15 | 4.3 | +3.011 | +3.112 | 100.5
GIRT | C300-C300/BB300(Z200) | G/17 | 7.4 | +2.985 | +3.137 | 151.5
GIRT | C300-C300/BB300(Z150) | G/16 | 5.9 | +2.999 | +3.124 | 124.5
GIRT | C300-C300/BB300(Z100) | G/15 | 4.3 | +3.011 | +3.112 | 100.5
2 x PLATE | C300/BB350(Z200)> | Z/1543 | 8.9 | +3.124 | +3.700 | 99
2 x PLATE | C300/BB350(Z150)-BB350(Z200) | Z/1543 | 8.9 | +3.119 | +3.695 | 99
2 x PLATE | C300/BB350(Z100)-BB350(Z150) | Z/1543 | 8.9 | +3.115 | +3.690 | 99
BB TRUSS BRACKET | C300-C300/BB350(Z100)-BB350(Z150) | PL/2065 | 4.3 | +3.295 | +3.681 | 147.699
PURLIN | C300-C300/BB350(Z200)> | PU/18 | 7.4 | +3.746 | +3.976 | 151.5
FASCIA | C300-C300/BB350(Z200) | F/15 | 9.4 | +3.559 | +3.711 | 64
BEAM | C300-C300/BB350(Z200) | B/75 | 28.2 | +3.319 | +3.669 | 125
PURLIN | C300-C300/BB350(Z150)-BB350(Z200) | PU/17 | 5.9 | +3.744 | +3.918 | 124.5
FASCIA | C300-C300/BB350(Z150) | F/15 | 9.4 | +3.513 | +3.665 | 64
BEAM | C300-C300/BB350(Z150) | B/75(?) | 28.2 | +3.315 | +3.665 | 125
PURLIN | C300-C300/BB350(Z100)-BB350(Z150) | PU/16 | 4.3 | +3.742 | +3.862 | 100.5
FASCIA | C300-C300/BB350(Z100) | F/15 | 9.4 | +3.468 | +3.620 | 64
BEAM | C300-C300/BB350(Z100) | B/75 | 28.2 | +3.270 | +3.620 | 125
BEAM | C300-C300/BB300(Z200) | B/96 | 23.6 | +3.318 | +3.618 | 96
2 x PLATE | C300/BB300(Z200)-BB350(Z100) | Z/1543 | 8.9 | +3.124 | +3.700 | 99
PURLIN | C300-C300/BB300(Z200)-BB350(Z100) | PU/18 | 7.4 | +3.734 | +3.964 | 151.5
FASCIA | C300-C300/BB300(Z200) | F/15 | 9.4 | +3.559 | +3.711 | 64
BEAM | C300-C300/BB300(Z150) | B/96 | 23.6 | +3.338 | +3.638 | 96
2 x PLATE | C300/BB300(Z150)-BB300(Z200) | Z/1543 | 8.9 | +3.144 | +3.719 | 99
PURLIN | C300-C300/BB300(Z150)-BB300(Z200) | PU/17 | 5.9 | +3.756 | +3.930 | 124.5
FASCIA | C300-C300/BB300(Z150) | F/15 | 9.4 | +3.537 | +3.689 | 64
BEAM | C300-C300/BB300(Z100) | B/96 | 23.6 | +3.356 | +3.656 | 96
2 x PLATE | C300/BB300(Z100)-BB300(Z150) | Z/1543 | 8.9 | +3.161 | +3.736 | 99
BB TRUSS BRACKET | C300-C300/BB300(Z100)-BB300(Z150) | PL/2066 | 4.6 | +3.355 | +3.727 | 147.699
BB TRUSS BRACKET | C300-C300/BB300(Z100)-BB300(Z150) | PL/2064 | 4.6 | +3.355 | +3.727 | 147.699
PURLIN | C300-C300/BB300(Z100)-BB300(Z150) | PU/16 | 4.3 | +3.775 | +3.896 | 100.5
FASCIA | C300-C300/BB300(Z100) | F/15 | 9.4 | +3.514 | +3.666 | 64
GIRT | C250-C250/BB350(Z200) | G/14 | 7.4 | +3.098 | +3.249 | 151.5
GIRT | C250-C250/BB350(Z150) | G/13 | 5.9 | +3.111 | +3.235 | 124.5
GIRT | C250-C250/BB350(Z100) | G/12 | 4.1 | +3.123 | +3.223 | 100.5
GIRT | C250-C250/BB300(Z200) | G/14 | 7.4 | +3.098 | +3.249 | 151.5
GIRT | C250-C250/BB300(Z150) | G/13 | 5.9 | +3.111 | +3.235 | 124.5
GIRT | C250-C250/BB300(Z100) | G/12 | 4.1 | +3.123 | +3.223 | 100.5
GIRT | C250-C250/BB250(Z200) | G/14 | 7.4 | +3.098 | +3.249 | 151.5
GIRT | C250-C250/BB250(Z150) | G/13 | 5.9 | +3.111 | +3.235 | 124.5
GIRT | C250-C250/BB250(Z100) | G/12 | 4.1 | +3.123 | +3.223 | 100.5
2 x PLATE | C250/BB350(Z100) | Z/1289 | 5.2 | +3.275 | +3.702 | 79
2 x PLATE | C250/BB350(Z150) | Z/1289 | 5.2 | +3.258 | +3.685 | 79
2 x PLATE | C250/BB350(Z200) | Z/1289 | 5.2 | +3.238 | +3.665 | 79
FASCIA | C250-C250/BB350(Z200) | F/14 | 8.1 | +3.558 | +3.710 | 64
PURLIN | C250-C250/BB350(Z200)> | PU/15 | 7.4 | +3.739 | +3.969 | 151.5
BEAM | C250-C250/BB350(Z200) | B/104 | 28.5 | +3.353 | +3.703 | 125
FASCIA | C250-C250/BB350(Z150) | F/14 | 8.1 | +3.536 | +3.688 | 64
PURLIN | C250-C250/BB350(Z150)-BB350(Z200) | PU/14 | 5.9 | +3.761 | +3.935 | 124.5
BEAM | C250-C250/BB350(Z150) | B/104 | 28.5 | +3.338 | +3.688 | 125
PURLIN | C250-C250/BB350(Z100)-BB350(Z150) | PU/13 | 4.1 | +3.780 | +3.901 | 100.5
FASCIA | C250-C250/BB350(Z100) | F/14 | 8.1 | +3.513 | +3.665 | 64
BEAM | C250-C250/BB350(Z100) | B/104 | 28.5 | +3.315 | +3.665 | 125
2 x PLATE | C250/BB300(Z100) | Z/1289 | 5.2 | +3.275 | +3.702 | 79
2 x PLATE | C250/BB300(Z150) | Z/1289 | 5.2 | +3.258 | +3.685 | 79
2 x PLATE | C250/BB300(Z200) | Z/1289 | 5.2 | +3.238 | +3.665 | 79
BB TRUSS BRACKET | C250-C250/BB300(Z100) | PL/2062 | 3 | +3.377 | +3.690 | 147.999
BB TRUSS BRACKET | C250-C250/BB300(Z100) | PL/2059 | 3 | +3.377 | +3.690 | 147.999
PURLIN | C250-C250/BB300(Z200)-BB350(Z100) | PU/15 | 7.4 | +3.739 | +3.969 | 151.5
FASCIA | C250-C250/BB300(Z200) | F/14 | 8.1 | +3.558 | +3.710 | 64
BEAM | C250-C250/BB300(Z200) | B/72 | 19 | +3.352 | +3.652 | 96
PURLIN | C250-C250/BB300(Z150)-BB300(Z200) | PU/14 | 5.9 | +3.761 | +3.935 | 124.5
FASCIA | C250-C250/BB300(Z150) | F/14 | 8.1 | +3.536 | +3.688 | 64
BEAM | C250-C250/BB300(Z150) | B/72 | 19 | +3.368 | +3.668 | 96
PURLIN | C250-C250/BB300(Z100)-BB300(Z150) | PU/13 | 4.1 | +3.780 | +3.901 | 100.5
FASCIA | C250-C250/BB300(Z100) | F/14 | 8.1 | +3.513 | +3.665 | 64
BEAM | C250-C250/BB300(Z100) | B/72 | 19 | +3.365 | +3.665 | 96
FASCIA | C250-C250/BB250(Z200) | F/12 | 7.9 | +3.558 | +3.710 | 64
PURLIN | C250-C250/BB250(Z200)-BB300(Z100) | PU/15 | 7.4 | +3.705 | +3.935 | 151.5
2 x PLATE | C250/BB250(Z200) | Z/1289 | 5.2 | +3.238 | +3.666 | 79
2 x BRIDGING BRACKET | C250/BB250(Z200) | PL/152 | 1.5 | +3.370 | +3.590 | 6
BEAM | C250-C250/BB250(Z200) | B/70 | 15.3 | +3.353 | +3.607 | 76
FASCIA | C250-C250/BB250(Z150) | F/12 | 7.9 | +3.537 | +3.689 | 64
PURLIN | C250-C250/BB250(Z150)-BB250(Z200) | PU/14 | 5.9 | +3.727 | +3.902 | 124.5
2 x PLATE | C250/BB250(Z150) | Z/1289 | 5.2 | +3.258 | +3.685 | 79
2 x BRIDGING BRACKET | C250/BB250(Z150) | PL/152 | 1.5 | +3.390 | +3.610 | 6
BEAM | C250-C250/BB250(Z150) | B/70 | 15.3 | +3.373 | +3.627 | 76
FASCIA | C250-C250/BB250(Z100) | F/12 | 7.9 | +3.513 | +3.665 | 64
BB TRUSS BRACKET | C250-C250/BB250(Z100) | PL/2061 | 3.1 | +3.389 | +3.690 | 147.999
PURLIN | C250-C250/BB250(Z100)-BB250(Z150) | PU/13 | 4.1 | +3.747 | +3.867 | 100.5
2 x PLATE | C250/BB250(Z100) | Z/1289 | 5.2 | +3.275 | +3.702 | 79
2 x BRIDGING BRACKET | C250/BB250(Z100) | PL/152 | 1.5 | +3.403 | +3.623 | 6
BEAM | C250-C250/BB250(Z100) | B/70 | 15.3 | +3.386 | +3.640 | 76
COLUMN | C200/BB300(Z200) | C/64 | 26.3 | +0.000 | +3.710 | 76
COLUMN | C200/BB300(Z150) | C/63 | 26.1 | +0.000 | +3.689 | 76
COLUMN | C200/BB300(Z100) | C/62 | 26 | +0.000 | +3.665 | 76
COLUMN | C200/BB250(Z200) | C/64 | 26.3 | +0.000 | +3.710 | 76
COLUMN | C200/BB250(Z150) | C/63 | 26.1 | +0.000 | +3.689 | 76
COLUMN | C200/BB250(Z100) | C/62 | 26 | +0.000 | +3.665 | 76
COLUMN | C200/BB200(Z200) | C/64 | 26.3 | +0.000 | +3.710 | 76
COLUMN | C200/BB200(Z150) | C/63 | 26.1 | +0.000 | +3.689 | 76
COLUMN | C200/BB200(Z100) | C/62 | 26 | +0.000 | +3.665 | 76
BRIDGING BEAM | C200-C200/BB300(Z200) | BB/5 | 19 | +3.385 | +3.685 | 96
BRIDGING BEAM | C200-C200/BB300(Z150) | BB/5 | 19 | +3.389 | +3.689 | 96
BRIDGING BEAM | C200-C200/BB300(Z100) | BB/5 | 19 | +3.365 | +3.665 | 96
2 x FASCIA BRACKET | C200/BB300(Z200) | Z/2954 | 0.8 | +3.554 | +3.715 | 161
FASCIA BRACKET | C200-C200/BB300(Z200) | Z/2994 | 0.8 | +3.554 | +3.715 | 161
2 x FASCIA BRACKET | C200/BB250(Z200) | Z/2954 | 0.8 | +3.554 | +3.715 | 161
FASCIA BRACKET | C200-C200/BB250(Z200) | Z/2994 | 0.8 | +3.554 | +3.715 | 161
2 x FASCIA BRACKET | C200/BB200(Z200) | Z/2954 | 0.8 | +3.554 | +3.715 | 161
FASCIA BRACKET | C200-C200/BB200(Z200) | Z/2994 | 0.8 | +3.554 | +3.715 | 161
2 x FASCIA BRACKET | C200/BB300(Z150) | Z/2953 | 0.6 | +3.532 | +3.693 | 161
FASCIA BRACKET | C200-C200/BB300(Z150) | Z/2953 | 0.6 | +3.532 | +3.693 | 161
2 x FASCIA BRACKET | C200/BB250(Z150) | Z/2953 | 0.6 | +3.532 | +3.693 | 161
FASCIA BRACKET | C200-C200/BB250(Z150) | Z/2981 | 0.6 | +3.532 | +3.693 | 161
2 x FASCIA BRACKET | C200/BB200(Z150) | Z/2953 | 0.6 | +3.532 | +3.693 | 161
FASCIA BRACKET | C200-C200/BB200(Z150) | Z/2981 | 0.6 | +3.532 | +3.693 | 161
2 x FASCIA BRACKET | C200/BB300(Z100) | Z/2951 | 0.4 | +3.509 | +3.670 | 161
FASCIA BRACKET | C200-C200/BB300(Z100) | Z/2980 | 0.4 | +3.509 | +3.670 | 161
2 x FASCIA BRACKET | C200/BB250(Z100) | Z/2951 | 0.4 | +3.509 | +3.670 | 161
FASCIA BRACKET | C200-C200/BB250(Z100) | Z/2980 | 0.4 | +3.509 | +3.670 | 161
2 x FASCIA BRACKET | C200/BB200(Z100) | Z/2951 | 0.4 | +3.509 | +3.670 | 161
FASCIA BRACKET | C200-C200/BB200(Z100) | Z/2980 | 0.4 | +3.509 | +3.670 | 161
BRIDGING U-PLATE | C200-C200/BB300(Z200) | PL/2038 | 3.6 | +3.381 | +3.689 | 308
BRIDGING U-PLATE | C200-C200/BB300(Z150) | PL/2037 | 3.6 | +3.385 | +3.693 | 308
BRIDGING U-PLATE | C200-C200/BB300(Z100) | PL/2031 | 3.6 | +3.361 | +3.669 | 308
BRIDGING U-PLATE | C200-C200/BB250(Z200) | PL/2026 | 3 | +3.387 | +3.649 | 262
BRIDGING BEAM | C200-C200/BB250(Z200) | BB/3 | 15.3 | +3.391 | +3.645 | 76
BRIDGING U-PLATE | C200-C200/BB250(Z150) | PL/2026 | 3 | +3.407 | +3.669 | 262
BRIDGING BEAM | C200-C200/BB250(Z150) | BB/3 | 15.3 | +3.411 | +3.665 | 76
BRIDGING U-PLATE | C200-C200/BB250(Z100) | PL/2025 | 3 | +3.407 | +3.669 | 262
BRIDGING BEAM | C200-C200/BB250(Z100) | BB/3 | 15.3 | +3.411 | +3.665 | 76
BRIDGING U-PLATE | C200-C200/BB200(Z200) | PL/2017 | 2.6 | +3.388 | +3.599 | 211
BRIDGING BEAM | C200-C200/BB200(Z200) | BB/1 | 13.5 | +3.392 | +3.595 | 76
BRIDGING U-PLATE | C200-C200/BB200(Z150) | PL/2035 | 2.6 | +3.407 | +3.618 | 211
BRIDGING BEAM | C200-C200/BB200(Z150) | BB/1 | 13.5 | +3.411 | +3.614 | 76
RAFTER | C200-C200/BB300(Z200)-BB350(Z100) | R/93 | 3.9 | +3.393 | +3.706 | 76
RAFTER | C200-C200/BB300(Z150)-BB300(Z200) | R/93 | 3.9 | +3.412 | +3.725 | 76
RAFTER | C200-C200/BB300(Z100)-BB300(Z150) | R/93 | 3.9 | +3.429 | +3.742 | 76
RAFTER | C200-C200/BB250(Z200)-BB300(Z100) | R/93 | 3.9 | +3.393 | +3.706 | 76
RAFTER | C200-C200/BB250(Z150)-BB250(Z200) | R/93 | 3.9 | +3.412 | +3.725 | 76
RAFTER | C200-C200/BB250(Z100)-BB250(Z150) | R/93 | 3.9 | +3.429 | +3.742 | 76
RAFTER | C200-C200/BB200(Z200)-BB250(Z100) | R/93 | 3.9 | +3.393 | +3.706 | 76
RAFTER | C200-C200/BB200(Z150)-BB200(Z200) | R/93 | 3.9 | +3.412 | +3.725 | 76
2 x RAFTER | C200/BB300(Z200)-BB350(Z100) | R/92 | 3.9 | +3.393 | +3.706 | 76
2 x RAFTER | C200/BB300(Z150)-BB300(Z200) | R/92 | 3.9 | +3.412 | +3.725 | 76
2 x RAFTER | C200/BB300(Z100)-BB300(Z150) | R/92 | 3.9 | +3.429 | +3.742 | 76
COLUMN | C200/BB300(Z200) | C/67 | 26.3 | +0.000 | +3.710 | 76
FASCIA STIFFENER | C200-C200/BB300(Z200) | PL/113 | 0.8 | +3.385 | +3.685 | 3
COLUMN | C200/BB300(Z150) | C/66 | 26.1 | +0.000 | +3.689 | 76
FASCIA STIFFENER | C200-C200/BB300(Z150) | PL/113 | 0.8 | +3.389 | +3.689 | 3
COLUMN | C200/BB300(Z100) | C/65 | 26 | +0.000 | +3.665 | 76
FASCIA STIFFENER | C200-C200/BB300(Z100) | PL/113 | 0.8 | +3.365 | +3.665 | 3
2 x RAFTER | C200/BB250(Z200)-BB300(Z100) | R/92 | 3.9 | +3.393 | +3.706 | 76
2 x RAFTER | C200/BB250(Z150)-BB250(Z200) | R/92 | 3.9 | +3.412 | +3.725 | 76
2 x RAFTER | C200/BB250(Z100)-BB250(Z150) | R/92 | 3.9 | +3.429 | +3.742 | 76
COLUMN | C200/BB250(Z200) | C/67 | 26.3 | +0.000 | +3.710 | 76
FASCIA STIFFENER | C200-C200/BB250(Z200) | PL/128 | 0.6 | +3.391 | +3.645 | 3
COLUMN | C200/BB250(Z150) | C/66 | 26.1 | +0.000 | +3.689 | 76
FASCIA STIFFENER | C200-C200/BB250(Z150) | PL/128 | 0.6 | +3.411 | +3.665 | 3
COLUMN | C200/BB250(Z100) | C/65 | 26 | +0.000 | +3.665 | 76
FASCIA STIFFENER | C200-C200/BB250(Z100) | PL/128 | 0.6 | +3.411 | +3.665 | 3
BRIDGING BEAM | C200-C200/BB200(Z100) | BB/1 | 13.5 | +3.428 | +3.631 | 76
RAFTER | C200-C200/BB200(Z100)-BB200(Z150) | R/93 | 3.9 | +3.429 | +3.742 | 76
BRIDGING U-PLATE | C200-C200/BB200(Z100) | PL/2035 | 2.6 | +3.424 | +3.635 | 211
FASCIA STIFFENER | C200-C200/BB200(Z200) | PL/156 | 0.6 | +3.392 | +3.595 | 3
2 x RAFTER | C200/BB200(Z200)-BB250(Z100) | R/92 | 3.9 | +3.393 | +3.706 | 76
COLUMN | C200/BB200(Z200) | C/67 | 26.3 | +0.000 | +3.710 | 76
FASCIA STIFFENER | C200-C200/BB200(Z150) | PL/156 | 0.6 | +3.411 | +3.614 | 3
2 x RAFTER | C200/BB200(Z150)-BB200(Z200) | R/92 | 3.9 | +3.412 | +3.725 | 76
COLUMN | C200/BB200(Z150) | C/66 | 26.1 | +0.000 | +3.689 | 76
FASCIA STIFFENER | C200-C200/BB200(Z100) | PL/156 | 0.6 | +3.428 | +3.631 | 3
2 x RAFTER | C200/BB200(Z100)-BB200(Z150) | R/92 | 3.9 | +3.429 | +3.742 | 76
COLUMN | C200/BB200(Z100) | C/65 | 26 | +0.000 | +3.665 | 76
BRIDGING-COLUMN STIFF | C200/BB300(Z200) | PL/111 | 2.6 | +3.360 | +3.710 | 64.2
BRIDGING-COLUMN STIFF | C200/BB300(Z150) | PL/111 | 2.6 | +3.339 | +3.689 | 64.2
BRIDGING-COLUMN STIFF | C200/BB300(Z100) | PL/111 | 2.6 | +3.315 | +3.665 | 64.2
BRIDGING-COLUMN STIFF | C200/BB250(Z200) | PL/111 | 2.6 | +3.360 | +3.710 | 64.2
BRIDGING-COLUMN STIFF | C200/BB250(Z150) | PL/111 | 2.6 | +3.339 | +3.689 | 64.2
BRIDGING-COLUMN STIFF | C200/BB250(Z100) | PL/111 | 2.6 | +3.315 | +3.665 | 64.2
BRIDGING-COLUMN STIFF | C200/BB200(Z200) | PL/111 | 2.6 | +3.360 | +3.710 | 64.2
BRIDGING-COLUMN STIFF | C200/BB200(Z150) | PL/111 | 2.6 | +3.339 | +3.689 | 64.2
BRIDGING-COLUMN STIFF | C200/BB200(Z100) | PL/111 | 2.6 | +3.315 | +3.665 | 64.2
2 x BRIDGING BRACKET | C200/BB300(Z200) | PL/218 | 1.8 | +3.400 | +3.670 | 6
2 x BRIDGING BRACKET | C200/BB300(Z150) | PL/218 | 1.8 | +3.404 | +3.674 | 6
2 x BRIDGING BRACKET | C200/BB300(Z100) | PL/218 | 1.8 | +3.380 | +3.650 | 6
BB TRUSS BRACKET | C200-C200/BB300(Z200) | PL/2057 | 1.8 | +3.393 | +3.626 | 147.999
BB TRUSS BRACKET | C200-C200/BB300(Z200) | PL/2054 | 1.8 | +3.393 | +3.626 | 147.999
BB TRUSS BRACKET | C200-C200/BB300(Z150) | PL/2057 | 1.8 | +3.412 | +3.645 | 147.999
BB TRUSS BRACKET | C200-C200/BB300(Z150) | PL/2054 | 1.8 | +3.412 | +3.645 | 147.999
BB TRUSS BRACKET | C200-C200/BB300(Z100) | PL/2057 | 1.8 | +3.429 | +3.662 | 147.999
BB TRUSS BRACKET | C200-C200/BB300(Z100) | PL/2054 | 1.8 | +3.429 | +3.662 | 147.999
BB TRUSS BRACKET | C200-C200/BB250(Z200) | PL/2056 | 1.9 | +3.384 | +3.626 | 147.999
BB TRUSS BRACKET | C200-C200/BB250(Z200) | PL/2053 | 1.9 | +3.384 | +3.626 | 147.999
BB TRUSS BRACKET | C200-C200/BB250(Z150) | PL/2056 | 1.9 | +3.404 | +3.645 | 147.999
BB TRUSS BRACKET | C200-C200/BB250(Z150) | PL/2053 | 1.9 | +3.404 | +3.645 | 147.999
BB TRUSS BRACKET | C200-C200/BB250(Z100) | PL/2056 | 1.9 | +3.421 | +3.662 | 147.999
BB TRUSS BRACKET | C200-C200/BB250(Z100) | PL/2053 | 1.9 | +3.421 | +3.662 | 147.999
BB TRUSS BRACKET | C200-C200/BB200(Z200) | PL/2055 | 1.8 | +3.394 | +3.626 | 147.999
BB TRUSS BRACKET | C200-C200/BB200(Z200) | PL/2052 | 1.8 | +3.394 | +3.626 | 147.999
BB TRUSS BRACKET | C200-C200/BB200(Z150) | PL/2055 | 1.8 | +3.413 | +3.645 | 147.999
BB TRUSS BRACKET | C200-C200/BB200(Z150) | PL/2052 | 1.8 | +3.413 | +3.645 | 147.999
GIRT | C200-C200/BB300(Z200) | G/11 | 11.3 | +3.065 | +3.216 | 151.5
GIRT | C200-C200/BB300(Z150) | G/10 | 8.9 | +3.078 | +3.202 | 124.5
GIRT | C200-C200/BB300(Z100) | G/9 | 6.6 | +3.090 | +3.190 | 100.5
GIRT | C200-C200/BB250(Z200) | G/11 | 11.3 | +3.065 | +3.216 | 151.5
GIRT | C200-C200/BB250(Z150) | G/10 | 8.9 | +3.078 | +3.202 | 124.5
GIRT | C200-C200/BB250(Z100) | G/9 | 6.6 | +3.090 | +3.190 | 100.5
GIRT | C200-C200/BB200(Z200) | G/11 | 11.3 | +3.065 | +3.216 | 151.5
GIRT | C200-C200/BB200(Z150) | G/10 | 8.9 | +3.078 | +3.202 | 124.5
GIRT | C200-C200/BB200(Z100) | G/9 | 6.6 | +3.090 | +3.190 | 100.5
2 x PLATE | C200/BB300(Z200) | Z/227 | 3.1 | +3.323 | +3.637 | 79
2 x PLATE | C200/BB300(Z150) | Z/227 | 3.1 | +3.343 | +3.657 | 79
2 x PLATE | C200/BB300(Z100) | Z/227 | 3.1 | +3.360 | +3.674 | 79
PURLIN | C200-C200/BB300(Z200)-BB350(Z100) | PU/12 | 11.3 | +3.690 | +3.921 | 151.5
FASCIA | C200-C200/BB300(Z200) | F/16 | 8.9 | +3.558 | +3.710 | 64
BRIDGING BEAM | C200-C200/BB300(Z200) | BB/6 | 19 | +3.385 | +3.685 | 96
PURLIN | C200-C200/BB300(Z150)-BB300(Z200) | PU/11 | 8.9 | +3.713 | +3.887 | 124.5
FASCIA | C200-C200/BB300(Z150) | F/16 | 8.9 | +3.537 | +3.689 | 64
BRIDGING BEAM | C200-C200/BB300(Z150) | BB/6 | 19 | +3.389 | +3.689 | 96
PURLIN | C200-C200/BB300(Z100)-BB300(Z150) | PU/10 | 6.6 | +3.732 | +3.853 | 100.5
FASCIA | C200-C200/BB300(Z100) | F/16 | 8.9 | +3.513 | +3.665 | 64
BRIDGING BEAM | C200-C200/BB300(Z100) | BB/6 | 19 | +3.365 | +3.665 | 96
2 x PLATE | C200/BB250(Z200) | Z/227 | 3.1 | +3.323 | +3.637 | 79
2 x PLATE | C200/BB250(Z150) | Z/227 | 3.1 | +3.343 | +3.657 | 79
2 x PLATE | C200/BB250(Z100) | Z/227 | 3.1 | +3.360 | +3.674 | 79
2 x BRIDGING BRACKET | C200/BB250(Z200) | PL/152 | 1.5 | +3.408 | +3.628 | 6
2 x BRIDGING BRACKET | C200/BB250(Z150) | PL/152 | 1.5 | +3.428 | +3.648 | 6
2 x BRIDGING BRACKET | C200/BB250(Z100) | PL/152 | 1.5 | +3.428 | +3.648 | 6
PURLIN | C200-C200/BB250(Z200)-BB300(Z100) | PU/12 | 11.3 | +3.690 | +3.921 | 151.5
FASCIA | C200-C200/BB250(Z200) | F/16 | 8.9 | +3.558 | +3.710 | 64
BRIDGING BEAM | C200-C200/BB250(Z200) | BB/4 | 15.3 | +3.391 | +3.645 | 76
PURLIN | C200-C200/BB250(Z150)-BB250(Z200) | PU/11 | 8.9 | +3.713 | +3.887 | 124.5
FASCIA | C200-C200/BB250(Z150) | F/16 | 8.9 | +3.537 | +3.689 | 64
BRIDGING BEAM | C200-C200/BB250(Z150) | BB/4 | 15.3 | +3.411 | +3.665 | 76
PURLIN | C200-C200/BB250(Z100)-BB250(Z150) | PU/10 | 6.6 | +3.732 | +3.853 | 100.5
FASCIA | C200-C200/BB250(Z100) | F/16 | 8.9 | +3.513 | +3.665 | 64
BRIDGING BEAM | C200-C200/BB250(Z100) | BB/4 | 15.3 | +3.411 | +3.665 | 76
BB TRUSS BRACKET | C200-C200/BB200(Z100) | PL/2055 | 1.8 | +3.430 | +3.662 | 147.999
BB TRUSS BRACKET | C200-C200/BB200(Z100) | PL/2052 | 1.8 | +3.430 | +3.662 | 147.999
2 x BRIDGING BRACKET | C200/BB200(Z200) | PL/214 | 1.2 | +3.409 | +3.579 | 6
2 x PLATE | C200/BB200(Z200) | Z/227 | 3.1 | +3.323 | +3.637 | 79
PURLIN | C200-C200/BB200(Z200)-BB250(Z100) | PU/12 | 11.3 | +3.690 | +3.921 | 151.5
FASCIA | C200-C200/BB200(Z200) | F/16 | 8.9 | +3.558 | +3.710 | 64
BRIDGING BEAM | C200-C200/BB200(Z200) | BB/2 | 13.5 | +3.392 | +3.595 | 76
2 x BRIDGING BRACKET | C200/BB200(Z150) | PL/214 | 1.2 | +3.427 | +3.597 | 6
2 x PLATE | C200/BB200(Z150) | Z/227 | 3.1 | +3.343 | +3.657 | 79
PURLIN | C200-C200/BB200(Z150)-BB200(Z200) | PU/11 | 8.9 | +3.713 | +3.887 | 124.5
FASCIA | C200-C200/BB200(Z150) | F/16 | 8.9 | +3.537 | +3.689 | 64
BRIDGING BEAM | C200-C200/BB200(Z150) | BB/2 | 13.5 | +3.411 | +3.614 | 76
2 x BRIDGING BRACKET | C200/BB200(Z100) | PL/214 | 1.2 | +3.445 | +3.615 | 6
2 x PLATE | C200/BB200(Z100) | Z/227 | 3.1 | +3.360 | +3.674 | 79
PURLIN | C200-C200/BB200(Z100)-BB200(Z150) | PU/10 | 6.6 | +3.732 | +3.853 | 100.5
FASCIA | C200-C200/BB200(Z100) | F/16 | 8.9 | +3.513 | +3.665 | 64
BRIDGING BEAM | C200-C200/BB200(Z100) | BB/2 | 13.5 | +3.428 | +3.631 | 76
COLUMN | C150/BB250(Z200) | Z/2596(?) | 20.7 | +0.000 | +3.711 | 64
COLUMN | C150/BB250(Z150) | Z/2572 | 20.4 | +0.000 | +3.664 | 64
COLUMN | C150/BB250(Z100) | Z/2575 | 20.2 | +0.000 | +3.619 | 64
COLUMN | C150/BB200(Z200) | Z/2571 | 20.4 | +0.000 | +3.665 | 64
COLUMN | C150/BB200(Z150) | Z/2532 | 20.2 | +0.000 | +3.643 | 64
COLUMN | C150/BB200(Z100) | Z/2575 | 20.2 | +0.000 | +3.619 | 64
BRIDGING U-PLATE | C150-C150/BB250(Z200) | PL/2016 | 3 | +3.428 | +3.690 | 262
RAFTER | C150-C150/BB250(Z200)-BB300(Z100) | Z/2555 | 2.6 | +3.432 | +3.677 | 64
BRIDGING U-PLATE | C150-C150/BB250(Z150) | PL/2015 | 3 | +3.406 | +3.668 | 262
RAFTER | C150-C150/BB250(Z150)-BB250(Z200) | Z/2555 | 2.6 | +3.427 | +3.672 | 64
BRIDGING U-PLATE | C150-C150/BB250(Z100) | PL/2014 | 3 | +3.361 | +3.623 | 262
RAFTER | C150-C150/BB250(Z100)-BB250(Z150) | Z/2555 | 2.6 | +3.422 | +3.668 | 64
BRIDGING U-PLATE | C150-C150/BB200(Z200) | PL/2007 | 2.6 | +3.382 | +3.593 | 211
RAFTER | C150-C150/BB200(Z200)-BB250(Z100) | Z/2555 | 2.6 | +3.386 | +3.631 | 64
BRIDGING U-PLATE | C150-C150/BB200(Z150) | PL/1999 | 2.6 | +3.401 | +3.612 | 211
RAFTER | C150-C150/BB200(Z150)-BB200(Z200) | Z/2555 | 2.6 | +3.405 | +3.651 | 64
BRIDGING U-PLATE | C150-C150/BB200(Z100) | PL/2005 | 2.6 | +3.412 | +3.623 | 211
RAFTER | C150-C150/BB200(Z100)-BB200(Z150) | Z/2555 | 2.6 | +3.422 | +3.668 | 64
BEAM | C150-C150/BB250(Z200) | B/80 | 15.3 | +3.432 | +3.686 | 76
BEAM | C150-C150/BB250(Z150) | B/80 | 15.3 | +3.410 | +3.664 | 76
BEAM | C150-C150/BB250(Z100) | B/80 | 15.3 | +3.365 | +3.619 | 76
2 x RAFTER | C150/BB250(Z100)-BB250(Z150) | Z/222 | 2.6 | +3.422 | +3.668 | 64
2 x RAFTER | C150/BB250(Z150)-BB250(Z200) | Z/222 | 2.6 | +3.427 | +3.672 | 64
2 x RAFTER | C150/BB250(Z200)-BB300(Z100) | Z/222 | 2.6 | +3.432 | +3.677 | 64
BEAM | C150-C150/BB250(Z200) | B/91 | 15.3 | +3.432 | +3.686 | 76
BEAM | C150-C150/BB250(Z150) | B/91 | 15.3 | +3.410 | +3.664 | 76
BEAM | C150-C150/BB250(Z100) | B/91 | 15.3 | +3.365 | +3.619 | 76
FASCIA STIFFENER | C150-C150/BB250(Z200) | PL/128 | 0.6 | +3.432 | +3.686 | 3
2 x FASCIA BRACKET | C150/BB250(Z200) | Z/2533 | 0.4 | +3.556 | +3.713 | 157.2
FASCIA BRACKET | C150-C150/BB250(Z200) | Z/2533 | 0.4 | +3.556 | +3.713 | 157.2
COLUMN | C150/BB250(Z200) | Z/2641 | 20.7 | +0.000 | +3.711 | 64
FASCIA STIFFENER | C150-C150/BB250(Z150) | PL/128 | 0.6 | +3.410 | +3.664 | 3
2 x FASCIA BRACKET | C150/BB250(Z150) | Z/2515 | 0.4 | +3.510 | +3.667 | 157.2
FASCIA BRACKET | C150-C150/BB250(Z150) | Z/2515 | 0.4 | +3.510 | +3.667 | 157.2
COLUMN | C150/BB250(Z150) | Z/2640 | 20.4 | +0.000 | +3.664 | 64
FASCIA STIFFENER | C150-C150/BB250(Z100) | PL/128 | 0.6 | +3.365 | +3.619 | 3
2 x FASCIA BRACKET | C150/BB250(Z100) | Z/2514 | 0.4 | +3.465 | +3.622 | 157.2
FASCIA BRACKET | C150-C150/BB250(Z100) | Z/2514 | 0.4 | +3.465 | +3.622 | 157.2
COLUMN | C150/BB250(Z100) | Z/1584 | 20.2 | +0.000 | +3.619 | 64
BEAM | C150-C150/BB200(Z200) | B/15 | 13.6 | +3.386 | +3.589 | 76
BEAM | C150-C150/BB200(Z150) | B/15 | 13.6 | +3.405 | +3.608 | 76
BEAM | C150-C150/BB200(Z100) | B/15 | 13.6 | +3.416 | +3.619 | 76
BEAM | C150-C150/BB200(Z200) | B/38 | 13.6 | +3.386 | +3.589 | 76
2 x RAFTER | C150/BB200(Z200)-BB250(Z100) | Z/222 | 2.6 | +3.386 | +3.631 | 64
FASCIA STIFFENER | C150-C150/BB200(Z200) | PL/156 | 0.6 | +3.386 | +3.589 | 3
2 x FASCIA BRACKET | C150/BB200(Z200) | Z/2533 | 0.4 | +3.510 | +3.667 | 157.2
FASCIA BRACKET | C150-C150/BB200(Z200) | Z/2533 | 0.4 | +3.510 | +3.667 | 157.2
COLUMN | C150/BB200(Z200) | Z/2639 | 20.4 | +0.000 | +3.665 | 64
BEAM | C150-C150/BB200(Z150) | B/38 | 13.6 | +3.405 | +3.608 | 76
2 x RAFTER | C150/BB200(Z150)-BB200(Z200) | Z/222 | 2.6 | +3.405 | +3.651 | 64
FASCIA STIFFENER | C150-C150/BB200(Z150) | PL/156 | 0.6 | +3.405 | +3.608 | 3
2 x FASCIA BRACKET | C150/BB200(Z150) | Z/2515 | 0.4 | +3.488 | +3.645 | 157.2
FASCIA BRACKET | C150-C150/BB200(Z150) | Z/2515 | 0.4 | +3.488 | +3.645 | 157.2
COLUMN | C150/BB200(Z150) | Z/2638 | 20.2 | +0.000 | +3.643 | 64
BEAM | C150-C150/BB200(Z100) | B/38 | 13.6 | +3.416 | +3.619 | 76
2 x RAFTER | C150/BB200(Z100)-BB200(Z150) | Z/222 | 2.6 | +3.422 | +3.668 | 64
FASCIA STIFFENER | C150-C150/BB200(Z100) | PL/156 | 0.6 | +3.416 | +3.619 | 3
2 x FASCIA BRACKET | C150/BB200(Z100) | Z/2514 | 0.4 | +3.465 | +3.622 | 157.2
FASCIA BRACKET | C150-C150/BB200(Z100) | Z/2514 | 0.4 | +3.465 | +3.622 | 157.2
COLUMN | C150/BB200(Z100) | Z/1584 | 20.2 | +0.000 | +3.619 | 64
BRIDGING-COLUMN STIFF | C150/BB250(Z200) | PL/91(?) | 1.9 | +3.361 | +3.711 | 52.2
BRIDGING-COLUMN STIFF | C150/BB250(Z150) | PL/91 | 1.9 | +3.314 | +3.664 | 52.2
BRIDGING-COLUMN STIFF | C150/BB250(Z100) | PL/91 | 1.9 | +3.269 | +3.619 | 52.2
BRIDGING-COLUMN STIFF | C150/BB200(Z200) | PL/91 | 1.9 | +3.315 | +3.665 | 52.2
BRIDGING-COLUMN STIFF | C150/BB200(Z150) | PL/91 | 1.9 | +3.293 | +3.643 | 52.2
BRIDGING-COLUMN STIFF | C150/BB200(Z100) | PL/91 | 1.9 | +3.269 | +3.619 | 52.2
BB TRUSS BRACKET | C150-C150/BB250(Z200) | PL/2050 | 1.2 | +3.436 | +3.616 | 147.999
BB TRUSS BRACKET | C150-C150/BB250(Z200) | PL/2051 | 1.2 | +3.436 | +3.616 | 147.999
BB TRUSS BRACKET | C150-C150/BB250(Z150) | PL/2050 | 1.2 | +3.431 | +3.611 | 147.999
BB TRUSS BRACKET | C150-C150/BB250(Z150) | PL/2051 | 1.2 | +3.431 | +3.611 | 147.999
BB TRUSS BRACKET | C150-C150/BB250(Z100) | PL/2050 | 1.2 | +3.426 | +3.606 | 147.999
BB TRUSS BRACKET | C150-C150/BB250(Z100) | PL/2051 | 1.2 | +3.426 | +3.606 | 147.999
BB TRUSS BRACKET | C150-C150/BB200(Z200) | PL/2050 | 1.2 | +3.390 | +3.570 | 147.999
BB TRUSS BRACKET | C150-C150/BB200(Z200) | PL/2051 | 1.2 | +3.390 | +3.570 | 147.999
BB TRUSS BRACKET | C150-C150/BB200(Z150) | PL/2050 | 1.2 | +3.409 | +3.589 | 147.999
BB TRUSS BRACKET | C150-C150/BB200(Z150) | PL/2051 | 1.2 | +3.409 | +3.589 | 147.999
BB TRUSS BRACKET | C150-C150/BB200(Z100) | PL/2050 | 1.2 | +3.426 | +3.606 | 147.999
BB TRUSS BRACKET | C150-C150/BB200(Z100) | PL/2051 | 1.2 | +3.426 | +3.606 | 147.999
GIRT | C150-C150/BB250(Z200) | G/8 | 7.2 | +3.106 | +3.258 | 151.5
GIRT | C150-C150/BB250(Z150) | G/7 | 5.9 | +3.119 | +3.244 | 124.5
GIRT | C150-C150/BB250(Z100) | G/6 | 4.1 | +3.131 | +3.232 | 100.5
GIRT | C150-C150/BB200(Z200) | G/8 | 7.2 | +3.106 | +3.258 | 151.5
GIRT | C150-C150/BB200(Z150) | G/7 | 5.9 | +3.119 | +3.244 | 124.5
GIRT | C150-C150/BB200(Z100) | G/6 | 4.1 | +3.131 | +3.232 | 100.5
2 x PLATE | C150/BB250(Z100) | Z/220 | 2.5 | +3.314 | +3.617 | 67
2 x PLATE | C150/BB250(Z150) | Z/2518 | 2.5 | +3.319 | +3.621 | 67
2 x PLATE | C150/BB250(Z200) | Z/2519 | 2.5 | +3.324 | +3.626 | 67
2 x BRIDGING BRACKET | C150/BB250(Z200) | PL/152 | 1.5 | +3.449 | +3.669 | 6
2 x BRIDGING BRACKET | C150/BB250(Z150) | PL/152 | 1.5 | +3.427 | +3.647 | 6
2 x BRIDGING BRACKET | C150/BB250(Z100) | PL/152 | 1.5 | +3.382 | +3.602 | 6
PURLIN | C150-C150/BB250(Z100)-BB250(Z150) | PU/7 | 4.1 | +3.658 | +3.778 | 100.5
PURLIN | C150-C150/BB250(Z200)-BB300(Z100) | PU/9 | 7.2 | +3.662 | +3.892 | 151.5
FASCIA | C150-C150/BB250(Z200) | F/11 | 7.7 | +3.559 | +3.711 | 64
PURLIN | C150-C150/BB250(Z150)-BB250(Z200) | PU/8 | 5.9 | +3.660 | +3.834 | 124.5
FASCIA | C150-C150/BB250(Z150) | F/11 | 7.7 | +3.512 | +3.664 | 64
FASCIA | C150-C150/BB250(Z100) | F/11 | 7.7 | +3.467 | +3.619 | 64
2 x BRIDGING BRACKET | C150/BB200(Z200) | PL/214 | 1.2 | +3.402 | +3.572 | 6
2 x PLATE | C150/BB200(Z200) | Z/2519 | 2.5 | +3.278 | +3.580 | 67
PURLIN | C150-C150/BB200(Z200)-BB250(Z100) | PU/9 | 7.2 | +3.616 | +3.846 | 151.5
FASCIA | C150-C150/BB200(Z200) | F/11 | 7.7 | +3.513 | +3.665 | 64
2 x BRIDGING BRACKET | C150/BB200(Z150) | PL/214 | 1.2 | +3.421 | +3.591 | 6
2 x PLATE | C150/BB200(Z150) | Z/2518 | 2.5 | +3.297 | +3.600 | 67
PURLIN | C150-C150/BB200(Z150)-BB200(Z200) | PU/8 | 5.9 | +3.638 | +3.813 | 124.5
FASCIA | C150-C150/BB200(Z150) | F/11 | 7.7 | +3.491 | +3.643 | 64
2 x BRIDGING BRACKET | C150/BB200(Z100) | PL/214 | 1.2 | +3.433 | +3.603 | 6
2 x PLATE | C150/BB200(Z100) | Z/220 | 2.5 | +3.314 | +3.617 | 67
PURLIN | C150-C150/BB200(Z100)-BB200(Z150) | PU/7 | 4.1 | +3.658 | +3.778 | 100.5
FASCIA | C150-C150/BB200(Z100) | F/11 | 7.7 | +3.467 | +3.619 | 64
BRIDGING U-PLATE | C300-C300/BB300(TH96) | PL/2029 | 3.6 | +3.335 | +3.643 | 100
BRIDGING U-PLATE | C300-C300/BB350(TH96) | PL/2028 | 4.4 | +3.265 | +3.623 | 129
BRIDGING U-PLATE | C300-C300/BB300(TH120) | PL/2030 | 3.6 | +3.315 | +3.623 | 100
BRIDGING U-PLATE | C300-C300/BB350(TH120) | PL/2027 | 4.4 | +3.290 | +3.648 | 129
BRIDGING U-PLATE | C300-C300/BB350(TH75) | PL/2036 | 4.4 | +3.244 | +3.602 | 129
BRIDGING U-PLATE | C300-C300/BB300(TH75) | PL/1992 | 3.6 | +3.340 | +3.648 | 100
COLUMN | C350/BB350(TH120) | Z/2595 | 54.5 | +0.000 | +3.643 | 125
BRIDGING-COLUMN STIFF | C350/BB350(TH120) | PL/118 | 4.4 | +3.293 | +3.643 | 112
COLUMN | C350/BB350(TH96) | Z/2590 | 54.5 | +0.000 | +3.643 | 125
BRIDGING-COLUMN STIFF | C350/BB350(TH96) | PL/118 | 4.4 | +3.293 | +3.643 | 112
COLUMN | C350/BB350(TH75) | Z/2589 | 54.5 | +0.000 | +3.643 | 125
BRIDGING-COLUMN STIFF | C350/BB350(TH75) | PL/118 | 4.4 | +3.293 | +3.643 | 112
COLUMN | C300/BB350(TH120) | Z/2587 | 45.6 | +0.000 | +3.644 | 96
BRIDGING-COLUMN STIFF | C300/BB350(TH120) | PL/117 | 3.7 | +3.294 | +3.644 | 83
COLUMN | C300/BB350(TH96) | Z/2588 | 45.3 | +0.000 | +3.619 | 96
BRIDGING-COLUMN STIFF | C300/BB350(TH96) | PL/117 | 3.7 | +3.269 | +3.619 | 83
COLUMN | C300/BB350(TH75) | Z/225 | 45 | +0.000 | +3.598 | 96
BRIDGING-COLUMN STIFF | C300/BB350(TH75) | PL/117 | 3.7 | +3.248 | +3.598 | 83
COLUMN | C300/BB300(TH120) | Z/2587 | 45.6 | +0.000 | +3.644 | 96
BRIDGING-COLUMN STIFF | C300/BB300(TH120) | PL/117 | 3.7 | +3.294 | +3.644 | 83
COLUMN | C300/BB300(TH96) | Z/2586 | 45.6 | +0.000 | +3.644 | 96
BRIDGING-COLUMN STIFF | C300/BB300(TH96) | PL/117 | 3.7 | +3.294 | +3.644 | 83
COLUMN | C300/BB300(TH75) | Z/2585 | 45.6 | +0.000 | +3.644 | 96
BRIDGING-COLUMN STIFF | C300/BB300(TH75) | PL/117 | 3.7 | +3.294 | +3.644 | 83
COLUMN | C250/BB350(TH120) | Z/2584 | 29.2 | +0.000 | +3.643 | 76
BRIDGING-COLUMN STIFF | C250/BB350(TH120) | PL/114 | 3 | +3.293 | +3.643 | 64.2
COLUMN | C250/BB350(TH96) | Z/2578 | 29.2 | +0.000 | +3.643 | 76
BRIDGING-COLUMN STIFF | C250/BB350(TH96) | PL/114 | 3 | +3.293 | +3.643 | 64.2
COLUMN | C250/BB350(TH75) | Z/2577 | 29.2 | +0.000 | +3.643 | 76
BRIDGING-COLUMN STIFF | C250/BB350(TH75) | PL/114 | 3 | +3.293 | +3.643 | 64.2
COLUMN | C250/BB300(TH120) | Z/2584 | 29.2 | +0.000 | +3.643 | 76
BRIDGING-COLUMN STIFF | C250/BB300(TH120) | PL/114 | 3 | +3.293 | +3.643 | 64.2
COLUMN | C250/BB300(TH96) | Z/2578 | 29.2 | +0.000 | +3.643 | 76
BRIDGING-COLUMN STIFF | C250/BB300(TH96) | PL/114 | 3 | +3.293 | +3.643 | 64.2
COLUMN | C250/BB300(TH75) | Z/2577 | 29.2 | +0.000 | +3.643 | 76
BRIDGING-COLUMN STIFF | C250/BB300(TH75) | PL/114 | 3 | +3.293 | +3.643 | 64.2
COLUMN | C250/BB250(TH120) | Z/2584 | 29.2 | +0.000 | +3.643 | 76
BRIDGING-COLUMN STIFF | C250/BB250(TH120) | PL/114 | 3 | +3.293 | +3.643 | 64.2
COLUMN | C250/BB250(TH96) | Z/2578 | 29.2 | +0.000 | +3.643 | 76
BRIDGING-COLUMN STIFF | C250/BB250(TH96) | PL/114 | 3 | +3.293 | +3.643 | 64.2
COLUMN | C250/BB250(TH75) | Z/2577 | 29.2 | +0.000 | +3.643 | 76
BRIDGING-COLUMN STIFF | C250/BB250(TH75) | PL/114 | 3 | +3.293 | +3.643 | 64.2
COLUMN | C200/BB300(TH120) | C/61 | 25.8 | +0.000 | +3.643 | 76
BRIDGING-COLUMN STIFF | C200/BB300(TH120) | PL/111 | 2.6 | +3.293 | +3.643 | 64.2
COLUMN | C200/BB300(TH96) | C/60 | 25.8 | +0.000 | +3.643 | 76
BRIDGING-COLUMN STIFF | C200/BB300(TH96) | PL/111 | 2.6 | +3.293 | +3.643 | 64.2
COLUMN | C200/BB300(TH75) | C/59 | 25.8 | +0.000 | +3.643 | 76
BRIDGING-COLUMN STIFF | C200/BB300(TH75) | PL/111 | 2.6 | +3.293 | +3.643 | 64.2
COLUMN | C200/BB250(TH120) | C/61 | 25.8 | +0.000 | +3.643 | 76
BRIDGING-COLUMN STIFF | C200/BB250(TH120) | PL/111 | 2.6 | +3.293 | +3.643 | 64.2
COLUMN | C200/BB250(TH96) | C/60 | 25.8 | +0.000 | +3.643 | 76
BRIDGING-COLUMN STIFF | C200/BB250(TH96) | PL/111 | 2.6 | +3.293 | +3.643 | 64.2
COLUMN | C200/BB250(TH75) | C/59 | 25.8 | +0.000 | +3.643 | 76
BRIDGING-COLUMN STIFF | C200/BB250(TH75) | PL/111 | 2.6 | +3.293 | +3.643 | 64.2
COLUMN | C200/BB200(TH120) | C/61 | 25.8 | +0.000 | +3.643 | 76
BRIDGING-COLUMN STIFF | C200/BB200(TH120) | PL/111 | 2.6 | +3.293 | +3.643 | 64.2
COLUMN | C200/BB200(TH96) | C/60 | 25.8 | +0.000 | +3.643 | 76
BRIDGING-COLUMN STIFF | C200/BB200(TH96) | PL/111 | 2.6 | +3.293 | +3.643 | 64.2
COLUMN | C200/BB200(TH75) | C/59 | 25.8 | +0.000 | +3.643 | 76
BRIDGING-COLUMN STIFF | C200/BB200(TH75) | PL/111 | 2.6 | +3.293 | +3.643 | 64.2
COLUMN | C150/BB250(TH120) | Z/2576 | 20.2 | +0.000 | +3.643 | 64
BRIDGING-COLUMN STIFF | C150/BB250(TH120) | PL/91 | 1.9 | +3.293 | +3.643 | 52.2
COLUMN | C150/BB250(TH96) | Z/2575 | 20.2 | +0.000 | +3.619 | 64
BRIDGING-COLUMN STIFF | C150/BB250(TH96) | PL/91 | 1.9 | +3.269 | +3.619 | 52.2
COLUMN | C150/BB250(TH75) | Z/2570 | 20.1 | +0.000 | +3.597 | 64
BRIDGING-COLUMN STIFF | C150/BB250(TH75) | PL/91 | 1.9 | +3.247 | +3.597 | 52.2
COLUMN | C150/BB200(TH120) | Z/2574 | 20.1 | +0.000 | +3.597 | 64
BRIDGING-COLUMN STIFF | C150/BB200(TH120) | PL/91 | 1.9 | +3.247 | +3.597 | 52.2
COLUMN | C150/BB200(TH96) | Z/2573 | 20.1 | +0.000 | +3.597 | 64
BRIDGING-COLUMN STIFF | C150/BB200(TH96) | PL/91 | 1.9 | +3.247 | +3.597 | 52.2
COLUMN | C150/BB200(TH75) | Z/2570 | 20.1 | +0.000 | +3.597 | 64
BRIDGING-COLUMN STIFF | C150/BB200(TH75) | PL/91 | 1.9 | +3.247 | +3.597 | 52.2
BEAM | C300-C300/BB300(TH120) | B/105 | 23.6 | +3.319 | +3.619 | 96
2 x BRIDGING BRACKET | C300/BB300(TH120) | PL/218(?) | 1.8 | +3.334 | +3.604 | 6
BEAM | C300-C300/BB300(TH96) | B/95 | 23.6 | +3.339 | +3.639 | 96
2 x BRIDGING BRACKET | C300/BB300(TH96) | PL/218(?) | 1.8 | +3.354 | +3.624 | 6
BEAM | C300-C300/BB300(TH75) | B/105 | 23.6 | +3.344 | +3.644 | 96
2 x BRIDGING BRACKET | C300/BB300(TH75) | PL/218(?) | 1.8 | +3.359 | +3.629 | 6
BEAM | C250-C250/BB300(TH75) | B/93 | 19 | +3.343 | +3.643 | 96
2 x BRIDGING BRACKET | C250/BB300(TH75) | PL/218 | 1.8 | +3.358 | +3.628 | 6
BEAM | C250-C250/BB300(TH96) | B/93 | 19 | +3.343 | +3.643 | 96
2 x BRIDGING BRACKET | C250/BB300(TH96) | PL/218 | 1.8 | +3.358 | +3.628 | 6
BEAM | C250-C250/BB300(TH120) | B/93 | 19 | +3.343 | +3.643 | 96
2 x BRIDGING BRACKET | C250/BB300(TH120) | PL/218 | 1.8 | +3.358 | +3.628 | 6
BRIDGING BEAM | C200-C200/BB300(TH120) | BB/5 | 19 | +3.343 | +3.643 | 96
2 x BRIDGING BRACKET | C200/BB300(TH120) | PL/218 | 1.8 | +3.358 | +3.628 | 6
BRIDGING BEAM | C200-C200/BB300(TH96) | BB/5 | 19 | +3.343 | +3.643 | 96
2 x BRIDGING BRACKET | C200/BB300(TH96) | PL/218 | 1.8 | +3.358 | +3.628 | 6
BRIDGING BEAM | C200-C200/BB300(TH75) | BB/5 | 19 | +3.343 | +3.643 | 96
2 x BRIDGING BRACKET | C200/BB300(TH75) | PL/218 | 1.8 | +3.358 | +3.628 | 6
BEAM | C250-C250/BB350(TH75) | B/94 | 28.5 | +3.293 | +3.643 | 125
2 x BRIDGING BRACKET | C250/BB350(TH75) | PL/1998 | 2.2 | +3.308 | +3.628 | 6
BEAM | C250-C250/BB350(TH96) | B/94 | 28.5 | +3.293 | +3.643 | 125
2 x BRIDGING BRACKET | C250/BB350(TH96) | PL/1998 | 2.2 | +3.308 | +3.628 | 6
BEAM | C250-C250/BB350(TH120) | B/94 | 28.5 | +3.293 | +3.643 | 125
2 x BRIDGING BRACKET | C250/BB350(TH120) | PL/1998 | 2.2 | +3.308 | +3.628 | 6
BEAM | C300-C300/BB350(TH120) | B/98 | 28.2 | +3.294 | +3.644 | 125
2 x BRIDGING BRACKET | C300/BB350(TH120) | PL/1998 | 2.2 | +3.309 | +3.629 | 6
BEAM | C300-C300/BB350(TH96) | B/98 | 28.2 | +3.269 | +3.619 | 125
2 x BRIDGING BRACKET | C300/BB350(TH96) | PL/1998 | 2.2 | +3.284 | +3.604 | 6
BEAM | C300-C300/BB350(TH75) | B/98 | 28.2 | +3.248 | +3.598 | 125
2 x BRIDGING BRACKET | C300/BB350(TH75) | PL/1998 | 2.2 | +3.263 | +3.583 | 6
BEAM | C350-C350/BB350(TH75) | B/99 | 27.7 | +3.293 | +3.643 | 125
2 x BRIDGING BRACKET | C350/BB350(TH75) | PL/1998 | 2.2 | +3.308 | +3.628 | 6
BEAM | C350-C350/BB350(TH96) | B/99 | 27.7 | +3.293 | +3.643 | 125
2 x BRIDGING BRACKET | C350/BB350(TH96) | PL/1998 | 2.2 | +3.308 | +3.628 | 6
BEAM | C350-C350/BB350(TH120) | B/99 | 27.7 | +3.278 | +3.628 | 125
2 x BRIDGING BRACKET | C350/BB350(TH120) | PL/1998 | 2.2 | +3.293 | +3.613 | 6
2 x FASCIA BRACKET | C200/BB300(TH120) | Z/2556 | 0.6 | +3.487 | +3.648 | 161
FASCIA BRACKET | C200-C200/BB300(TH120) | Z/2556 | 0.6 | +3.487 | +3.648 | 161
2 x FASCIA BRACKET | C200/BB250(TH120) | Z/2556 | 0.6 | +3.487 | +3.648 | 161
FASCIA BRACKET | C200-C200/BB250(TH120) | Z/2556 | 0.6 | +3.487 | +3.648 | 161
2 x FASCIA BRACKET | C200/BB200(TH120) | Z/2556 | 0.6 | +3.487 | +3.648 | 161
FASCIA BRACKET | C200-C200/BB200(TH120) | Z/2556 | 0.6 | +3.487 | +3.648 | 161
2 x FASCIA BRACKET | C200/BB300(TH96) | Z/2554 | 0.4 | +3.487 | +3.648 | 161
FASCIA BRACKET | C200-C200/BB300(TH96) | Z/2554 | 0.4 | +3.487 | +3.648 | 161
2 x FASCIA BRACKET | C200/BB250(TH96) | Z/2554 | 0.4 | +3.487 | +3.648 | 161
FASCIA BRACKET | C200-C200/BB250(TH96) | Z/2554 | 0.4 | +3.487 | +3.648 | 161
2 x FASCIA BRACKET | C200/BB200(TH96) | Z/2554 | 0.4 | +3.487 | +3.648 | 161
FASCIA BRACKET | C200-C200/BB200(TH96) | Z/2554 | 0.4 | +3.487 | +3.648 | 161
2 x FASCIA BRACKET | C200/BB300(TH75) | Z/2553 | 0.4 | +3.487 | +3.648 | 161
FASCIA BRACKET | C200-C200/BB300(TH75) | Z/2553 | 0.4 | +3.487 | +3.648 | 161
2 x FASCIA BRACKET | C200/BB250(TH75) | Z/2553 | 0.4 | +3.487 | +3.648 | 161
FASCIA BRACKET | C200-C200/BB250(TH75) | Z/2553 | 0.4 | +3.487 | +3.648 | 161
2 x FASCIA BRACKET | C200/BB200(TH75) | Z/2553 | 0.4 | +3.487 | +3.648 | 161
FASCIA BRACKET | C200-C200/BB200(TH75) | Z/2553 | 0.4 | +3.487 | +3.648 | 161
BRIDGING U-PLATE | C350-C350/BB350(TH96) | PL/2033 | 4.4 | +3.289 | +3.647 | 358
BRIDGING U-PLATE | C350-C350/BB350(TH75) | PL/2032 | 4.4 | +3.289 | +3.647 | 358
BRIDGING U-PLATE | C350-C350/BB350(TH120) | PL/2034 | 4.4 | +3.274 | +3.632 | 358
RAFTER | C350-C350/BB350(TH120)> | Z/2606 | 10.8 | +3.280 | +3.773 | 125
BB TRUSS BRACKET | C350-C350/BB350(TH120)> | PL/1995 | 5.4 | +3.278 | +3.700 | 147.699
BB TRUSS BRACKET | C350-C350/BB350(TH120)> | PL/1996 | 5.4 | +3.278 | +3.700 | 147.699
RAFTER | C350-C350/BB350(TH96)-BB350(TH120) | Z/2606 | 10.8 | +3.299 | +3.792 | 125
BB TRUSS BRACKET | C350-C350/BB350(TH96)-BB350(TH120) | PL/1995 | 5.4 | +3.297 | +3.719 | 147.699
BB TRUSS BRACKET | C350-C350/BB350(TH96)-BB350(TH120) | PL/1996 | 5.4 | +3.297 | +3.719 | 147.699
RAFTER | C300-C300/BB350(TH120)> | Z/2599 | 8.9 | +3.319 | +3.761 | 96
BB TRUSS BRACKET | C300-C300/BB350(TH120)> | PL/1990 | 4.3 | +3.305 | +3.690 | 527.132
BB TRUSS BRACKET | C300-C300/BB350(TH120)> | PL/1993 | 4.3 | +3.305 | +3.690 | 147.699
RAFTER | C300-C300/BB350(TH96)-BB350(TH120) | Z/2599 | 8.9 | +3.314 | +3.756 | 96
BB TRUSS BRACKET | C300-C300/BB350(TH96)-BB350(TH120) | PL/1990 | 4.3 | +3.300 | +3.685 | 527.132
BB TRUSS BRACKET | C300-C300/BB350(TH96)-BB350(TH120) | PL/1993 | 4.3 | +3.300 | +3.685 | 147.699
BB TRUSS BRACKET | C300-C300/BB350(TH75)-BB350(TH96) | PL/1990 | 4.3 | +3.295 | +3.681 | 527.132
RAFTER | C300-C300/BB300(TH120)-BB350(TH75) | Z/2599 | 8.9 | +3.319 | +3.761 | 96
BB TRUSS BRACKET | C300-C300/BB300(TH120)-BB350(TH75) | PL/1991 | 4.6 | +3.319 | +3.690 | 147.699
BB TRUSS BRACKET | C300-C300/BB300(TH120)-BB350(TH75) | PL/1994 | 4.6 | +3.319 | +3.690 | 147.699
RAFTER | C300-C300/BB300(TH96)-BB300(TH120) | Z/2599 | 8.9 | +3.339 | +3.781 | 96
BB TRUSS BRACKET | C300-C300/BB300(TH96)-BB300(TH120) | PL/1991 | 4.6 | +3.338 | +3.710 | 147.699
BB TRUSS BRACKET | C300-C300/BB300(TH96)-BB300(TH120) | PL/1994 | 4.6 | +3.338 | +3.710 | 147.699
BRIDGING U-PLATE | C250-C250/BB350(TH120) | PL/2024 | 4.4 | +3.289 | +3.647 | 129
BRIDGING U-PLATE | C250-C250/BB350(TH96) | PL/2023 | 4.4 | +3.289 | +3.647 | 129
BRIDGING U-PLATE | C250-C250/BB350(TH75) | PL/1986 | 4.4 | +3.289 | +3.647 | 129
BRIDGING U-PLATE | C250-C250/BB300(TH120) | PL/2022 | 3.6 | +3.339 | +3.647 | 100
BRIDGING U-PLATE | C250-C250/BB300(TH96) | PL/2021 | 3.6 | +3.339 | +3.647 | 100
BRIDGING U-PLATE | C250-C250/BB300(TH75) | PL/2020 | 3.6 | +3.339 | +3.647 | 100
BRIDGING U-PLATE | C250-C250/BB250(TH120) | PL/2019 | 3 | +3.350 | +3.612 | 80
BRIDGING U-PLATE | C250-C250/BB250(TH96) | PL/2018 | 3 | +3.365 | +3.627 | 80
BRIDGING U-PLATE | C250-C250/BB250(TH75) | PL/1985 | 3 | +3.385 | +3.647 | 80
RAFTER | C250-C250/BB300(TH120)-BB350(TH75) | Z/2591 | 5.9 | +3.354 | +3.754 | 76
BB TRUSS BRACKET | C250-C250/BB300(TH120) | PL/1983 | 3 | +3.341 | +3.654 | 147.999
BB TRUSS BRACKET | C250-C250/BB300(TH120) | PL/1988 | 3 | +3.341 | +3.654 | 147.999
RAFTER | C250-C250/BB300(TH96)-BB300(TH120) | Z/2591 | 5.9 | +3.373 | +3.773 | 76
BB TRUSS BRACKET | C250-C250/BB300(TH96) | PL/1983 | 3 | +3.360 | +3.673 | 147.999
BB TRUSS BRACKET | C250-C250/BB300(TH96) | PL/1988 | 3 | +3.360 | +3.673 | 147.999
RAFTER | C250-C250/BB350(TH120)> | Z/2591 | 5.9 | +3.354 | +3.754 | 76
BB TRUSS BRACKET | C250-C250/BB350(TH120) | PL/1989 | 2.6 | +3.353 | +3.654 | 358.65
BB TRUSS BRACKET | C250-C250/BB350(TH120) | PL/1984 | 2.6 | +3.353 | +3.654 | 358.65
RAFTER | C250-C250/BB350(TH96)-BB350(TH120) | Z/2591 | 5.9 | +3.373 | +3.773 | 76
BB TRUSS BRACKET | C250-C250/BB350(TH96) | PL/1989 | 2.6 | +3.373 | +3.673 | 358.65
BB TRUSS BRACKET | C250-C250/BB350(TH96) | PL/1984 | 2.6 | +3.373 | +3.673 | 358.65
RAFTER | C250-C250/BB250(TH120)-BB300(TH75) | Z/2591 | 5.9 | +3.354 | +3.754 | 76
BB TRUSS BRACKET | C250-C250/BB250(TH120) | PL/1987 | 3.1 | +3.353 | +3.654 | 456.661
BB TRUSS BRACKET | C250-C250/BB250(TH120) | PL/1982 | 3.1 | +3.353 | +3.654 | 147.999
RAFTER | C250-C250/BB250(TH96)-BB250(TH120) | Z/2591 | 5.9 | +3.373 | +3.773 | 76
BB TRUSS BRACKET | C250-C250/BB250(TH96) | PL/1987 | 3.1 | +3.372 | +3.673 | 456.661
BB TRUSS BRACKET | C250-C250/BB250(TH96) | PL/1982 | 3.1 | +3.372 | +3.673 | 147.999
BB TRUSS BRACKET | C250-C250/BB350(TH75) | PL/1989 | 2.6 | +3.390 | +3.690 | 358.65
BB TRUSS BRACKET | C250-C250/BB350(TH75) | PL/1984 | 2.6 | +3.390 | +3.690 | 358.65
BB TRUSS BRACKET | C250-C250/BB250(TH75) | PL/1987 | 3.1 | +3.389 | +3.690 | 456.661
BRIDGING U-PLATE | C200-C200/BB300(TH120) | PL/2013 | 3.6 | +3.339 | +3.647 | 308
BRIDGING U-PLATE | C200-C200/BB300(TH96) | PL/2012 | 3.6 | +3.339 | +3.647 | 308
BRIDGING U-PLATE | C200-C200/BB300(TH75) | PL/1978 | 3.6 | +3.339 | +3.647 | 308
BRIDGING U-PLATE | C200-C200/BB250(TH120) | PL/2010 | 3 | +3.375 | +3.637 | 262
BRIDGING U-PLATE | C200-C200/BB250(TH96) | PL/2009 | 3 | +3.385 | +3.647 | 262
BRIDGING U-PLATE | C200-C200/BB250(TH75) | PL/2008 | 3 | +3.385 | +3.647 | 262
BRIDGING U-PLATE | C200-C200/BB200(TH120) | PL/2004 | 2.6 | +3.386 | +3.597 | 211
BRIDGING U-PLATE | C200-C200/BB200(TH96) | PL/2035 | 2.6 | +3.406 | +3.617 | 211
RAFTER | C200-C200/BB300(TH120)-BB350(TH75) | R/93 | 3.9 | +3.393 | +3.706 | 76
BB TRUSS BRACKET | C200-C200/BB300(TH120) | PL/1977 | 1.8 | +3.393 | +3.626 | 147.999
BB TRUSS BRACKET | C200-C200/BB300(TH120) | PL/1981 | 1.8 | +3.393 | +3.626 | 147.999
RAFTER | C200-C200/BB300(TH96)-BB300(TH120) | R/93 | 3.9 | +3.412 | +3.725 | 76
BB TRUSS BRACKET | C200-C200/BB300(TH96) | PL/1977 | 1.8 | +3.412 | +3.645 | 147.999
BB TRUSS BRACKET | C200-C200/BB300(TH96) | PL/1981 | 1.8 | +3.412 | +3.645 | 147.999
RAFTER | C200-C200/BB300(TH75)-BB300(TH96) | R/93 | 3.9 | +3.429 | +3.742 | 76
BB TRUSS BRACKET | C200-C200/BB300(TH75) | PL/1977 | 1.8 | +3.429 | +3.662 | 147.999
BB TRUSS BRACKET | C200-C200/BB300(TH75) | PL/1981 | 1.8 | +3.429 | +3.662 | 147.999
RAFTER | C200-C200/BB250(TH120)-BB300(TH75) | R/93 | 3.9 | +3.393 | +3.706 | 76
BB TRUSS BRACKET | C200-C200/BB250(TH120) | PL/1976 | 1.9 | +3.384 | +3.626 | 147.999
BB TRUSS BRACKET | C200-C200/BB250(TH120) | PL/1980 | 1.9 | +3.384 | +3.626 | 147.999
RAFTER | C200-C200/BB250(TH96)-BB250(TH120) | R/93 | 3.9 | +3.412 | +3.725 | 76
BB TRUSS BRACKET | C200-C200/BB250(TH96) | PL/1976 | 1.9 | +3.404 | +3.645 | 147.999
BB TRUSS BRACKET | C200-C200/BB250(TH96) | PL/1980 | 1.9 | +3.404 | +3.645 | 147.999
RAFTER | C200-C200/BB250(TH75)-BB250(TH96) | R/93 | 3.9 | +3.429 | +3.742 | 76
BB TRUSS BRACKET | C200-C200/BB250(TH75) | PL/1976 | 1.9 | +3.421 | +3.662 | 147.999
BB TRUSS BRACKET | C200-C200/BB250(TH75) | PL/1980 | 1.9 | +3.421 | +3.662 | 147.999
RAFTER | C200-C200/BB200(TH120)-BB250(TH75) | R/93 | 3.9 | +3.393 | +3.706 | 76
BB TRUSS BRACKET | C200-C200/BB200(TH120) | PL/1975 | 1.8 | +3.394 | +3.626 | 147.999
BB TRUSS BRACKET | C200-C200/BB200(TH120) | PL/1979 | 1.8 | +3.394 | +3.626 | 147.999
RAFTER | C200-C200/BB200(TH96)-BB200(TH120) | R/93 | 3.9 | +3.412 | +3.725 | 76
BB TRUSS BRACKET | C200-C200/BB200(TH96) | PL/1975 | 1.8 | +3.413 | +3.645 | 147.999
BB TRUSS BRACKET | C200-C200/BB200(TH96) | PL/1979 | 1.8 | +3.413 | +3.645 | 147.999
BRIDGING U-PLATE | C150-C150/BB250(TH120) | PL/2001 | 3 | +3.385 | +3.647 | 262
RAFTER | C150-C150/BB250(TH120)-BB300(TH75) | Z/2555 | 2.6 | +3.432 | +3.677 | 64
BB TRUSS BRACKET | C150-C150/BB250(TH120) | PL/1974 | 1.2 | +3.436 | +3.616 | 147.999
BB TRUSS BRACKET | C150-C150/BB250(TH120) | PL/1641 | 1.2 | +3.436 | +3.616 | 147.999
BRIDGING U-PLATE | C150-C150/BB250(TH96) | PL/2000 | 3 | +3.361 | +3.623 | 262
RAFTER | C150-C150/BB250(TH96)-BB250(TH120) | Z/2555 | 2.6 | +3.427 | +3.672 | 64
BB TRUSS BRACKET | C150-C150/BB250(TH96) | PL/1974 | 1.2 | +3.431 | +3.611 | 147.999
BB TRUSS BRACKET | C150-C150/BB250(TH96) | PL/1641 | 1.2 | +3.431 | +3.611 | 147.999
BRIDGING U-PLATE | C150-C150/BB250(TH75) | PL/1973 | 3 | +3.339 | +3.601 | 262
RAFTER | C150-C150/BB250(TH75)-BB250(TH96) | Z/2555 | 2.6 | +3.422 | +3.668 | 64
BB TRUSS BRACKET | C150-C150/BB250(TH75) | PL/1974 | 1.2 | +3.426 | +3.606 | 147.999
BB TRUSS BRACKET | C150-C150/BB250(TH75) | PL/1641 | 1.2 | +3.426 | +3.606 | 147.999
BRIDGING U-PLATE | C150-C150/BB200(TH120) | PL/1999 | 2.6 | +3.380 | +3.591 | 211
RAFTER | C150-C150/BB200(TH120)-BB250(TH75) | Z/2555 | 2.6 | +3.386 | +3.631 | 64
BB TRUSS BRACKET | C150-C150/BB200(TH120) | PL/1974 | 1.2 | +3.390 | +3.570 | 147.999
BB TRUSS BRACKET | C150-C150/BB200(TH120) | PL/1641 | 1.2 | +3.390 | +3.570 | 147.999
BRIDGING U-PLATE | C150-C150/BB200(TH96) | PL/1997 | 2.6 | +3.390 | +3.601 | 211
RAFTER | C150-C150/BB200(TH96)-BB200(TH120) | Z/2555 | 2.6 | +3.405 | +3.651 | 64
BB TRUSS BRACKET | C150-C150/BB200(TH96) | PL/1974 | 1.2 | +3.409 | +3.589 | 147.999
BB TRUSS BRACKET | C150-C150/BB200(TH96) | PL/1641 | 1.2 | +3.409 | +3.589 | 147.999
BB TRUSS BRACKET | C150-C150/BB200(TH75) | PL/1974 | 1.2 | +3.426 | +3.606 | 147.999
BB TRUSS BRACKET | C150-C150/BB200(TH75) | PL/1641 | 1.2 | +3.426 | +3.606 | 147.999
TH | C350-C350/BB350(TH120) | B/59 | 3 | +2.946 | +3.111 | 165
TH | C350-C350/BB350(TH96) | B/44 | 3 | +2.953 | +3.103 | 150
TH | C350-C350/BB350(TH75) | B/28 | 3 | +2.966 | +3.091 | 125
2 x RAFTER | C350/BB350(TH75)-BB350(TH96) | Z/431 | 10.8 | +3.316 | +3.809 | 125
2 x RAFTER | C350/BB350(TH96)-BB350(TH120) | Z/431 | 10.8 | +3.299 | +3.792 | 125
2 x RAFTER | C350/BB350(TH120)> | Z/431 | 10.8 | +3.280 | +3.773 | 125
RAFTER | C350-C350/BB350(TH75)-BB350(TH96) | Z/2606 | 10.8 | +3.316 | +3.809 | 125
2 x FASCIA BRACKET | C350/BB350(TH120) | Z/2531 | 0.4 | +3.488 | +3.645 | 157.2
FASCIA BRACKET | C350-C350/BB350(TH120) | Z/2531 | 0.4 | +3.488 | +3.645 | 157.2
FASCIA STIFFENER | C350-C350/BB350(TH120) | PL/116 | 1 | +3.291 | +3.641 | 3
COLUMN | C350/BB350(TH120) | Z/2602 | 54.5 | +0.000 | +3.643 | 125
2 x FASCIA BRACKET | C350/BB350(TH96) | Z/2520 | 0.4 | +3.488 | +3.645 | 157.2
FASCIA BRACKET | C350-C350/BB350(TH96) | Z/2520 | 0.4 | +3.488 | +3.645 | 157.2
