Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView_V2.0, QuantityTakeOffAddOnView], Option [BaseQuantities:On], Option [GridExport:On], Option [Assemblies:On], Option [Bolts:On], Option [Rebars:On], Option [PourObjects:Off], Option [Welds:Off], Option [SurfaceTreatments:Off], Option [LocationBy:0], Option [ViewColors:Off], Option [SectionedSpine:Off], Option [PropertySets:On], Option [Export all:Off]
File name: Fascia Bracket-2C-Section.ifc
Time: 2026-09-14T12:22:41
Author: MSI\User
Organization: Structural Designer
Written by: IFC Database Version: Work
Made in: Tekla Structures 2019 Service Pack 13, IFC Export Version: 4.0.0.0 Oct 18 2021

# IfcBuildingStorey, Undefined
In: Undefined
Elevation: 0 mm

# IfcBeam: C:100-15 (8)
In: Undefined
Description: C:100-15; Material: STEEL/300PLUS
Default - ASSEMBLY_POS: F/77
Tekla Common - Phase: 1; Class: 13
Tekla Quantity - Weight: 4.5 kg; Volume: 0 m3; Gross footprint area: 0.1 m2; Area per tons: 178.8 m2; Net surface area: 0.8 m2; Height: 102 mm; Width: 51 mm; Length: 1793.5 mm
Pset_BeamCommon - LoadBearing: no; Reference: F/77
BaseQuantities - Length: 1793.5 mm; OuterSurfaceArea: 0.81313 m2; NetVolume: 0.000605306 m3; NetWeight: 4.75165 kg
Name | Bottom elevation | Top elevation
3 x FASCIA | +3.129 | +3.231
5 x FASCIA | +3.109 | +3.211

# IfcBeam: C:150-15 (8)
In: Undefined
Description: C:150-15; Material: STEEL/300PLUS
Default - ASSEMBLY_POS: F/76
Tekla Common - Phase: 1; Class: 13
Tekla Quantity - Weight: 6.2 kg; Volume: 0 m3; Gross footprint area: 0.1 m2; Area per tons: 176.4 m2; Net surface area: 1.1 m2; Height: 152 mm; Width: 64 mm; Length: 1793.5 mm
Pset_BeamCommon - LoadBearing: no; Reference: F/76
BaseQuantities - Length: 1793.5 mm; OuterSurfaceArea: 1.10033 m2; NetVolume: 0.000820526 m3; NetWeight: 6.44113 kg
Name | Bottom elevation | Top elevation
3 x FASCIA | +2.719 | +2.871
5 x FASCIA | +2.899 | +3.051

# IfcBeam: C:150-24 (8)
In: Undefined
Description: C:150-24; Material: STEEL/G450
Default - ASSEMBLY_POS: Z/8
Tekla Common - Finish: 25 deg; Bottom elevation: +0.000; Top elevation: +3.400; Phase: 1; Class: 10
Tekla Quantity - Weight: 18.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 111.2 m2; Net surface area: 2.1 m2; Height: 152 mm; Width: 64 mm; Length: 3400 mm
Pset_BeamCommon - LoadBearing: no; Reference: Z/8
BaseQuantities - Length: 3400 mm; OuterSurfaceArea: 2.10812 m2; NetVolume: 0.00250838 m3; NetWeight: 19.6908 kg

# IfcBeam: C:200-15 (5)
In: Undefined
Description: C:200-15; Material: STEEL/300PLUS
Default - ASSEMBLY_POS: F/78
Tekla Common - Phase: 1; Class: 13
Tekla Quantity - Weight: 7.8 kg; Volume: 0 m3; Gross footprint area: 0.1 m2; Area per tons: 175.3 m2; Net surface area: 1.4 m2; Height: 203 mm; Width: 76 mm; Length: 1793.5 mm
Pset_BeamCommon - LoadBearing: no; Reference: F/78
BaseQuantities - Length: 1793.5 mm; OuterSurfaceArea: 1.36958 m2; NetVolume: 0.0010223 m3; NetWeight: 8.02502 kg
Name | Bottom elevation | Top elevation
3 x FASCIA | +2.228 | +2.431
2 x FASCIA | +2.638 | +2.841

# IfcBeam: C:200-24 (8)
In: Undefined
Description: C:200-24; Material: STEEL/G450
Tekla Common - Finish: 25 deg; Bottom elevation: +0.000; Top elevation: +3.400; Phase: 1; Class: 10
Default - ASSEMBLY_POS: Z/17
Tekla Quantity - Weight: 24.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 110.1 m2; Net surface area: 2.7 m2; Height: 203 mm; Width: 76 mm; Length: 3400 mm
Pset_BeamCommon - LoadBearing: no; Reference: Z/17
BaseQuantities - Length: 3400 mm; OuterSurfaceArea: 2.6525 m2; NetVolume: 0.00316118 m3; NetWeight: 24.8153 kg

# IfcBeam: C:250-24 (8)
In: Undefined
Description: C:250-24; Material: STEEL/G450
Tekla Common - Finish: 25 deg; Bottom elevation: +0.000; Top elevation: +3.400; Phase: 1; Class: 10
Default - ASSEMBLY_POS: Z/26
Tekla Quantity - Weight: 27.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 109.7 m2; Net surface area: 3 m2; Height: 254 mm; Width: 76 mm; Length: 3400 mm
Pset_BeamCommon - LoadBearing: no; Reference: Z/26
BaseQuantities - Length: 3400 mm; OuterSurfaceArea: 2.99274 m2; NetVolume: 0.00356918 m3; NetWeight: 28.0181 kg

# IfcBeam: C:300-24 (8)
In: Undefined
Description: C:300-24; Material: STEEL/G450
Tekla Common - Finish: 25 deg; Bottom elevation: +0.000; Top elevation: +3.400; Phase: 1; Class: 10
Default - ASSEMBLY_POS: Z/2609
Tekla Quantity - Weight: 33.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 108.5 m2; Net surface area: 3.7 m2; Height: 300 mm; Width: 96 mm; Length: 3400 mm
Pset_BeamCommon - LoadBearing: no; Reference: Z/2609
BaseQuantities - Length: 3400 mm; OuterSurfaceArea: 3.67322 m2; NetVolume: 0.00438518 m3; NetWeight: 34.4237 kg

# IfcBeam: C:350-30 (8)
In: Undefined
Description: C:350-30; Material: STEEL/G450
Tekla Common - Finish: 25 deg; Bottom elevation: +0.000; Top elevation: +3.400; Phase: 1; Class: 10
Default - ASSEMBLY_POS: Z/42
Tekla Quantity - Weight: 50.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.1 m2; Net surface area: 4.4 m2; Height: 350 mm; Width: 125 mm; Length: 3400 mm
Pset_BeamCommon - LoadBearing: no; Reference: Z/42
BaseQuantities - Length: 3400 mm; OuterSurfaceArea: 4.43069 m2; NetVolume: 0.0066096 m3; NetWeight: 51.8854 kg

# IfcBeam: PLT3*130 (105)
In: Undefined
Description: PLT3*130; Material: STEEL/250
Tekla Common - Phase: 1; Class: 12
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 130 mm; Width: 3 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
5 x FASCIA BRACKET | FB/41 | +3.124 | +3.235 | 1.5 | 87.5 | 0.1 | 498.8 | 498.85 | 0.134651 | 0.000195975 | 1.5384
5 x FASCIA BRACKET | FB/42 | +2.714 | +2.875 | 1.7 | 87.5 | 0.1 | 535.8 | 535.85 | 0.144493 | 0.000210405 | 1.65168
5 x FASCIA BRACKET | FB/43 | +2.223 | +2.435 | 1.7 | 87.5 | 0.2 | 574.8 | 574.85 | 0.154867 | 0.000225615 | 1.77108
5 x FASCIA BRACKET | FB/38 | +3.124 | +3.235 | 1.2 | 87.7 | 0.1 | 396.8 | 396.85 | 0.107519 | 0.000156195 | 1.22613
5 x FASCIA BRACKET | FB/39 | +2.714 | +2.875 | 1.2 | 87.7 | 0.1 | 433.8 | 433.85 | 0.117361 | 0.000170625 | 1.33941
5 x FASCIA BRACKET | FB/40 | +2.223 | +2.435 | 1.5 | 87.7 | 0.1 | 472.8 | 472.85 | 0.127735 | 0.000185835 | 1.4588
5 x FASCIA BRACKET | FB/35 | +3.124 | +3.235 | 0.9 | 88 | 0.1 | 296.8 | 296.85 | 0.0809194 | 0.000117195 | 0.919981
5 x FASCIA BRACKET | FB/36 | +2.714 | +2.875 | 0.9 | 87.8 | 0.1 | 333.8 | 333.85 | 0.0907614 | 0.000131625 | 1.03326
5 x FASCIA BRACKET | FB/37 | +2.223 | +2.435 | 1.2 | 87.7 | 0.1 | 372.8 | 372.85 | 0.101135 | 0.000146835 | 1.15265
5 x FASCIA BRACKET | FB/32 | +2.634 | +2.845 | 1.2 | 87.7 | 0.1 | 434.3 | 434.279 | 0.117481 | 0.00017082 | 1.34094
5 x FASCIA BRACKET | FB/33 | +2.894 | +3.055 | 1.2 | 87.7 | 0.1 | 384.3 | 384.279 | 0.104181 | 0.00015132 | 1.18786
5 x FASCIA BRACKET | FB/34 | +3.104 | +3.215 | 0.9 | 87.8 | 0.1 | 334.3 | 334.279 | 0.0908806 | 0.00013182 | 1.03479
5 x FASCIA BRACKET | FB/29 | +2.634 | +2.845 | 1.2 | 87.7 | 0.1 | 386.3 | 386.279 | 0.104713 | 0.0001521 | 1.19398
5 x FASCIA BRACKET | FB/30 | +2.894 | +3.055 | 0.9 | 87.8 | 0.1 | 336.3 | 336.279 | 0.0914126 | 0.0001326 | 1.04091
5 x FASCIA BRACKET | FB/31 | +3.104 | +3.215 | 0.9 | 88 | 0.1 | 286.3 | 286.279 | 0.0781126 | 0.0001131 | 0.887835
5 x FASCIA BRACKET | FB/27 | +2.894 | +3.055 | 0.9 | 88 | 0.1 | 294.3 | 294.279 | 0.0802406 | 0.00011622 | 0.912327
4 x FASCIA BRACKET | FB/28 | +3.104 | +3.215 | 0.9 | 88.2 | 0.1 | 244.3 | 244.279 | 0.0669406 | 0.00009672 | 0.759252
FASCIA BRACKET | FB/25 | +2.894 | +3.055 | 0.9 | 88 | 0.1 | 272.5 | 272.479 | 0.0744418 | 0.000107718 | 0.845586
5 x FASCIA BRACKET | FB/26 | +3.104 | +3.215 | 0.7 | 88.3 | 0.1 | 222.3 | 222.279 | 0.0610886 | 0.00008814 | 0.691899
4 x FASCIA BRACKET | FB/25 | +2.894 | +3.055 | 0.7 | 88 | 0.1 | 272.5 | 272.479 | 0.0744418 | 0.000107718 | 0.845586
5 x FASCIA BRACKET | FB/23 | +2.894 | +3.055 | 0.7 | 88.2 | 0.1 | 266.3 | 266.279 | 0.0727926 | 0.0001053 | 0.826605
5 x FASCIA BRACKET | FB/24 | +3.104 | +3.215 | 0.7 | 88.3 | 0.1 | 216.3 | 216.279 | 0.0594926 | 0.0000858 | 0.67353
FASCIA BRACKET | FB/28 | +3.104 | +3.215 | 0.7 | 88.2 | 0.1 | 244.3 | 244.279 | 0.0669406 | 0.00009672 | 0.759252

# IfcBeam: TH:120-95, TH
In: Undefined
Description: TH:120-95; Material: STEEL/300PLUS
Default - ASSEMBLY_POS: B/111
Tekla Common - Bottom elevation: +2.402; Top elevation: +2.567; Phase: 1; Class: 4
Tekla Quantity - Weight: 3.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 0 m2; Net surface area: 1.3 m2; Height: 120 mm; Width: 165 mm; Length: 1793.5 mm
Pset_BeamCommon - LoadBearing: no; Reference: B/111
BaseQuantities - Length: 1793.5 mm; OuterSurfaceArea: 8.17872e-07 m2; NetVolume: 0.000629884 m3; NetWeight: 4.94459 kg

# IfcBeam: TH:61-95, TH
In: Undefined
Description: TH:61-95; Material: STEEL/300PLUS
Default - ASSEMBLY_POS: B/107
Tekla Common - Bottom elevation: +2.720; Top elevation: +2.850; Phase: 1; Class: 4
Tekla Quantity - Weight: 3.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 0 m2; Net surface area: 0.8 m2; Height: 61 mm; Width: 130 mm; Length: 1793.5 mm
Pset_BeamCommon - LoadBearing: no; Reference: B/107
BaseQuantities - Length: 1793.5 mm; OuterSurfaceArea: 8.17872e-07 m2; NetVolume: 0.000376635 m3; NetWeight: 2.95658 kg

# IfcBeam: TH:64-95, TH
In: Undefined
Description: TH:64-95; Material: STEEL/300PLUS
Tekla Common - Bottom elevation: +2.720; Top elevation: +2.850; Phase: 1; Class: 4
Default - ASSEMBLY_POS: B/108
Tekla Quantity - Weight: 3.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 0 m2; Net surface area: 0.8 m2; Height: 64 mm; Width: 130 mm; Length: 1793.5 mm
Pset_BeamCommon - LoadBearing: no; Reference: B/108
BaseQuantities - Length: 1793.5 mm; OuterSurfaceArea: 8.17872e-07 m2; NetVolume: 0.000386603 m3; NetWeight: 3.03484 kg

# IfcBeam: TH:75-95, TH
In: Undefined
Description: TH:75-95; Material: STEEL/300PLUS
Default - ASSEMBLY_POS: B/109
Tekla Common - Bottom elevation: +2.422; Top elevation: +2.547; Phase: 1; Class: 4
Tekla Quantity - Weight: 3.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 0 m2; Net surface area: 0.8 m2; Height: 75 mm; Width: 125 mm; Length: 1793.5 mm
Pset_BeamCommon - LoadBearing: no; Reference: B/109
BaseQuantities - Length: 1793.5 mm; OuterSurfaceArea: 8.17872e-07 m2; NetVolume: 0.000415914 m3; NetWeight: 3.26492 kg

# IfcBeam: TH:96-95, TH
In: Undefined
Description: TH:96-95; Material: STEEL/300PLUS
Default - ASSEMBLY_POS: B/110
Tekla Common - Bottom elevation: +2.410; Top elevation: +2.560; Phase: 1; Class: 4
Tekla Quantity - Weight: 3.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 0 m2; Net surface area: 1 m2; Height: 96 mm; Width: 150 mm; Length: 1793.5 mm
Pset_BeamCommon - LoadBearing: no; Reference: B/110
BaseQuantities - Length: 1793.5 mm; OuterSurfaceArea: 8.17872e-07 m2; NetVolume: 0.000515044 m3; NetWeight: 4.04309 kg

# IfcBeam: Z:100-15, TH
In: Undefined
Description: Z:100-15; Material: STEEL/300PLUS
Default - ASSEMBLY_POS: B/112
Tekla Common - Bottom elevation: +2.007; Top elevation: +2.107; Phase: 1; Class: 4
Tekla Quantity - Weight: 4.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 179.1 m2; Net surface area: 0.8 m2; Height: 102 mm; Width: 100.5 mm; Length: 1793.5 mm
Pset_BeamCommon - LoadBearing: no; Reference: B/112
BaseQuantities - Length: 1793.5 mm; OuterSurfaceArea: 0.81313 m2; NetVolume: 0.000605306 m3; NetWeight: 4.75165 kg

# IfcBeam: Z:150-15, TH
In: Undefined
Description: Z:150-15; Material: STEEL/300PLUS
Default - ASSEMBLY_POS: B/113
Tekla Common - Bottom elevation: +1.995; Top elevation: +2.119; Phase: 1; Class: 4
Tekla Quantity - Weight: 6.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 176.6 m2; Net surface area: 1.1 m2; Height: 152 mm; Width: 124.5 mm; Length: 1793.5 mm
Pset_BeamCommon - LoadBearing: no; Reference: B/113
BaseQuantities - Length: 1793.5 mm; OuterSurfaceArea: 1.10033 m2; NetVolume: 0.000820526 m3; NetWeight: 6.44113 kg

# IfcBeam: Z:200-15, TH
In: Undefined
Description: Z:200-15; Material: STEEL/300PLUS
BaseQuantities - Length: 1793.5 mm; OuterSurfaceArea: 1.36958 m2; NetVolume: 0.0010223 m3; NetWeight: 8.02502 kg
Default - ASSEMBLY_POS: B/114
Tekla Common - Bottom elevation: +1.982; Top elevation: +2.133; Phase: 1; Class: 4
Tekla Quantity - Weight: 7.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 175.3 m2; Net surface area: 1.4 m2; Height: 203 mm; Width: 151.5 mm; Length: 1793.5 mm
Pset_BeamCommon - LoadBearing: no; Reference: B/114

# IfcColumn: C:150-24 (8)
In: Undefined
Description: C:150-24; Material: STEEL/G450
Default - ASSEMBLY_POS: Z/8
Tekla Common - Finish: 25 deg; Bottom elevation: +0.000; Top elevation: +3.400; Phase: 1; Class: 10
Tekla Quantity - Weight: 18.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 111.2 m2; Net surface area: 2.1 m2; Height: 152 mm; Width: 64 mm; Length: 3400 mm
Pset_ColumnCommon - LoadBearing: no; Reference: Z/8
BaseQuantities - Length: 3400 mm; OuterSurfaceArea: 2.10812 m2; NetVolume: 0.00250838 m3; NetWeight: 19.6908 kg

# IfcColumn: C:200-24 (8)
In: Undefined
Description: C:200-24; Material: STEEL/G450
Tekla Common - Finish: 25 deg; Bottom elevation: +0.000; Top elevation: +3.400; Phase: 1; Class: 10
Default - ASSEMBLY_POS: Z/17
Tekla Quantity - Weight: 24.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 110.1 m2; Net surface area: 2.7 m2; Height: 203 mm; Width: 76 mm; Length: 3400 mm
Pset_ColumnCommon - LoadBearing: no; Reference: Z/17
BaseQuantities - Length: 3400 mm; OuterSurfaceArea: 2.6525 m2; NetVolume: 0.00316118 m3; NetWeight: 24.8153 kg

# IfcColumn: C:250-24 (8)
In: Undefined
Description: C:250-24; Material: STEEL/G450
Tekla Common - Finish: 25 deg; Bottom elevation: +0.000; Top elevation: +3.400; Phase: 1; Class: 10
Default - ASSEMBLY_POS: Z/26
Tekla Quantity - Weight: 27.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 109.7 m2; Net surface area: 3 m2; Height: 254 mm; Width: 76 mm; Length: 3400 mm
Pset_ColumnCommon - LoadBearing: no; Reference: Z/26
BaseQuantities - Length: 3400 mm; OuterSurfaceArea: 2.99274 m2; NetVolume: 0.00356918 m3; NetWeight: 28.0181 kg

# IfcColumn: C:300-24 (8)
In: Undefined
Description: C:300-24; Material: STEEL/G450
Tekla Common - Finish: 25 deg; Bottom elevation: +0.000; Top elevation: +3.400; Phase: 1; Class: 10
Default - ASSEMBLY_POS: Z/2609
Tekla Quantity - Weight: 33.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 108.5 m2; Net surface area: 3.7 m2; Height: 300 mm; Width: 96 mm; Length: 3400 mm
Pset_ColumnCommon - LoadBearing: no; Reference: Z/2609
BaseQuantities - Length: 3400 mm; OuterSurfaceArea: 3.67322 m2; NetVolume: 0.00438518 m3; NetWeight: 34.4237 kg

# IfcColumn: C:350-30 (8)
In: Undefined
Description: C:350-30; Material: STEEL/G450
Tekla Common - Finish: 25 deg; Bottom elevation: +0.000; Top elevation: +3.400; Phase: 1; Class: 10
Default - ASSEMBLY_POS: Z/42
Tekla Quantity - Weight: 50.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.1 m2; Net surface area: 4.4 m2; Height: 350 mm; Width: 125 mm; Length: 3400 mm
Pset_ColumnCommon - LoadBearing: no; Reference: Z/42
BaseQuantities - Length: 3400 mm; OuterSurfaceArea: 4.43069 m2; NetVolume: 0.0066096 m3; NetWeight: 51.8854 kg

# IfcElementAssembly (214)
In: Undefined
PredefinedType: RIGID_FRAME
Name | ASSEMBLY_POSITION_CODE = Assembly/Cast unit position code | ASSEMBLY_POS = Assembly/Cast unit Mark | Assembly/Cast unit weight (kg) | Assembly/Cast unit bottom elevation | Assembly/Cast unit top elevation | Width (mm)
2 x FASCIA BRACKET | C250TB/3 | FB/41 | 1.5 | +3.124 | +3.235 | 111
2 x FASCIA BRACKET | C250TB/3 | FB/42 | 1.7 | +2.714 | +2.875 | 161
2 x FASCIA BRACKET | C250TB/3 | FB/43 | 1.7 | +2.223 | +2.435 | 212
FASCIA BRACKET | C200TB-C250TB/3 | FB/41 | 1.5 | +3.124 | +3.235 | 111
FASCIA BRACKET | C200TB-C250TB/3 | FB/42 | 1.7 | +2.714 | +2.875 | 161
FASCIA BRACKET | C200TB-C250TB/3 | FB/43 | 1.7 | +2.223 | +2.435 | 212
2 x FASCIA BRACKET | C200TB/3 | FB/41 | 1.5 | +3.124 | +3.235 | 111
2 x FASCIA BRACKET | C200TB/3 | FB/42 | 1.7 | +2.714 | +2.875 | 161
2 x FASCIA BRACKET | C200TB/3 | FB/43 | 1.7 | +2.223 | +2.435 | 212
2 x FASCIA BRACKET | C250TB/2 | FB/38 | 1.2 | +3.124 | +3.235 | 111
2 x FASCIA BRACKET | C250TB/2 | FB/39 | 1.2 | +2.714 | +2.875 | 161
2 x FASCIA BRACKET | C250TB/2 | FB/40 | 1.5 | +2.223 | +2.435 | 212
FASCIA BRACKET | C200TB-C250TB/2 | FB/38 | 1.2 | +3.124 | +3.235 | 111
FASCIA BRACKET | C200TB-C250TB/2 | FB/39 | 1.2 | +2.714 | +2.875 | 161
FASCIA BRACKET | C200TB-C250TB/2 | FB/40 | 1.5 | +2.223 | +2.435 | 212
2 x FASCIA BRACKET | C200TB/2 | FB/38 | 1.2 | +3.124 | +3.235 | 111
2 x FASCIA BRACKET | C200TB/2 | FB/39 | 1.2 | +2.714 | +2.875 | 161
2 x FASCIA BRACKET | C200TB/2 | FB/40 | 1.5 | +2.223 | +2.435 | 212
4 x COLUMN | C200TB/3 | Z/8 | 18.9 | +0.000 | +3.400 | 64
4 x COLUMN | C200TB/2 | Z/8 | 18.9 | +0.000 | +3.400 | 64
2 x FASCIA BRACKET | C250TB/1 | FB/35 | 0.9 | +3.124 | +3.235 | 111
2 x FASCIA BRACKET | C250TB/1 | FB/36 | 0.9 | +2.714 | +2.875 | 161
2 x FASCIA BRACKET | C250TB/1 | FB/37 | 1.2 | +2.223 | +2.435 | 212
FASCIA BRACKET | C200TB-C250TB/1 | FB/35 | 0.9 | +3.124 | +3.235 | 111
FASCIA BRACKET | C200TB-C250TB/1 | FB/36 | 0.9 | +2.714 | +2.875 | 161
FASCIA BRACKET | C200TB-C250TB/1 | FB/37 | 1.2 | +2.223 | +2.435 | 212
2 x FASCIA BRACKET | C200TB/1 | FB/35 | 0.9 | +3.124 | +3.235 | 111
2 x FASCIA BRACKET | C200TB/1 | FB/36 | 0.9 | +2.714 | +2.875 | 161
2 x FASCIA BRACKET | C200TB/1 | FB/37 | 1.2 | +2.223 | +2.435 | 212
4 x COLUMN | C250TB/3 | Z/2609 | 33.8 | +0.000 | +3.400 | 96
4 x COLUMN | C200TB/3 | Z/17 | 24.1 | +0.000 | +3.400 | 76
4 x COLUMN | C200TB-C250TB/3 | Z/26 | 27.3 | +0.000 | +3.400 | 76
4 x COLUMN | C250TB/3 | Z/42 | 50.8 | +0.000 | +3.400 | 125
4 x COLUMN | C250TB/2 | Z/2609 | 33.8 | +0.000 | +3.400 | 96
4 x COLUMN | C200TB/2 | Z/17 | 24.1 | +0.000 | +3.400 | 76
4 x COLUMN | C200TB-C250TB/2 | Z/26 | 27.3 | +0.000 | +3.400 | 76
4 x COLUMN | C250TB/2 | Z/42 | 50.8 | +0.000 | +3.400 | 125
4 x COLUMN | C250TB/1 | Z/2609 | 33.8 | +0.000 | +3.400 | 96
4 x COLUMN | C200TB/1 | Z/17 | 24.1 | +0.000 | +3.400 | 76
4 x COLUMN | C200TB-C250TB/1 | Z/26 | 27.3 | +0.000 | +3.400 | 76
4 x COLUMN | C250TB/1 | Z/42 | 50.8 | +0.000 | +3.400 | 125
4 x COLUMN | C200TB/1 | Z/8 | 18.9 | +0.000 | +3.400 | 64
FASCIA | C200TB-C250TB/1 | F/77 | 4.5 | +3.129 | +3.231 | 51
FASCIA | C200TB-C250TB/1 | F/76 | 6.2 | +2.719 | +2.871 | 64
FASCIA | C200TB-C250TB/1 | F/78 | 7.8 | +2.228 | +2.431 | 76
TH | C200TB-C250TB/1 | B/112 | 4.5 | +2.007 | +2.107 | 100.5
FASCIA | C200TB-C250TB/3 | F/77 | 4.5 | +3.129 | +3.231 | 51
FASCIA | C200TB-C250TB/3 | F/76 | 6.2 | +2.719 | +2.871 | 64
FASCIA | C200TB-C250TB/3 | F/78 | 7.8 | +2.228 | +2.431 | 76
TH | C200TB-C250TB/3 | B/114 | 7.8 | +1.982 | +2.133 | 151.5
FASCIA | C200TB-C250TB/2 | F/77 | 4.5 | +3.129 | +3.231 | 51
FASCIA | C200TB-C250TB/2 | F/76 | 6.2 | +2.719 | +2.871 | 64
FASCIA | C200TB-C250TB/2 | F/78 | 7.8 | +2.228 | +2.431 | 76
TH | C200TB-C250TB/2 | B/113 | 6.2 | +1.995 | +2.119 | 124.5
2 x FASCIA BRACKET | C250TB/5 | FB/32 | 1.2 | +2.634 | +2.845 | 211
2 x FASCIA BRACKET | C250TB/5 | FB/33 | 1.2 | +2.894 | +3.055 | 161
2 x FASCIA BRACKET | C250TB/5 | FB/34 | 0.9 | +3.104 | +3.215 | 111
FASCIA BRACKET | C200TB-C250TB/5 | FB/32 | 1.2 | +2.634 | +2.845 | 211
FASCIA BRACKET | C200TB-C250TB/5 | FB/33 | 1.2 | +2.894 | +3.055 | 161
FASCIA BRACKET | C200TB-C250TB/5 | FB/34 | 0.9 | +3.104 | +3.215 | 111
2 x FASCIA BRACKET | C200TB/5 | FB/32 | 1.2 | +2.634 | +2.845 | 211
2 x FASCIA BRACKET | C200TB/5 | FB/33 | 1.2 | +2.894 | +3.055 | 161
2 x FASCIA BRACKET | C200TB/5 | FB/34 | 0.9 | +3.104 | +3.215 | 111
2 x FASCIA BRACKET | C250TB/4 | FB/29 | 1.2 | +2.634 | +2.845 | 211
2 x FASCIA BRACKET | C250TB/4 | FB/30 | 0.9 | +2.894 | +3.055 | 161
2 x FASCIA BRACKET | C250TB/4 | FB/31 | 0.9 | +3.104 | +3.215 | 111
FASCIA BRACKET | C200TB-C250TB/4 | FB/29 | 1.2 | +2.634 | +2.845 | 211
FASCIA BRACKET | C200TB-C250TB/4 | FB/30 | 0.9 | +2.894 | +3.055 | 161
FASCIA BRACKET | C200TB-C250TB/4 | FB/31 | 0.9 | +3.104 | +3.215 | 111
2 x FASCIA BRACKET | C200TB/4 | FB/29 | 1.2 | +2.634 | +2.845 | 211
2 x FASCIA BRACKET | C200TB/4 | FB/30 | 0.9 | +2.894 | +3.055 | 161
2 x FASCIA BRACKET | C200TB/4 | FB/31 | 0.9 | +3.104 | +3.215 | 111
2 x FASCIA BRACKET | C250TB/3 | FB/27 | 0.9 | +2.894 | +3.055 | 161
2 x FASCIA BRACKET | C250TB/3 | FB/28 | 0.9 | +3.104 | +3.215 | 111
FASCIA BRACKET | C200TB-C250TB/3 | FB/27 | 0.9 | +2.894 | +3.055 | 161
FASCIA BRACKET | C200TB-C250TB/3 | FB/28 | 0.9 | +3.104 | +3.215 | 111
2 x FASCIA BRACKET | C200TB/3 | FB/27 | 0.9 | +2.894 | +3.055 | 161
FASCIA BRACKET | C200TB/3 | FB/28 | 0.9 | +3.104 | +3.215 | 111
FASCIA BRACKET | C250TB/2 | FB/25 | 0.9 | +2.894 | +3.055 | 161
2 x FASCIA BRACKET | C250TB/2 | FB/26 | 0.7 | +3.104 | +3.215 | 111
FASCIA BRACKET | C250TB/2 | FB/25 | 0.7 | +2.894 | +3.055 | 161
FASCIA BRACKET | C200TB-C250TB/2 | FB/25 | 0.7 | +2.894 | +3.055 | 161
FASCIA BRACKET | C200TB-C250TB/2 | FB/26 | 0.7 | +3.104 | +3.215 | 111
2 x FASCIA BRACKET | C200TB/2 | FB/25 | 0.7 | +2.894 | +3.055 | 161
2 x FASCIA BRACKET | C200TB/2 | FB/26 | 0.7 | +3.104 | +3.215 | 111
2 x COLUMN | C250TB/5 | Z/2609 | 33.8 | +0.000 | +3.400 | 96
2 x COLUMN | C200TB/5 | Z/17 | 24.1 | +0.000 | +3.400 | 76
2 x COLUMN | C250TB/5 | Z/42 | 50.8 | +0.000 | +3.400 | 125
2 x COLUMN | C200TB-C250TB/5 | Z/26 | 27.3 | +0.000 | +3.400 | 76
2 x COLUMN | C250TB/4 | Z/2609 | 33.8 | +0.000 | +3.400 | 96
2 x COLUMN | C200TB/4 | Z/17 | 24.1 | +0.000 | +3.400 | 76
2 x COLUMN | C250TB/4 | Z/42 | 50.8 | +0.000 | +3.400 | 125
2 x COLUMN | C200TB-C250TB/4 | Z/26 | 27.3 | +0.000 | +3.400 | 76
2 x FASCIA BRACKET | C250TB/1 | FB/23 | 0.7 | +2.894 | +3.055 | 161
2 x FASCIA BRACKET | C250TB/1 | FB/24 | 0.7 | +3.104 | +3.215 | 111
2 x FASCIA BRACKET | C200TB/1 | FB/23 | 0.7 | +2.894 | +3.055 | 161
2 x FASCIA BRACKET | C200TB/1 | FB/24 | 0.7 | +3.104 | +3.215 | 111
FASCIA BRACKET | C200TB-C250TB/1 | FB/23 | 0.7 | +2.894 | +3.055 | 161
FASCIA BRACKET | C200TB-C250TB/1 | FB/24 | 0.7 | +3.104 | +3.215 | 111
2 x COLUMN | C200TB/5 | Z/8 | 18.9 | +0.000 | +3.400 | 64
2 x COLUMN | C200TB/4 | Z/8 | 18.9 | +0.000 | +3.400 | 64
FASCIA BRACKET | C200TB/3 | FB/28 | 0.7 | +3.104 | +3.215 | 111
FASCIA | C200TB-C250TB/1 | F/76 | 6.2 | +2.899 | +3.051 | 64
FASCIA | C200TB-C250TB/1 | F/77 | 4.5 | +3.109 | +3.211 | 51
TH | C200TB-C250TB/1 | B/107 | 3.2 | +2.720 | +2.850 | 130
FASCIA | C200TB-C250TB/2 | F/76 | 6.2 | +2.899 | +3.051 | 64
FASCIA | C200TB-C250TB/5 | F/78 | 7.8 | +2.638 | +2.841 | 76
FASCIA | C200TB-C250TB/5 | F/76 | 6.2 | +2.899 | +3.051 | 64
FASCIA | C200TB-C250TB/5 | F/77 | 4.5 | +3.109 | +3.211 | 51
TH | C200TB-C250TB/5 | B/111 | 3.2 | +2.402 | +2.567 | 165
FASCIA | C200TB-C250TB/4 | F/78 | 7.8 | +2.638 | +2.841 | 76
FASCIA | C200TB-C250TB/4 | F/76 | 6.2 | +2.899 | +3.051 | 64
FASCIA | C200TB-C250TB/4 | F/77 | 4.5 | +3.109 | +3.211 | 51
TH | C200TB-C250TB/4 | B/110 | 3.2 | +2.410 | +2.560 | 150
FASCIA | C200TB-C250TB/3 | F/76 | 6.2 | +2.899 | +3.051 | 64
FASCIA | C200TB-C250TB/3 | F/77 | 4.5 | +3.109 | +3.211 | 51
TH | C200TB-C250TB/3 | B/109 | 3.2 | +2.422 | +2.547 | 125
FASCIA | C200TB-C250TB/2 | F/77 | 4.5 | +3.109 | +3.211 | 51
TH | C200TB-C250TB/2 | B/108 | 3.2 | +2.720 | +2.850 | 130

# IfcMechanicalFastener: Bolt assembly (315)
In: Undefined
NominalDiameter: 5 mm; NominalLength: 25 mm; Material: TEK_16TPIM
Tekla Bolt - Washer diameter: 5 mm; Washer type: UNDEF_WASH; Washer name: UNDEFINED_WASHER10G; Nut type: UNDEF_NUT; Nut name: UNDEFINED_NUTM5; Slotted hole y: 0 mm; Slotted hole x: 0 mm; Bolt hole diameter: 7 mm; Location: Site; Bolt size: 5 mm; Bolt length: 25 mm; Bolt standard: TEK_16TPIM; Bolt Name: TEKSCREW_M5*25
Name | Washer count | Nut count = Bolt count
210 x Bolt assembly | 4 | 2
105 x Bolt assembly | 8 | 4
