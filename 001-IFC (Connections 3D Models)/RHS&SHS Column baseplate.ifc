Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView_V2.0, QuantityTakeOffAddOnView], Option [BaseQuantities:On], Option [GridExport:On], Option [Assemblies:On], Option [Bolts:On], Option [Rebars:On], Option [PourObjects:Off], Option [Welds:Off], Option [SurfaceTreatments:Off], Option [LocationBy:0], Option [ViewColors:Off], Option [SectionedSpine:Off], Option [PropertySets:On], Option [Export all:Off]
File name: RHS&SHS Column baseplate.ifc
Time: 2026-05-25T09:50:52
Author: DESKTOP-BKNQL56\admin
Organization: Structural Designer
Written by: IFC Database Version: Work
Made in: Tekla Structures 2019 Service Pack 13, IFC Export Version: 4.0.0.0 Oct 18 2021

# IfcBuildingStorey, Undefined
In: Undefined
Elevation: 0 mm

# IfcBeam: D16 (18)
In: Undefined
Description: D16; Material: STEEL/250
Default - ASSEMBLY_POS: z/3
Tekla Common - Phase: 1; Class: 1
Tekla Quantity - Weight: 0.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 35.2 m2; Net surface area: 0 m2; Height: 16 mm; Width: 16 mm; Length: 378.3 mm
Pset_BeamCommon - LoadBearing: no; Reference: z/3
BaseQuantities - Length: 378.265 mm; OuterSurfaceArea: 0.0188516 m2; NetVolume: 0.0000682413 m3; NetWeight: 0.535694 kg
Name | Bottom elevation | Top elevation
8 x HOOK BOLTS | -0.238 | +0.062
10 x HOOK BOLTS | -0.234 | +0.066

# IfcColumn: RHS:100x50x5.0, COLUMN
In: Undefined
Description: RHS:100x50x5.0; Material: STEEL/300PLUS
Tekla Common - Bottom elevation: +0.012; Top elevation: +0.900; Phase: 1; Class: 12
BaseQuantities - Length: 888 mm; OuterSurfaceArea: 0.247752 m2; NetVolume: 0.0012432 m3; NetWeight: 9.75912 kg
Default - ASSEMBLY_POS: C/33
Tekla Quantity - Weight: 9.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 27.1 m2; Net surface area: 0.4 m2; Height: 100 mm; Width: 50 mm; Length: 888 mm
Pset_ColumnCommon - LoadBearing: no; Reference: C/33

# IfcColumn: RHS:150x100x5.0, COLUMN
In: Undefined
Description: RHS:150x100x5.0; Material: STEEL/300PLUS
Tekla Common - Bottom elevation: +0.016; Top elevation: +0.900; Phase: 1; Class: 12
BaseQuantities - Length: 884 mm; OuterSurfaceArea: 0.423436 m2; NetVolume: 0.0021216 m3; NetWeight: 16.6546 kg
Default - ASSEMBLY_POS: C/37
Tekla Quantity - Weight: 16 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 26.4 m2; Net surface area: 0.4 m2; Height: 150 mm; Width: 100 mm; Length: 884 mm
Pset_ColumnCommon - LoadBearing: no; Reference: C/37

# IfcColumn: RHS:150x50x5.0, COLUMN
In: Undefined
Description: RHS:150x50x5.0; Material: STEEL/300PLUS
Tekla Common - Bottom elevation: +0.012; Top elevation: +0.900; Phase: 1; Class: 12
Default - ASSEMBLY_POS: C/35
Tekla Quantity - Weight: 12.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 26.7 m2; Net surface area: 0.4 m2; Height: 150 mm; Width: 50 mm; Length: 888 mm
Pset_ColumnCommon - LoadBearing: no; Reference: C/35
BaseQuantities - Length: 888 mm; OuterSurfaceArea: 0.336552 m2; NetVolume: 0.0016872 m3; NetWeight: 13.2445 kg

# IfcColumn: RHS:200x100x5.0, COLUMN
In: Undefined
Description: RHS:200x100x5.0; Material: STEEL/300PLUS
Tekla Common - Bottom elevation: +0.016; Top elevation: +0.900; Phase: 1; Class: 12
Default - ASSEMBLY_POS: C/39
Tekla Quantity - Weight: 19.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 26.2 m2; Net surface area: 0.4 m2; Height: 200 mm; Width: 100 mm; Length: 884 mm
Pset_ColumnCommon - LoadBearing: no; Reference: C/39
BaseQuantities - Length: 884 mm; OuterSurfaceArea: 0.511836 m2; NetVolume: 0.0025636 m3; NetWeight: 20.1243 kg

# IfcColumn: RHS:250x150x5.0, COLUMN
In: Undefined
Description: RHS:250x150x5.0; Material: STEEL/300PLUS
Tekla Common - Bottom elevation: +0.016; Top elevation: +0.900; Phase: 1; Class: 12
Default - ASSEMBLY_POS: C/40
Tekla Quantity - Weight: 26.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 26 m2; Net surface area: 0.7 m2; Height: 250 mm; Width: 150 mm; Length: 884 mm
Pset_ColumnCommon - LoadBearing: no; Reference: C/40
BaseQuantities - Length: 884 mm; OuterSurfaceArea: 0.688636 m2; NetVolume: 0.0034476 m3; NetWeight: 27.0637 kg

# IfcColumn: SHS:100x100x5.0, COLUMN
In: Undefined
Description: SHS:100x100x5.0; Material: STEEL/300PLUS
Tekla Common - Bottom elevation: +0.016; Top elevation: +0.900; Phase: 1; Class: 12
Default - ASSEMBLY_POS: C/36
Tekla Quantity - Weight: 12.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 26.7 m2; Net surface area: 0.4 m2; Height: 100 mm; Width: 100 mm; Length: 884 mm
Pset_ColumnCommon - LoadBearing: no; Reference: C/36
BaseQuantities - Length: 884 mm; OuterSurfaceArea: 0.335036 m2; NetVolume: 0.0016796 m3; NetWeight: 13.1849 kg

# IfcColumn: SHS:125x125x5.0, COLUMN
In: Undefined
Description: SHS:125x125x5.0; Material: STEEL/300PLUS
Default - ASSEMBLY_POS: C/38
Tekla Common - Bottom elevation: +0.016; Top elevation: +0.900; Phase: 1; Class: 12
Tekla Quantity - Weight: 16 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 26.4 m2; Net surface area: 0.4 m2; Height: 125 mm; Width: 125 mm; Length: 884 mm
Pset_ColumnCommon - LoadBearing: no; Reference: C/38
BaseQuantities - Length: 884 mm; OuterSurfaceArea: 0.423436 m2; NetVolume: 0.0021216 m3; NetWeight: 16.6546 kg

# IfcColumn: SHS:50x50x5.0, COLUMN
In: Undefined
Description: SHS:50x50x5.0; Material: STEEL/300PLUS
Tekla Common - Bottom elevation: +0.012; Top elevation: +0.900; Phase: 1; Class: 12
Default - ASSEMBLY_POS: C/32
Tekla Quantity - Weight: 5.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 28 m2; Net surface area: 0.2 m2; Height: 50 mm; Width: 50 mm; Length: 888 mm
Pset_ColumnCommon - LoadBearing: no; Reference: C/32
BaseQuantities - Length: 888 mm; OuterSurfaceArea: 0.158952 m2; NetVolume: 0.0007992 m3; NetWeight: 6.27372 kg

# IfcColumn: SHS:75x75x5.0, COLUMN
In: Undefined
Description: SHS:75x75x5.0; Material: STEEL/300PLUS
Default - ASSEMBLY_POS: C/34
Tekla Common - Bottom elevation: +0.012; Top elevation: +0.900; Phase: 1; Class: 12
Tekla Quantity - Weight: 9.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 27.1 m2; Net surface area: 0.4 m2; Height: 75 mm; Width: 75 mm; Length: 888 mm
Pset_ColumnCommon - LoadBearing: no; Reference: C/34
BaseQuantities - Length: 888 mm; OuterSurfaceArea: 0.247752 m2; NetVolume: 0.0012432 m3; NetWeight: 9.75912 kg

# IfcDiscreteAccessory: BASEPLATE (9)
In: Undefined
Material: STEEL/450
Tekla Common - Bottom elevation: +0.000; Phase: 1; Class: 99
Tekla Quantity - Volume: 0 m3
Pset_PlateCommon - LoadBearing: no
Name | Description | Top elevation | Weight (kg) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) | Height (mm) | Width (mm) | Length (mm) | Reference | NetArea (m2) = GrossArea (m2) | CrossSectionArea (m2) | NetVolume (m3) = GrossVolume (m3)
BASEPLATE | FL12*50 | +0.012 | 1.1 | 0 | 27.4 | 0 | 50 | 12 | 240 | p/620 | 0.03096 | 0.0006 | 0.000144
BASEPLATE | FL12*50 | +0.012 | 1.4 | 0 | 27.2 | 0 | 50 | 12 | 290 | p/619 | 0.03716 | 0.0006 | 0.000174
BASEPLATE | FL16*100 | +0.016 | 3.6 | 0 | 19.3 | 0.1 | 100 | 16 | 290 | p/618 | 0.07048 | 0.0016 | 0.000464
BASEPLATE | FL16*100 | +0.016 | 4.3 | 0 | 19.3 | 0.1 | 100 | 16 | 340 | p/617 | 0.08208 | 0.0016 | 0.000544
BASEPLATE | FL16*150 | +0.016 | 7.3 | 0.1 | 18.3 | 0.1 | 150 | 16 | 390 | p/616 | 0.13428 | 0.0024 | 0.000936
BASEPLATE | PLT16*125 | +0.016 | 4.3 | 0 | 18.9 | 0.1 | 125 | 16 | 265 | p/615 | 0.07873 | 0.002 | 0.00053
BASEPLATE | FL16*100 | +0.016 | 3 | 0 | 19.5 | 0.1 | 100 | 16 | 240 | p/614 | 0.05888 | 0.0016 | 0.000384
BASEPLATE | FL12*75 | +0.012 | 1.4 | 0 | 25.8 | 0 | 75 | 12 | 215 | p/613 | 0.03921 | 0.0009 | 0.0001935
BASEPLATE | FL12*50 | +0.012 | 0.9 | 0 | 27.7 | 0 | 50 | 12 | 190 | p/612 | 0.02476 | 0.0006 | 0.000114

# IfcDiscreteAccessory: NUT (18)
In: Undefined
Description: M16_NUT; Material: STEEL/250
Tekla Common - Phase: 1; Class: 1
Tekla Quantity - Weight: 0.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 30.6 m2; Net surface area: 0 m2; Height: 24.2 mm; Width: 28 mm; Length: 16 mm
Pset_PlateCommon - LoadBearing: no; Reference: z/696
BaseQuantities - NetArea: 0.00236245 m2; GrossArea: 0 m2; CrossSectionArea: 0.000615 m2; NetVolume: 0.00000814757 m3; GrossVolume: 0.00000984 m3
Name | Bottom elevation | Top elevation
8 x NUT | +0.020 | +0.036
10 x NUT | +0.024 | +0.040

# IfcDiscreteAccessory: WASHER (18)
In: Undefined
Description: PD32*8; Material: STEEL/250
Tekla Common - Phase: 1; Class: 1
Tekla Quantity - Weight: 0 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 43.2 m2; Net surface area: 0 m2; Height: 32 mm; Width: 32 mm; Length: 8 mm
Pset_PlateCommon - LoadBearing: no; Reference: z/1743
BaseQuantities - NetArea: 0.00156309 m2; GrossArea: 0.00156309 m2; CrossSectionArea: 0.000576 m2; NetVolume: 0.000004608 m3; GrossVolume: 0.000004608 m3
Name | Bottom elevation | Top elevation
8 x WASHER | +0.012 | +0.020
10 x WASHER | +0.016 | +0.024

# IfcElementAssembly (27)
In: Undefined
PredefinedType: RIGID_FRAME
Name | ASSEMBLY_POSITION_CODE = Assembly/Cast unit position code | ASSEMBLY_POS = Assembly/Cast unit Mark | Assembly/Cast unit weight (kg) | Assembly/Cast unit bottom elevation | Assembly/Cast unit top elevation | Width (mm)
2 x HOOK BOLTS | RHS100X50/TYPE1 | z/3 | 0.6 | -0.238 | +0.062 | 32
COLUMN | RHS100X50/TYPE1 | C/33 | 10.3 | +0.000 | +0.900 | 50
2 x HOOK BOLTS | RHS150X50/TYPE1 | z/3 | 0.6 | -0.238 | +0.062 | 32
COLUMN | RHS150X50/TYPE1 | C/35 | 14 | +0.000 | +0.900 | 50
2 x HOOK BOLTS | RHS150X100/TYPE1 | z/3 | 0.6 | -0.234 | +0.066 | 32
COLUMN | RHS150X100/TYPE1 | C/37 | 19.7 | +0.000 | +0.900 | 100
2 x HOOK BOLTS | RHS200X100/TYPE1 | z/3 | 0.6 | -0.234 | +0.066 | 32
COLUMN | RHS200X100/TYPE1 | C/39 | 23.8 | +0.000 | +0.900 | 100
2 x HOOK BOLTS | RHS250X150/TYPE1 | z/3 | 0.6 | -0.234 | +0.066 | 32
COLUMN | RHS250X150/TYPE1 | C/40 | 33.8 | +0.000 | +0.900 | 150
2 x HOOK BOLTS | SHS125*125*5.0/TYPE1 | z/3 | 0.6 | -0.234 | +0.066 | 32
COLUMN | SHS125*125*5.0/TYPE1 | C/38 | 20.2 | +0.000 | +0.900 | 125
2 x HOOK BOLTS | SHS100*100*5.0/TYPE1 | z/3 | 0.6 | -0.234 | +0.066 | 32
COLUMN | SHS100*100*5.0/TYPE1 | C/36 | 15.6 | +0.000 | +0.900 | 100
2 x HOOK BOLTS | SHS75*75*5.0/TYPE1 | z/3 | 0.6 | -0.238 | +0.062 | 32
COLUMN | SHS75*75*5.0/TYPE1 | C/34 | 10.7 | +0.000 | +0.900 | 75
2 x HOOK BOLTS | SHS50*50*5.0/TYPE1 | z/3 | 0.6 | -0.238 | +0.062 | 32
COLUMN | SHS50*50*5.0/TYPE1 | C/32 | 6.6 | +0.000 | +0.900 | 50

# IfcMechanicalFastener: Bolt assembly (9)
In: Undefined
NominalDiameter: 16 mm; Material: HIT_HY150
Tekla Bolt - Washer count: 0; Washer diameter: 16 mm; Washer type: WASHER-HAS; Washer name: HAS-WASHER-16; Nut count: 0; Nut type: NUT-HAS; Nut name: HAS-NUT-16; Slotted hole y: 0 mm; Slotted hole x: 0 mm; Bolt hole diameter: 22 mm; Location: Site; Bolt count: 2; Bolt size: 22 mm; Bolt standard: HILTI_HY150-E; Bolt Name: HAS
Name | NominalLength (mm) = Bolt length (mm)
4 x Bolt assembly | 12
5 x Bolt assembly | 16
