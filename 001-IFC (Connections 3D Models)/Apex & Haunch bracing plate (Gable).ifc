Properties of the parts of a building model (IFC2X3), part 4 of 4

# IfcPlate: PLT3*645.5 (4)
Default - ASSEMBLY_POS: Z/1095
Tekla Common - Bottom elevation: +5.893; Top elevation: +6.348; Phase: 1; Class: 1
Tekla Quantity - Weight: 9.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.8 m2; Height: 645.5 mm; Width: 3 mm; Length: 975.3 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/1095
BaseQuantities - Width: 645.542 mm; NetArea: 0.849539 m2; GrossArea: 0.629592 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00126179 m3; GrossVolume: 0.00126179 m3

# IfcPlate: PLT3*650 (4)
In: Undefined
Description: PLT3*650; Material: STEEL/450
Default - ASSEMBLY_POS: Z/667
Tekla Common - Bottom elevation: +5.433; Top elevation: +5.887; Phase: 1; Class: 1
Tekla Quantity - Weight: 11.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.7 m2; Height: 650 mm; Width: 3 mm; Length: 981.8 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/667
BaseQuantities - Width: 650 mm; NetArea: 0.948818 m2; GrossArea: 0.638154 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00141008 m3; GrossVolume: 0.00141008 m3
Name | Net surface area (m2)
PLATE | 1
3 x PLATE | 0.8

# IfcPlate: PLT3*651.2 (8)
In: Undefined
Description: PLT3*651.2; Material: STEEL/450
Tekla Common - Bottom elevation: +4.577; Top elevation: +5.137; Phase: 1; Class: 1
Tekla Quantity - Weight: 9.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.8 m2; Height: 651.2 mm; Width: 3 mm; Length: 932.8 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 651.229 mm; GrossArea: 0.607454 m2; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | NetArea (m2) | NetVolume (m3) = GrossVolume (m3)
2 x PLATE | Z/2415 | 0.846959 | 0.00125794
2 x PLATE | Z/2416 | 0.846955 | 0.00125793
2 x PLATE | Z/2416 | 0.846958 | 0.00125794
2 x PLATE | Z/2415 | 0.846956 | 0.00125794

# IfcPlate: PLT3*651.8 (4)
In: Undefined
Description: PLT3*651.8; Material: STEEL/450
Default - ASSEMBLY_POS: Z/1115
Tekla Common - Bottom elevation: +4.577; Top elevation: +5.345; Phase: 1; Class: 1
Tekla Quantity - Weight: 11.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.7 m2; Net surface area: 1 m2; Height: 651.8 mm; Width: 3.1 mm; Length: 1025.7 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/1115
BaseQuantities - Width: 651.804 mm; NetArea: 1.00762 m2; GrossArea: 0.668586 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00149792 m3; GrossVolume: 0.00149792 m3

# IfcPlate: PLT3*652 (4)
In: Undefined
Description: PLT3*652; Material: STEEL/450
Tekla Common - Bottom elevation: +4.577; Top elevation: +5.345; Phase: 1; Class: 1
Default - ASSEMBLY_POS: Z/1116
Tekla Quantity - Weight: 11.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.7 m2; Net surface area: 1 m2; Height: 652 mm; Width: 3.1 mm; Length: 1025.7 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/1116
BaseQuantities - Width: 651.954 mm; NetArea: 1.00763 m2; GrossArea: 0.668766 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.0014979 m3; GrossVolume: 0.0014979 m3

# IfcPlate: PLT3*672.5 (2)
In: Undefined
Description: PLT3*672.5; Material: STEEL/450
Tekla Common - Bottom elevation: +4.478; Top elevation: +5.246; Phase: 1; Class: 11
Tekla Quantity - Weight: 8.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.6 m2; Height: 672.5 mm; Width: 3 mm; Length: 838 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 672.453 mm; NetArea: 0.746033 m2; GrossArea: 0.563485 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00110637 m3; GrossVolume: 0.00113185 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1884
HAUNCH BRACING PLATE | PL/1895

# IfcPlate: PLT3*674.2 (2)
In: Undefined
Description: PLT3*674.2; Material: STEEL/450
Tekla Common - Bottom elevation: +3.826; Top elevation: +4.416; Phase: 1; Class: 11
Tekla Quantity - Weight: 7.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.6 m2; Height: 674.2 mm; Width: 3 mm; Length: 781.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 674.214 mm; NetArea: 0.654677 m2; GrossArea: 0.526971 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.0009702 m3; GrossVolume: 0.000995684 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1905
HAUNCH BRACING PLATE | PL/1916

# IfcPlate: PLT3*678.3 (2)
In: Undefined
Description: PLT3*678.3; Material: STEEL/450
Tekla Common - Bottom elevation: +4.509; Top elevation: +5.300; Phase: 1; Class: 11
Tekla Quantity - Weight: 9.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.8 m2; Height: 678.3 mm; Width: 3 mm; Length: 863.7 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 678.313 mm; NetArea: 0.782285 m2; GrossArea: 0.585869 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00116041 m3; GrossVolume: 0.00118589 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1886
HAUNCH BRACING PLATE | PL/1897

# IfcPlate: PLT3*686.5 (2)
In: Undefined
Description: PLT3*686.5; Material: STEEL/450
Tekla Common - Bottom elevation: +4.556; Top elevation: +5.385; Phase: 1; Class: 11
Tekla Quantity - Weight: 9.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.8 m2; Height: 686.5 mm; Width: 3 mm; Length: 909.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 686.522 mm; NetArea: 0.845503 m2; GrossArea: 0.624473 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00125462 m3; GrossVolume: 0.0012801 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1888
HAUNCH BRACING PLATE | PL/1899

# IfcPlate: PLT3*687.9 (4)
In: Undefined
Description: PLT3*687.9; Material: STEEL/450
Default - ASSEMBLY_POS: Z/1121
Tekla Common - Bottom elevation: +5.638; Top elevation: +6.119; Phase: 1; Class: 1
Tekla Quantity - Weight: 11.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.7 m2; Net surface area: 1 m2; Height: 687.9 mm; Width: 3 mm; Length: 1000.7 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/1121
BaseQuantities - Width: 687.908 mm; NetArea: 0.97651 m2; GrossArea: 0.688403 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.0014515 m3; GrossVolume: 0.0014515 m3

# IfcPlate: PLT3*694 (2)
In: Undefined
Description: PLT3*694; Material: STEEL/450
Tekla Common - Bottom elevation: +4.604; Top elevation: +5.479; Phase: 1; Class: 11
Tekla Quantity - Weight: 10.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.8 m2; Height: 694 mm; Width: 3 mm; Length: 967 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 694.014 mm; NetArea: 0.922465 m2; GrossArea: 0.671109 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00136932 m3; GrossVolume: 0.0013948 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1890
HAUNCH BRACING PLATE | PL/1901

# IfcPlate: PLT3*708.6 (2)
In: Undefined
Description: PLT3*708.6; Material: STEEL/450
Tekla Common - Bottom elevation: +4.718; Top elevation: +5.753; Phase: 1; Class: 11
Tekla Quantity - Weight: 13.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.7 m2; Net surface area: 1.2 m2; Height: 708.6 mm; Width: 3 mm; Length: 1180.2 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 708.623 mm; NetArea: 1.19174 m2; GrossArea: 0.836328 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00177061 m3; GrossVolume: 0.00179609 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1892
HAUNCH BRACING PLATE | PL/1903

# IfcPlate: PLT3*713.4 (2)
In: Undefined
Description: PLT3*713.4; Material: STEEL/450
Tekla Common - Bottom elevation: +4.422; Top elevation: +5.239; Phase: 1; Class: 11
Tekla Quantity - Weight: 9.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.8 m2; Height: 713.4 mm; Width: 3 mm; Length: 866.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 713.419 mm; NetArea: 0.79865 m2; GrossArea: 0.61828 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00118485 m3; GrossVolume: 0.00121033 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1906
HAUNCH BRACING PLATE | PL/1917

# IfcPlate: PLT3*716.4 (4)
In: Undefined
Description: PLT3*716.4; Material: STEEL/450
Default - ASSEMBLY_POS: Z/1096
Tekla Common - Bottom elevation: +6.416; Top elevation: +6.935; Phase: 1; Class: 1
Tekla Quantity - Weight: 10.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.7 m2; Net surface area: 0.8 m2; Height: 716.4 mm; Width: 3 mm; Length: 969.5 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/1096
BaseQuantities - Width: 716.41 mm; NetArea: 0.899521 m2; GrossArea: 0.694526 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00133658 m3; GrossVolume: 0.00133658 m3

# IfcPlate: PLT3*720.2 (2)
In: Undefined
Description: PLT3*720.2; Material: STEEL/450
Tekla Common - Bottom elevation: +4.494; Top elevation: +5.334; Phase: 1; Class: 11
Tekla Quantity - Weight: 9.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.8 m2; Height: 720.2 mm; Width: 3 mm; Length: 890.9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 720.245 mm; NetArea: 0.837656 m2; GrossArea: 0.641696 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00124301 m3; GrossVolume: 0.00126848 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1908
HAUNCH BRACING PLATE | PL/1919

# IfcPlate: PLT3*723.1 (4)
In: Undefined
Description: PLT3*723.1; Material: STEEL/450
Default - ASSEMBLY_POS: Z/1122
Tekla Common - Bottom elevation: +5.849; Top elevation: +6.357; Phase: 1; Class: 1
Tekla Quantity - Weight: 11.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.7 m2; Net surface area: 1 m2; Height: 723.1 mm; Width: 3 mm; Length: 1013.6 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/1122
BaseQuantities - Width: 723.131 mm; NetArea: 1.00302 m2; GrossArea: 0.732998 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00149115 m3; GrossVolume: 0.00149115 m3

# IfcPlate: PLT3*729.8 (2)
In: Undefined
Description: PLT3*729.8; Material: STEEL/450
Tekla Common - Bottom elevation: +4.523; Top elevation: +5.400; Phase: 1; Class: 11
Tekla Quantity - Weight: 10.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.8 m2; Height: 729.8 mm; Width: 3 mm; Length: 934.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 729.824 mm; NetArea: 0.905805 m2; GrossArea: 0.682108 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00134462 m3; GrossVolume: 0.00137009 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1910
HAUNCH BRACING PLATE | PL/1921

# IfcPlate: PLT3*738.6 (2)
In: Undefined
Description: PLT3*738.6; Material: STEEL/450
Tekla Common - Bottom elevation: +4.606; Top elevation: +5.529; Phase: 1; Class: 11
Tekla Quantity - Weight: 11.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 1 m2; Height: 738.6 mm; Width: 3 mm; Length: 989.7 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 738.568 mm; NetArea: 0.98887 m2; GrossArea: 0.730971 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00146847 m3; GrossVolume: 0.00149395 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1912
HAUNCH BRACING PLATE | PL/1923

# IfcPlate: PLT3*753.2 (2)
In: Undefined
Description: PLT3*753.2; Material: STEEL/450
Tekla Common - Bottom elevation: +3.684; Top elevation: +4.344; Phase: 1; Class: 11
Tekla Quantity - Weight: 9.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.8 m2; Height: 753.2 mm; Width: 3 mm; Length: 831.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 753.215 mm; GrossArea: 0.626396 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00119813 m3; GrossVolume: 0.00122361 m3
Name | ASSEMBLY_POS = Reference | NetArea (m2)
HAUNCH BRACING PLATE | PL/1927 | 0.807386
HAUNCH BRACING PLATE | PL/1938 | 0.807385

# IfcPlate: PLT3*755.6 (2)
In: Undefined
Description: PLT3*755.6; Material: STEEL/450
Tekla Common - Bottom elevation: +4.742; Top elevation: +5.820; Phase: 1; Class: 11
Tekla Quantity - Weight: 14.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.7 m2; Net surface area: 1.2 m2; Height: 755.6 mm; Width: 3 mm; Length: 1193.2 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 755.604 mm; NetArea: 1.27842 m2; GrossArea: 0.90159 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00190021 m3
Name | ASSEMBLY_POS = Reference | GrossVolume (m3)
HAUNCH BRACING PLATE | PL/1914 | 0.00192569
HAUNCH BRACING PLATE | PL/1925 | 0.00192568

# IfcPlate: PLT3*792.4 (2)
In: Undefined
Description: PLT3*792.4; Material: STEEL/450
Tekla Common - Bottom elevation: +4.402; Top elevation: +5.270; Phase: 1; Class: 11
Tekla Quantity - Weight: 11.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 1 m2; Height: 792.4 mm; Width: 3 mm; Length: 938.1 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 792.417 mm; NetArea: 0.991619 m2; GrossArea: 0.743328 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00147296 m3; GrossVolume: 0.00149843 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1928
HAUNCH BRACING PLATE | PL/1939

# IfcPlate: PLT3*792.7 (4)
In: Undefined
Description: PLT3*792.7; Material: STEEL/450
Default - ASSEMBLY_POS: Z/1123
Tekla Common - Bottom elevation: +6.373; Top elevation: +6.947; Phase: 1; Class: 1
Tekla Quantity - Weight: 12.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.7 m2; Net surface area: 1.1 m2; Height: 792.7 mm; Width: 3 mm; Length: 1020 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/1123
BaseQuantities - Width: 792.682 mm; NetArea: 1.06002 m2; GrossArea: 0.808545 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.0015764 m3; GrossVolume: 0.0015764 m3

# IfcPlate: PLT3*799.2 (2)
In: Undefined
Description: PLT3*799.2; Material: STEEL/450
Tekla Common - Bottom elevation: +4.435; Top elevation: +5.329; Phase: 1; Class: 11
Tekla Quantity - Weight: 12.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.7 m2; Net surface area: 1 m2; Height: 799.2 mm; Width: 3 mm; Length: 967.9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 799.249 mm; NetArea: 1.04139 m2; GrossArea: 0.773617 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.0015472 m3; GrossVolume: 0.00157267 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1930
HAUNCH BRACING PLATE | PL/1941

# IfcPlate: PLT3*808.8 (2)
In: Undefined
Description: PLT3*808.8; Material: STEEL/450
Tekla Common - Bottom elevation: +4.484; Top elevation: +5.423; Phase: 1; Class: 11
Tekla Quantity - Weight: 13.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.7 m2; Net surface area: 1.1 m2; Height: 808.8 mm; Width: 3 mm; Length: 1021.2 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 808.819 mm; NetArea: 1.12819 m2; GrossArea: 0.825975 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00167668 m3; GrossVolume: 0.00170216 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1932
HAUNCH BRACING PLATE | PL/1943

# IfcPlate: PLT3*817.6 (2)
In: Undefined
Description: PLT3*817.6; Material: STEEL/450
Tekla Common - Bottom elevation: +4.534; Top elevation: +5.526; Phase: 1; Class: 11
Tekla Quantity - Weight: 14.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.7 m2; Net surface area: 1.2 m2; Height: 817.6 mm; Width: 3 mm; Length: 1087.8 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 817.562 mm; NetArea: 1.23388 m2; GrossArea: 0.889379 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00183435 m3; GrossVolume: 0.00185983 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1934
HAUNCH BRACING PLATE | PL/1945

# IfcPlate: PLT3*834.6 (2)
In: Undefined
Description: PLT3*834.6; Material: STEEL/450
Tekla Common - Bottom elevation: +4.724; Top elevation: +5.899; Phase: 1; Class: 11
Tekla Quantity - Weight: 18.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.7 m2; Net surface area: 1.6 m2; Height: 834.6 mm; Width: 3 mm; Length: 1330.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 834.599 mm; NetArea: 1.60156 m2; GrossArea: 1.11049 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00238286 m3; GrossVolume: 0.00240833 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1936
HAUNCH BRACING PLATE | PL/1947
