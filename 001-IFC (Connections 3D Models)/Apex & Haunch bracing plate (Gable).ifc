Properties of the parts of a building model (IFC2X3), part 2 of 4

# IfcElementAssembly (1488)
Name | ASSEMBLY_POSITION_CODE = Assembly/Cast unit position code | ASSEMBLY_POS = Assembly/Cast unit Mark | Assembly/Cast unit weight (kg) | Assembly/Cast unit bottom elevation | Assembly/Cast unit top elevation | Width (mm)
2 x TH | C200SD-C250SD/HB | Z/562 | 1.8 | +4.559 | +4.684 | 125
TH | C200SD-C250SD/AB-HB | Z/562 | 1.8 | +5.441 | +5.534 | 125
2 x FASCIA | C200SD-C250SD/HB | Z/561 | 3.5 | +4.908 | +5.060 | 64
4 x TH | C200SD-C250SD/HB | Z/562 | 1.8 | +4.562 | +4.687 | 125
TH | C200SD-C250SD/AB-HB | Z/562 | 1.8 | +5.355 | +5.445 | 125
2 x FASCIA | C200SD-C250SD/HB(25deg) | Z/561 | 3.5 | +4.895 | +5.047 | 64
2 x TH | C200SD-C250SD/HB(25deg) | Z/562 | 1.8 | +4.549 | +4.674 | 125
2 x FASCIA | C200SD-C250SD/HB(18deg) | Z/561 | 3.5 | +4.902 | +5.054 | 64
2 x TH | C200SD-C250SD/HB(18deg) | Z/562 | 1.8 | +4.556 | +4.681 | 125
2 x FASCIA | C200SD-C250SD/HB(15deg) | Z/561 | 3.5 | +4.905 | +5.057 | 64
2 x TH | C200SD-C250SD/HB(15deg) | Z/562 | 1.8 | +4.559 | +4.684 | 125
FASCIA | C200SD-C250SD/HB(12deg) | Z/561 | 3.5 | +4.908 | +5.060 | 64
2 x TH | C200SD-C250SD/HB(12deg) | Z/562 | 1.8 | +4.562 | +4.687 | 125
TH | C200SD-C250SD/HB(25deg)-AB | Z/562 | 1.8 | +5.713 | +5.815 | 125
TH | C200SD-C250SD/HB(18deg)-AB | Z/562 | 1.8 | +5.526 | +5.622 | 125
TH | C200SD-C250SD/HB(15deg)-AB | Z/562 | 1.8 | +5.441 | +5.534 | 125
TH | C200SD-C250SD/HB(12deg)-AB | Z/562 | 1.8 | +5.355 | +5.445 | 125
PLATE | C250SD/AB-HB | Z/1058 | 6.1 | +4.692 | +5.252 | 79
PLATE | C250SD/AB-HB | Z/1060 | 5.6 | +4.692 | +5.180 | 79
PLATE | C250SD/AB-HB | Z/1062 | 5.4 | +4.692 | +5.149 | 79
PLATE | C250SD/HB | Z/1289 | 5.2 | +4.692 | +5.119 | 79
PLATE | C250SD/HB(25deg)-AB | Z/1059 | 6.1 | +4.692 | +5.252 | 79
2 x PLATE | C250SD/AB | Z/1066 | 4.7 | +6.540 | +6.924 | 79
PLATE | C250SD/HB(18deg)-AB | Z/1061 | 5.6 | +4.692 | +5.180 | 79
2 x PLATE | C250SD/AB | Z/1065 | 4.4 | +5.996 | +6.341 | 79
PLATE | C250SD/HB(15deg)-AB | Z/1063 | 5.4 | +4.692 | +5.149 | 79
2 x PLATE | C250SD/AB | Z/1064 | 4.2 | +5.776 | +6.105 | 79
PLATE | C250SD/HB(12deg) | Z/1287 | 5.2 | +4.692 | +5.119 | 79
2 x PLATE | C250SD/AB | Z/1288 | 4.2 | +5.562 | +5.877 | 79
APEX BRACING PLATE | C200SD/HB(12deg)-AB | PL/1750 | 9.1 | +5.254 | +5.502 | 79
APEX BRACING PLATE | C200SD/HB(25deg)-AB | PL/1756 | 5.4 | +6.047 | +6.327 | 79
APEX BRACING PLATE | C200SD/HB(18deg)-AB | PL/1754 | 6.7 | +5.607 | +5.871 | 79
APEX BRACING PLATE | C200SD/HB(15deg)-AB | PL/1752 | 7.7 | +5.428 | +5.684 | 79
HAUNCH BRACING PLATE | C200SD/HB(25deg)-AB | PL/1755 | 7 | +4.961 | +5.717 | 79
HAUNCH BRACING PLATE | C200SD/HB(18deg)-AB | PL/1753 | 5.4 | +4.821 | +5.469 | 79
HAUNCH BRACING PLATE | C200SD/HB(15deg)-AB | PL/1751 | 5.2 | +4.764 | +5.380 | 79
HAUNCH BRACING PLATE | C200SD/HB(12deg)-AB | PL/1749 | 4.8 | +4.707 | +5.298 | 79
2 x FASCIA BRACKET | C200SD/HB | Z/52 | 0.2 | +4.893 | +5.050 | 157.2
2 x FASCIA BRACKET | C200SD/HB | Z/52 | 0.2 | +4.900 | +5.057 | 157.2
2 x FASCIA BRACKET | C200SD/HB | Z/52 | 0.2 | +4.903 | +5.060 | 157.2
4 x FASCIA BRACKET | C200SD/HB | Z/52 | 0.2 | +4.906 | +5.063 | 157.2
2 x FASCIA BRACKET | C200SD/HB(25deg) | Z/52 | 0.2 | +4.893 | +5.050 | 157.2
2 x FASCIA BRACKET | C200SD/HB(18deg) | Z/52 | 0.2 | +4.900 | +5.057 | 157.2
2 x FASCIA BRACKET | C200SD/HB(12deg) | Z/52 | 0.2 | +4.906 | +5.063 | 157.2
2 x FASCIA BRACKET | C200SD/HB(15deg) | Z/52 | 0.2 | +4.903 | +5.060 | 157.2
2 x COLUMN | C200SD/HB | Z/111 | 35.8 | +0.000 | +5.050 | 76
2 x COLUMN | C200SD/HB | Z/109 | 35.8 | +0.000 | +5.057 | 76
2 x COLUMN | C200SD/HB | Z/106 | 35.8 | +0.000 | +5.060 | 76
3 x COLUMN | C200SD/HB | Z/2398 | 35.8 | +0.000 | +5.063 | 76
2 x RAFTER | C200SD/AB-HB | Z/5 | 29.7 | +4.915 | +6.870 | 76
2 x RAFTER | C200SD/HB(25deg)-AB | Z/2485 | 29.7 | +4.915 | +6.870 | 76
2 x COLUMN | C200SD/HB(25deg) | Z/111 | 35.8 | +0.000 | +5.050 | 76
2 x RAFTER | C200SD/AB-HB | Z/4 | 28.5 | +4.876 | +6.310 | 76
2 x RAFTER | C200SD/HB(18deg)-AB | Z/2484 | 28.5 | +4.876 | +6.310 | 76
2 x COLUMN | C200SD/HB(18deg) | Z/109 | 35.8 | +0.000 | +5.057 | 76
2 x RAFTER | C200SD/AB-HB | Z/107 | 28.1 | +4.861 | +6.083 | 76
2 x RAFTER | C200SD/HB(15deg)-AB | Z/2442 | 28.1 | +4.861 | +6.083 | 76
2 x COLUMN | C200SD/HB(15deg) | Z/106 | 35.8 | +0.000 | +5.060 | 76
2 x RAFTER | C200SD/AB-HB | Z/64 | 27.8 | +4.846 | +5.861 | 76
2 x RAFTER | C200SD/HB(12deg)-AB | Z/2414 | 27.8 | +4.846 | +5.861 | 76
2 x COLUMN | C200SD/HB(12deg) | Z/2398 | 35.8 | +0.000 | +5.063 | 76
APEX BRACING PLATE | C200SD/HB(12deg)-AB | PL/1739 | 9.1 | +5.254 | +5.502 | 79
2 x APEX BRACE | C200SD/HB(12deg)-HB | Z/2433 | 16.3 | +5.257 | +5.460 | 76
APEX BRACING PLATE | C200SD/HB(25deg)-AB | PL/1745 | 5.4 | +6.047 | +6.327 | 79
2 x APEX BRACE | C200SD/HB(25deg)-HB | Z/2433 | 16.3 | +6.050 | +6.253 | 76
APEX BRACING PLATE | C200SD/HB(18deg)-AB | PL/1743 | 6.7 | +5.607 | +5.871 | 79
2 x APEX BRACE | C200SD/HB(18deg)-HB | Z/2433 | 16.3 | +5.610 | +5.813 | 76
APEX BRACING PLATE | C200SD/HB(15deg)-AB | PL/1741 | 7.7 | +5.428 | +5.684 | 79
2 x APEX BRACE | C200SD/HB(15deg)-HB | Z/2433 | 16.3 | +5.431 | +5.634 | 76
HAUNCH BRACING PLATE | C200SD/HB(25deg)-AB | PL/1744 | 7 | +4.961 | +5.717 | 79
HAUNCH BRACING PLATE | C200SD/HB(18deg)-AB | PL/1742 | 5.4 | +4.821 | +5.469 | 79
HAUNCH BRACING PLATE | C200SD/HB(15deg)-AB | PL/1740 | 5.2 | +4.764 | +5.380 | 79
HAUNCH BRACING PLATE | C200SD/HB(12deg)-AB | PL/1738 | 4.8 | +4.707 | +5.298 | 79
2 x HAUNCH BRACE | C200SD/HB(25deg)-AB | Z/2486 | 6.8 | +4.265 | +5.262 | 76
2 x HAUNCH BRACE | C200SD/HB(18deg)-AB | Z/2486 | 6.8 | +4.125 | +5.122 | 76
2 x HAUNCH BRACE | C200SD/HB(15deg)-AB | Z/2486 | 6.8 | +4.068 | +5.065 | 76
2 x HAUNCH BRACE | C200SD/HB(12deg)-AB | Z/2486 | 6.8 | +4.012 | +5.009 | 76
PLATE | C200SD/HB | Z/1030 | 3.7 | +4.775 | +5.192 | 79
2 x FASCIA | C150SD-C200SD/HB | Z/561 | 3.5 | +4.895 | +5.047 | 64
2 x TH | C150SD-C200SD/HB | Z/562 | 1.8 | +4.549 | +4.674 | 125
TH | C150SD-C200SD/AB-HB | Z/562 | 1.8 | +5.704 | +5.806 | 125
2 x FASCIA | C150SD-C200SD/HB | Z/561 | 3.5 | +4.902 | +5.054 | 64
2 x TH | C150SD-C200SD/HB | Z/562 | 1.8 | +4.556 | +4.681 | 125
TH | C150SD-C200SD/AB-HB | Z/562 | 1.8 | +5.519 | +5.615 | 125
2 x FASCIA | C150SD-C200SD/HB | Z/561 | 3.5 | +4.905 | +5.057 | 64
2 x TH | C150SD-C200SD/HB | Z/562 | 1.8 | +4.559 | +4.684 | 125
TH | C150SD-C200SD/AB-HB | Z/562 | 1.8 | +5.435 | +5.528 | 125
4 x FASCIA | C150SD-C200SD/HB | Z/561 | 3.5 | +4.909 | +5.061 | 64
4 x TH | C150SD-C200SD/HB | Z/562 | 1.8 | +4.562 | +4.687 | 125
TH | C150SD-C200SD/AB-HB | Z/562 | 1.8 | +5.349 | +5.440 | 125
2 x FASCIA | C150SD-C200SD/HB(25deg) | Z/561 | 3.5 | +4.895 | +5.047 | 64
2 x TH | C150SD-C200SD/HB(25deg) | Z/562 | 1.8 | +4.549 | +4.674 | 125
2 x FASCIA | C150SD-C200SD/HB(18deg) | Z/561 | 3.5 | +4.902 | +5.054 | 64
2 x TH | C150SD-C200SD/HB(18deg) | Z/562 | 1.8 | +4.556 | +4.681 | 125
2 x FASCIA | C150SD-C200SD/HB(15deg) | Z/561 | 3.5 | +4.905 | +5.057 | 64
2 x TH | C150SD-C200SD/HB(15deg) | Z/562 | 1.8 | +4.559 | +4.684 | 125
2 x FASCIA | C150SD-C200SD/HB(12deg) | Z/561 | 3.5 | +4.909 | +5.061 | 64
2 x TH | C150SD-C200SD/HB(12deg) | Z/562 | 1.8 | +4.562 | +4.687 | 125
TH | C150SD-C200SD/HB(25deg)-AB | Z/562 | 1.8 | +5.704 | +5.806 | 125
TH | C150SD-C200SD/HB(18deg)-AB | Z/562 | 1.8 | +5.519 | +5.615 | 125
TH | C150SD-C200SD/HB(15deg)-AB | Z/562 | 1.8 | +5.435 | +5.528 | 125
TH | C150SD-C200SD/HB(12deg)-AB | Z/562 | 1.8 | +5.349 | +5.440 | 125
PLATE | C200SD/HB | Z/1034 | 3.3 | +4.777 | +5.137 | 79
PLATE | C200SD/HB | Z/1032 | 3.2 | +4.777 | +5.114 | 79
PLATE | C200SD/HB | Z/227 | 3.1 | +4.777 | +5.091 | 79
PLATE | C200SD/HB(25deg) | Z/1031 | 3.7 | +4.775 | +5.192 | 79
2 x PLATE | C200SD/AB | Z/1038 | 3.9 | +6.585 | +6.912 | 79
PLATE | C200SD/HB(18deg) | Z/1035 | 3.3 | +4.777 | +5.137 | 79
2 x PLATE | C200SD/AB | Z/1037 | 3.7 | +6.041 | +6.332 | 79
PLATE | C200SD/HB(15deg) | Z/1033 | 3.2 | +4.777 | +5.114 | 79
2 x PLATE | C200SD/AB | Z/1036 | 3.6 | +5.822 | +6.099 | 79
PLATE | C200SD/HB(12deg) | Z/548 | 3.1 | +4.777 | +5.091 | 79
2 x PLATE | C200SD/AB | Z/187 | 3.5 | +5.609 | +5.872 | 79
APEX BRACING PLATE | C150SD/HB(25deg)-AB | PL/1728 | 3.5 | +6.217 | +6.451 | 67
APEX BRACING PLATE | C150SD/HB(18deg)-AB | PL/1727 | 4.2 | +5.755 | +5.971 | 67
APEX BRACING PLATE | C150SD/HB(15deg)-AB | PL/1726 | 4.8 | +5.568 | +5.775 | 67
APEX BRACING PLATE | C150SD/HB(12deg)-AB | PL/1725 | 5.6 | +5.386 | +5.584 | 67
HAUNCH BRACING PLATE | C150SD/HB(25deg)-AB | PL/1733 | 4.4 | +5.088 | +5.700 | 67
HAUNCH BRACING PLATE | C150SD/HB(18deg)-AB | PL/1732 | 3.5 | +4.935 | +5.464 | 67
HAUNCH BRACING PLATE | C150SD/HB(15deg)-AB | PL/1731 | 3.3 | +4.873 | +5.378 | 67
HAUNCH BRACING PLATE | C150SD/HB(12deg)-AB | PL/1730 | 3.1 | +4.812 | +5.297 | 67
2 x FASCIA BRACKET | C150SD/HB | Z/52 | 0.2 | +4.893 | +5.050 | 157.2
2 x FASCIA BRACKET | C150SD/HB | Z/52 | 0.2 | +4.900 | +5.057 | 157.2
2 x FASCIA BRACKET | C150SD/HB | Z/52 | 0.2 | +4.903 | +5.060 | 157.2
4 x FASCIA BRACKET | C150SD/HB | Z/52 | 0.2 | +4.906 | +5.063 | 157.2
2 x FASCIA BRACKET | C150SD/HB(25deg) | Z/52 | 0.2 | +4.893 | +5.050 | 157.2
2 x FASCIA BRACKET | C150SD/HB(18deg) | Z/52 | 0.2 | +4.900 | +5.057 | 157.2
2 x FASCIA BRACKET | C150SD/HB(12deg) | Z/52 | 0.2 | +4.906 | +5.063 | 157.2
2 x FASCIA BRACKET | C150SD/HB(15deg) | Z/52 | 0.2 | +4.903 | +5.060 | 157.2
2 x COLUMN | C150SD/HB | Z/92 | 28.1 | +0.000 | +5.050 | 64
2 x COLUMN | C150SD/HB | Z/89 | 28.2 | +0.000 | +5.057 | 64
2 x COLUMN | C150SD/HB | Z/86 | 28.2 | +0.000 | +5.060 | 64
3 x COLUMN | C150SD/HB | Z/2393 | 28.2 | +0.000 | +5.063 | 64
2 x RAFTER | C150SD/AB-HB | Z/93 | 23.6 | +4.937 | +6.868 | 64
2 x RAFTER | C150SD/HB(25deg)-AB | Z/2407 | 23.6 | +4.937 | +6.868 | 64
2 x COLUMN | C150SD/HB(25deg) | Z/92 | 28.1 | +0.000 | +5.050 | 64
2 x RAFTER | C150SD/AB-HB | Z/90 | 22.6 | +4.908 | +6.307 | 64
2 x RAFTER | C150SD/HB(18deg)-AB | Z/2400 | 22.6 | +4.908 | +6.307 | 64
2 x COLUMN | C150SD/HB(18deg) | Z/89 | 28.2 | +0.000 | +5.057 | 64
2 x RAFTER | C150SD/AB-HB | Z/87 | 22.3 | +4.896 | +6.080 | 64
2 x RAFTER | C150SD/HB(15deg)-AB | Z/2394 | 22.3 | +4.896 | +6.080 | 64
2 x COLUMN | C150SD/HB(15deg) | Z/86 | 28.2 | +0.000 | +5.060 | 64
2 x RAFTER | C150SD/AB-HB | Z/61 | 22.1 | +4.886 | +5.858 | 64
2 x RAFTER | C150SD/HB(12deg)-AB | Z/2385 | 22.1 | +4.886 | +5.858 | 64
2 x COLUMN | C150SD/HB(12deg) | Z/2393 | 28.2 | +0.000 | +5.063 | 64
APEX BRACING PLATE | C150SD/HB(25deg)-AB | PL/1723 | 3.5 | +6.217 | +6.451 | 67
APEX BRACE | C150SD/HB(25deg)-HB | Z/2387 | 12.1 | +6.220 | +6.372 | 64
APEX BRACING PLATE | C150SD/HB(18deg)-AB | PL/1722 | 4.2 | +5.755 | +5.971 | 67
APEX BRACE | C150SD/HB(18deg)-HB | Z/2387 | 12.1 | +5.758 | +5.910 | 64
APEX BRACING PLATE | C150SD/HB(15deg)-AB | PL/1721 | 4.8 | +5.568 | +5.775 | 67
APEX BRACE | C150SD/HB(15deg)-HB | Z/2387 | 12.1 | +5.571 | +5.723 | 64
APEX BRACING PLATE | C150SD/HB(12deg)-AB | PL/1720 | 5.6 | +5.386 | +5.584 | 67
APEX BRACE | C150SD/HB(12deg)-HB | Z/2387 | 12.1 | +5.389 | +5.541 | 64
HAUNCH BRACING PLATE | C150SD/HB(25deg)-AB | PL/1718 | 4.4 | +5.088 | +5.700 | 67
HAUNCH BRACING PLATE | C150SD/HB(18deg)-AB | PL/1717 | 3.5 | +4.935 | +5.464 | 67
HAUNCH BRACING PLATE | C150SD/HB(15deg)-AB | PL/1716 | 3.3 | +4.873 | +5.378 | 67
HAUNCH BRACING PLATE | C150SD/HB(12deg)-AB | PL/1715 | 3.1 | +4.812 | +5.297 | 67
2 x HAUNCH BRACE | C150SD/HB(25deg)-AB | Z/2427 | 6.1 | +4.266 | +5.354 | 64
2 x HAUNCH BRACE | C150SD/HB(18deg)-AB | Z/2427 | 6.1 | +4.113 | +5.200 | 64
2 x HAUNCH BRACE | C150SD/HB(15deg)-AB | Z/2427 | 6.1 | +4.050 | +5.138 | 64
2 x HAUNCH BRACE | C150SD/HB(12deg)-AB | Z/2427 | 6.1 | +3.989 | +5.077 | 64
FASCIA | <C150SD/HB | Z/561 | 3.5 | +4.895 | +5.047 | 64
TH | <C150SD/HB | Z/562 | 1.8 | +4.549 | +4.674 | 125
TH | <C150SD/AB-HB | Z/562 | 1.8 | +5.694 | +5.796 | 125
FASCIA | <C150SD/HB | Z/561 | 3.5 | +4.902 | +5.054 | 64
TH | <C150SD/HB | Z/562 | 1.8 | +4.556 | +4.681 | 125
TH | <C150SD/AB-HB | Z/562 | 1.8 | +5.511 | +5.607 | 125
FASCIA | <C150SD/HB | Z/561 | 3.5 | +4.905 | +5.057 | 64
TH | <C150SD/HB | Z/562 | 1.8 | +4.559 | +4.684 | 125
TH | <C150SD/AB-HB | Z/562 | 1.8 | +5.428 | +5.522 | 125
TH | <C150SD/AB-HB | Z/562 | 1.8 | +5.344 | +5.435 | 125
2 x FASCIA | <C150SD/HB | Z/561 | 3.5 | +4.909 | +5.061 | 64
2 x TH | <C150SD/HB | Z/562 | 1.8 | +4.562 | +4.687 | 125
FASCIA | <C150SD/HB(25deg) | Z/561 | 3.5 | +4.895 | +5.047 | 64
TH | <C150SD/HB(25deg) | Z/562 | 1.8 | +4.549 | +4.674 | 125
FASCIA | <C150SD/HB(18deg) | Z/561 | 3.5 | +4.902 | +5.054 | 64
TH | <C150SD/HB(18deg) | Z/562 | 1.8 | +4.556 | +4.681 | 125
FASCIA | <C150SD/HB(15deg) | Z/561 | 3.5 | +4.905 | +5.057 | 64
TH | <C150SD/HB(15deg) | Z/562 | 1.8 | +4.559 | +4.684 | 125
TH | <C150SD/HB(25deg)-AB | Z/562 | 1.8 | +5.694 | +5.796 | 125
TH | <C150SD/HB(18deg)-AB | Z/562 | 1.8 | +5.511 | +5.607 | 125
TH | <C150SD/HB(15deg)-AB | Z/562 | 1.8 | +5.428 | +5.522 | 125
TH | <C150SD/HB(12deg)-AB | Z/562 | 1.8 | +5.344 | +5.435 | 125
FASCIA | <C150SD/HB(12deg) | Z/561 | 3.5 | +4.909 | +5.061 | 64
TH | <C150SD/HB(12deg) | Z/562 | 1.8 | +4.562 | +4.687 | 125
PLATE | C150SD/HB | Z/993 | 2.9 | +4.777 | +5.168 | 67
PLATE | C150SD/HB | Z/995 | 2.7 | +4.777 | +5.120 | 67
PLATE | C150SD/HB | Z/997 | 2.6 | +4.777 | +5.100 | 67
PLATE | C150SD/HB | Z/220 | 2.5 | +4.777 | +5.080 | 67
PLATE | C150SD/HB(25deg) | Z/994 | 2.9 | +4.777 | +5.168 | 67
2 x PLATE | C150SD/AB | Z/1003 | 2.5 | +6.646 | +6.900 | 67
PLATE | C150SD/HB(18deg) | Z/996 | 2.7 | +4.777 | +5.120 | 67
2 x PLATE | C150SD/AB | Z/1002 | 2.3 | +6.099 | +6.324 | 67
PLATE | C150SD/HB(15deg) | Z/998 | 2.6 | +4.777 | +5.100 | 67
2 x PLATE | C150SD/AB | Z/1001 | 2.3 | +5.878 | +6.092 | 67
PLATE | C150SD/HB(12deg) | Z/1000 | 2.5 | +4.777 | +5.080 | 67
2 x PLATE | C150SD/AB | Z/182 | 2.2 | +5.664 | +5.866 | 67
APEX BRACE | C150SD/HB(25deg)-HB | Z/2428 | 12.1 | +6.220 | +6.372 | 64
APEX BRACE | C150SD/HB(18deg)-HB | Z/2428 | 12.1 | +5.758 | +5.910 | 64
APEX BRACE | C150SD/HB(15deg)-HB | Z/2428 | 12.1 | +5.571 | +5.723 | 64
APEX BRACE | C150SD/HB(12deg)-HB | Z/2428 | 12.1 | +5.389 | +5.541 | 64
HAUNCH BRACING PLATE | C350SD>/HB(10deg)-AB | PL/1938 | 9.3 | +3.684 | +4.344 | 128
HAUNCH BRACING PLATE | C350SD>/HB(10deg)-AB | PL/1939 | 11.7 | +4.402 | +5.270 | 128
HAUNCH BRACING PLATE | C350SD>/HB(10deg)-AB | PL/1928 | 11.7 | +4.402 | +5.270 | 128
APEX BRACING PLATE | C350SD>/HB(10deg)-AB | PL/1940 | 27.8 | +4.937 | +5.323 | 128
2 x RAFTER | C350SD>/AB-HB | Z/2419 | 56.9 | +4.719 | +5.725 | 125
2 x RAFTER | C350SD>/HB(10deg)-AB | Z/2467 | 56.9 | +4.719 | +5.725 | 125
2 x COLUMN | C350SD>/HB(10deg) | Z/2466 | 75.7 | +0.000 | +5.063 | 125
HAUNCH BRACING PLATE | C350SD>/HB(10deg)-AB | PL/1927 | 9.3 | +3.684 | +4.344 | 128
APEX BRACING PLATE | C350SD>/HB(10deg)-AB | PL/1929 | 27.8 | +4.937 | +5.323 | 128
2 x APEX BRACE | C350SD>/AB-HB | Z/2469 | 36.8 | +4.940 | +5.290 | 125
2 x HAUNCH BRACE | C350SD>/HB(10deg)-AB | Z/2468 | 13.1 | +3.941 | +4.807 | 125
PLATE | C350SD>/AB-HB | Z/2415 | 9.8 | +4.577 | +5.137 | 529.431
PLATE | C350SD>/HB(10deg)-AB | Z/2416 | 9.8 | +4.577 | +5.137 | 529.431
2 x PLATE | C350SD>/AB | Z/2417 | 10.8 | +5.299 | +5.736 | 128
APEX BRACING PLATE | C300SD-C350SD/HB(10deg)-AB | PL/1896 | 20.6 | +4.953 | +5.290 | 99
APEX BRACING PLATE | C300SD-C350SD/HB(10deg)-AB | PL/1885 | 20.6 | +4.953 | +5.290 | 99
HAUNCH BRACING PLATE | C300SD-C350SD/HB(10deg)-AB | PL/1883 | 7.2 | +3.801 | +4.391 | 99
HAUNCH BRACING PLATE | C300SD-C350SD/HB(10deg)-AB | PL/1884 | 8.8 | +4.478 | +5.246 | 99
2 x RAFTER | C300SD-C350SD/HB(10deg)-AB | Z/2456 | 48 | +4.760 | +5.722 | 96
2 x COLUMN | C300SD-C350SD/HB(10deg) | Z/2455 | 63.3 | +0.000 | +5.063 | 96
2 x RAFTER | C300SD-C350SD/AB-HB | Z/2412 | 48 | +4.760 | +5.722 | 96
2 x APEX BRACE | C300SD-C350SD/HB(10deg)-HB | Z/2458 | 36.4 | +4.956 | +5.256 | 96
2 x HAUNCH BRACE | C300SD-C350SD/HB(10deg)-AB | Z/2457 | 10.8 | +4.023 | +4.848 | 96
PLATE | C300SD-C350SD/HB(10deg)-AB | Z/2409 | 8.6 | +4.577 | +5.128 | 516.982
PLATE | C300SD-C350SD/AB-HB | Z/2408 | 8.6 | +4.577 | +5.128 | 516.981
2 x PLATE | C300SD-C350SD/AB | Z/2410 | 9.1 | +5.345 | +5.732 | 99
APEX BRACING PLATE | C250SD-C300SD/HB(10deg)-AB | PL/1792 | 14.6 | +5.042 | +5.333 | 79
HAUNCH BRACING PLATE | C250SD-C300SD/HB(10deg) | PL/1790 | 5.4 | +3.811 | +4.335 | 79
HAUNCH BRACING PLATE | C250SD-C300SD/HB(10deg)-AB | PL/1791 | 6.5 | +4.569 | +5.246 | 79
2 x RAFTER | C250SD-C300SD/HB(10deg)-AB | Z/2445 | 31.1 | +4.796 | +5.719 | 76
2 x COLUMN | C250SD-C300SD/HB(10deg) | Z/2444 | 40.6 | +0.000 | +5.063 | 76
2 x RAFTER | C250SD-C300SD/AB-HB | Z/2405 | 31.1 | +4.796 | +5.719 | 76
APEX BRACING PLATE | C250SD-C300SD/HB(10deg)-AB | PL/1781 | 14.6 | +5.042 | +5.333 | 79
2 x APEX BRACE | C250SD-C300SD/HB(10deg)-HB | Z/2447 | 18.5 | +5.045 | +5.299 | 76
HAUNCH BRACING PLATE | C250SD-C300SD/HB(10deg) | PL/1779 | 5.4 | +3.811 | +4.335 | 79
HAUNCH BRACING PLATE | C250SD-C300SD/HB(10deg)-AB | PL/1780 | 6.5 | +4.569 | +5.246 | 79
2 x HAUNCH BRACE | C250SD-C300SD/HB(10deg)-AB | Z/2446 | 6.5 | +4.000 | +4.906 | 76
PLATE | C250SD-C300SD/HB(10deg) | Z/2440 | 5.2 | +4.692 | +5.099 | 385.493
PLATE | C250SD-C300SD/HB | Z/2439 | 5.2 | +4.692 | +5.099 | 386.992
2 x PLATE | C250SD-C300SD/AB | Z/2403 | 3.9 | +5.422 | +5.727 | 79
APEX BRACING PLATE | C350SD/HB(10deg)-AB | PL/1918 | 21.8 | +4.907 | +5.293 | 99
HAUNCH BRACING PLATE | C350SD/HB(10deg)-AB | PL/1916 | 7.7 | +3.826 | +4.416 | 99
HAUNCH BRACING PLATE | C350SD/HB(10deg)-AB | PL/1917 | 9.3 | +4.422 | +5.239 | 99
2 x RAFTER | C350SD/AB-HB | Z/2419 | 56.9 | +4.719 | +5.725 | 125
2 x RAFTER | C350SD/HB(10deg)-AB | Z/2462 | 56.9 | +4.719 | +5.725 | 125
2 x COLUMN | C350SD/HB(10deg) | Z/2461 | 75.7 | +0.000 | +5.063 | 125
2 x FASCIA BRACKET | C350SD/HB(10deg) | Z/52 | 0.2 | +4.906 | +5.063 | 157.2
APEX BRACING PLATE | C350SD/HB(10deg)-AB | PL/1907 | 21.8 | +4.907 | +5.293 | 99
2 x APEX BRACE | C350SD/HB(10deg)-HB | Z/2458 | 36.4 | +4.910 | +5.210 | 96
HAUNCH BRACING PLATE | C350SD/HB(10deg)-AB | PL/1905 | 7.7 | +3.826 | +4.416 | 99
HAUNCH BRACING PLATE | C350SD/HB(10deg)-AB | PL/1906 | 9.3 | +4.422 | +5.239 | 99
2 x HAUNCH BRACE | C350SD/HB(10deg)-AB | Z/2463 | 9.3 | +4.048 | +4.792 | 96
PLATE | C350SD/AB-HB | Z/2415 | 9.8 | +4.577 | +5.137 | 529.431
PLATE | C350SD/HB(10deg)-AB | Z/2416 | 9.8 | +4.577 | +5.137 | 529.431
TH | C300SD-C350SD/AB-HB | Z/562 | 1.8 | +5.306 | +5.394 | 125
FASCIA | C300SD-C350SD/HB(10deg) | Z/561 | 3.5 | +4.909 | +5.061 | 64
2 x TH | C300SD-C350SD/HB(10deg) | Z/562 | 1.8 | +4.562 | +4.687 | 125
TH | C300SD-C350SD/HB(10deg)-AB | Z/562 | 1.8 | +5.305 | +5.392 | 125
2 x PLATE | C350SD/AB | Z/2417 | 10.8 | +5.299 | +5.736 | 128
APEX BRACING PLATE | C300SD/HB(10deg)-AB | PL/1874 | 15.6 | +4.999 | +5.336 | 79
HAUNCH BRACING PLATE | C300SD/HB(10deg) | PL/1872 | 5.6 | +3.834 | +4.358 | 79
HAUNCH BRACING PLATE | C300SD/HB(10deg)-AB | PL/1873 | 6.8 | +4.518 | +5.240 | 79
2 x RAFTER | C300SD/HB(10deg)-AB | Z/2451 | 48 | +4.760 | +5.722 | 96
2 x COLUMN | C300SD/HB(10deg) | Z/2450 | 63.3 | +0.000 | +5.063 | 96
2 x RAFTER | C300SD/AB-HB | Z/2412 | 48 | +4.760 | +5.722 | 96
2 x FASCIA BRACKET | C300SD/HB(10deg) | Z/52 | 0.2 | +4.906 | +5.063 | 157.2
APEX BRACING PLATE | C300SD/HB(10deg)-AB | PL/1803 | 15.6 | +4.999 | +5.336 | 79
2 x APEX BRACE | C300SD/HB(10deg)-HB | Z/2447 | 18.5 | +5.002 | +5.256 | 76
HAUNCH BRACING PLATE | C300SD/HB(10deg) | PL/1801 | 5.6 | +3.834 | +4.358 | 79
HAUNCH BRACING PLATE | C300SD/HB(10deg)-AB | PL/1802 | 6.8 | +4.518 | +5.240 | 79
2 x HAUNCH BRACE | C300SD/HB(10deg)-AB | Z/2452 | 5.8 | +4.023 | +4.855 | 76
PLATE | C300SD/HB(10deg)-AB | Z/2409 | 8.6 | +4.577 | +5.128 | 516.982
PLATE | C300SD/AB-HB | Z/2408 | 8.6 | +4.577 | +5.128 | 516.981
TH | C250SD-C300SD/AB-HB | Z/562 | 1.8 | +5.302 | +5.389 | 125
2 x FASCIA | C250SD-C300SD/HB(10deg) | Z/561 | 3.5 | +4.908 | +5.060 | 64
2 x TH | C250SD-C300SD/HB(10deg) | Z/562 | 1.8 | +4.562 | +4.687 | 125
TH | C250SD-C300SD/HB(10deg)-AB | Z/562 | 1.8 | +5.300 | +5.388 | 125
2 x PLATE | C300SD/AB | Z/2410 | 9.1 | +5.345 | +5.732 | 99
APEX BRACING PLATE | C250SD/HB(10deg)-AB | PL/1770 | 11.4 | +5.093 | +5.384 | 79
HAUNCH BRACING PLATE | C250SD/HB(10deg) | PL/1768 | 4.2 | +3.847 | +4.299 | 79
HAUNCH BRACING PLATE | C250SD/HB(10deg)-AB | PL/1769 | 5 | +4.613 | +5.238 | 79
2 x RAFTER | C250SD/HB(10deg)-AB | Z/2438 | 31.1 | +4.796 | +5.719 | 76
2 x COLUMN | C250SD/HB(10deg) | Z/2437 | 40.6 | +0.000 | +5.063 | 76
2 x RAFTER | C250SD/AB-HB | Z/2405 | 31.1 | +4.796 | +5.719 | 76
2 x FASCIA BRACKET | C250SD/HB(10deg) | Z/52 | 0.2 | +4.906 | +5.063 | 157.2
APEX BRACING PLATE | C250SD/HB(10deg)-AB | PL/1759 | 11.4 | +5.093 | +5.384 | 79
2 x APEX BRACE | C250SD/HB(10deg)-HB | Z/2433 | 16.3 | +5.096 | +5.299 | 76
HAUNCH BRACING PLATE | C250SD/HB(10deg) | PL/1757 | 4.2 | +3.847 | +4.299 | 79
HAUNCH BRACING PLATE | C250SD/HB(10deg)-AB | PL/1758 | 5 | +4.613 | +5.238 | 79
2 x HAUNCH BRACE | C250SD/HB(10deg)-AB | Z/2441 | 6.1 | +4.000 | +4.914 | 76
PLATE | C250SD/HB(10deg) | Z/2440 | 5.2 | +4.692 | +5.099 | 385.494
PLATE | C250SD/HB | Z/2439 | 5.2 | +4.692 | +5.099 | 386.992
TH | C200SD-C250SD/AB-HB | Z/562 | 1.8 | +5.296 | +5.384 | 125
FASCIA | C200SD-C250SD/HB(10deg) | Z/561 | 3.5 | +4.908 | +5.060 | 64
2 x TH | C200SD-C250SD/HB(10deg) | Z/562 | 1.8 | +4.562 | +4.687 | 125
TH | C200SD-C250SD/HB(10deg)-AB | Z/562 | 1.8 | +5.294 | +5.382 | 125
2 x PLATE | C250SD/AB | Z/2403 | 3.9 | +5.422 | +5.727 | 79
APEX BRACING PLATE | C200SD/HB(10deg)-AB | PL/1748 | 10.3 | +5.140 | +5.381 | 79
HAUNCH BRACING PLATE | C200SD/HB(10deg) | PL/1746 | 3.8 | +3.821 | +4.274 | 79
HAUNCH BRACING PLATE | C200SD/HB(10deg)-AB | PL/1747 | 4.7 | +4.670 | +5.245 | 79
2 x RAFTER | C200SD/HB(10deg)-AB | Z/2431 | 27.8 | +4.838 | +5.716 | 76
2 x COLUMN | C200SD/HB(10deg) | Z/2430 | 35.8 | +0.000 | +5.063 | 76
2 x RAFTER | C200SD/AB-HB | Z/2399 | 27.8 | +4.838 | +5.716 | 76
2 x FASCIA BRACKET | C200SD/HB(10deg) | Z/52 | 0.2 | +4.906 | +5.063 | 157.2
APEX BRACING PLATE | C200SD/HB(10deg)-AB | PL/1737 | 10.3 | +5.140 | +5.381 | 79
HAUNCH BRACING PLATE | C200SD/HB(10deg) | PL/1735 | 3.8 | +3.821 | +4.274 | 79
HAUNCH BRACING PLATE | C200SD/HB(10deg)-AB | PL/1736 | 4.7 | +4.670 | +5.245 | 79
2 x HAUNCH BRACE | C200SD/HB(10deg)-AB | Z/2432 | 6.8 | +3.975 | +4.971 | 76
2 x APEX BRACE | C200SD/HB(10deg)-HB | Z/2433 | 16.3 | +5.143 | +5.346 | 76
PLATE | C200SD/HB(10deg) | Z/2396 | 2.9 | +4.777 | +5.076 | 279.982
PLATE | C200SD/HB | Z/2395 | 2.9 | +4.777 | +5.076 | 279.982
TH | C150SD-C200SD/AB-HB | Z/562 | 1.8 | +5.292 | +5.380 | 125
2 x FASCIA | C150SD-C200SD/HB(10deg) | Z/561 | 3.5 | +4.909 | +5.061 | 64
2 x TH | C150SD-C200SD/HB(10deg) | Z/562 | 1.8 | +4.562 | +4.687 | 125
TH | C150SD-C200SD/HB(10deg)-AB | Z/562 | 1.8 | +5.292 | +5.380 | 125
2 x PLATE | C200SD/AB | Z/2397 | 3.5 | +5.469 | +5.723 | 79
APEX BRACING PLATE | C150SD/HB(10deg)-AB | PL/1724 | 6.7 | +5.265 | +5.456 | 67
HAUNCH BRACING PLATE | C150SD/HB(10deg)-AB | PL/1729 | 2.9 | +4.772 | +5.245 | 67
HAUNCH BRACING PLATE | C150SD/HB(10deg) | PL/1734 | 2.5 | +3.832 | +4.212 | 67
2 x RAFTER | C150SD/HB(10deg)-AB | Z/2424 | 22 | +4.879 | +5.713 | 64
2 x COLUMN | C150SD/HB(10deg) | Z/2391 | 28.2 | +0.000 | +5.063 | 64
2 x RAFTER | C150SD/AB-HB | Z/2392 | 22 | +4.879 | +5.713 | 64
2 x FASCIA BRACKET | C150SD/HB(10deg) | Z/52 | 0.2 | +4.906 | +5.063 | 157.2
APEX BRACING PLATE | C150SD/HB(10deg)-AB | PL/1719 | 6.7 | +5.265 | +5.456 | 67
HAUNCH BRACING PLATE | C150SD/HB(10deg)-AB | PL/1714 | 2.9 | +4.772 | +5.245 | 67
HAUNCH BRACING PLATE | C150SD/HB(10deg) | PL/1713 | 2.5 | +3.832 | +4.212 | 67
2 x HAUNCH BRACE | C150SD/HB(10deg)-AB | Z/2386 | 6.1 | +3.949 | +5.037 | 64
2 x APEX BRACE | C150SD/HB(10deg)-HB | Z/2387 | 12.1 | +5.268 | +5.420 | 64
PLATE | C150SD/HB(10deg) | Z/2426 | 2.5 | +4.777 | +5.067 | 271.356
PLATE | C150SD/HB | Z/2425 | 2.5 | +4.777 | +5.067 | 271.936
TH | <C150SD/AB-HB | Z/562 | 1.8 | +5.288 | +5.375 | 125
TH | <C150SD/HB(10deg)-AB | Z/562 | 1.8 | +5.288 | +5.375 | 125
FASCIA | <C150SD/HB(10deg) | Z/561 | 3.5 | +4.909 | +5.061 | 64
TH | <C150SD/HB(10deg) | Z/562 | 1.8 | +4.562 | +4.687 | 125
2 x PLATE | C150SD/AB | Z/2390 | 2.2 | +5.524 | +5.719 | 67
PLATE | C350SD>/AB-HB | Z/2416 | 9.8 | +4.577 | +5.137 | 529.431
PLATE | C350SD>/HB(10deg)-AB | Z/2415 | 9.8 | +4.577 | +5.137 | 529.431
HAUNCH BRACING PLATE | C300SD-C350SD/HB(10deg)-AB | PL/1894 | 7.2 | +3.801 | +4.391 | 99
HAUNCH BRACING PLATE | C300SD-C350SD/HB(10deg)-AB | PL/1895 | 8.8 | +4.478 | +5.246 | 99
PLATE | C300SD-C350SD/HB(10deg)-AB | Z/2408 | 8.6 | +4.577 | +5.128 | 516.982
PLATE | C300SD-C350SD/AB-HB | Z/2409 | 8.6 | +4.577 | +5.128 | 516.981
PLATE | C250SD-C300SD/HB(10deg) | Z/2401 | 5.2 | +4.692 | +5.099 | 385.493
PLATE | C250SD-C300SD/HB | Z/2402 | 5.2 | +4.692 | +5.099 | 386.992
COLUMN | C150SD/HB | Z/2429 | 28.2 | +0.000 | +5.063 | 64
COLUMN | C200SD/HB | Z/2436 | 35.8 | +0.000 | +5.063 | 76
COLUMN | C250SD/HB | Z/2443 | 40.6 | +0.000 | +5.063 | 76
COLUMN | C300SD/HB | Z/2454 | 63.3 | +0.000 | +5.063 | 96
COLUMN | C350SD/HB | Z/2465 | 75.7 | +0.000 | +5.063 | 125
PLATE | C150SD/HB(10deg) | Z/2388 | 2.5 | +4.777 | +5.067 | 271.356
PLATE | C150SD/HB | Z/2389 | 2.5 | +4.777 | +5.067 | 271.936
PLATE | C200SD/HB(10deg) | Z/2395 | 2.9 | +4.777 | +5.076 | 279.982
PLATE | C200SD/HB | Z/2396 | 2.9 | +4.777 | +5.076 | 279.982
PLATE | C250SD/HB(10deg) | Z/2401 | 5.2 | +4.692 | +5.099 | 385.494
PLATE | C250SD/HB | Z/2402 | 5.2 | +4.692 | +5.099 | 386.992
PLATE | C300SD/HB(10deg)-AB | Z/2408 | 8.6 | +4.577 | +5.128 | 516.982
PLATE | C300SD/AB-HB | Z/2409 | 8.6 | +4.577 | +5.128 | 516.981
PLATE | C350SD/AB-HB | Z/2416 | 9.8 | +4.577 | +5.137 | 529.431
PLATE | C350SD/HB(10deg)-AB | Z/2415 | 9.8 | +4.577 | +5.137 | 529.431
2 x FASCIA | C200SD-C250SD/HB | Z/561 | 3.5 | +4.909 | +5.061 | 64
TH | C350SD>/AB-HB | Z/562 | 1.8 | +5.306 | +5.394 | 125
TH | C300SD-C350SD/AB-HB | Z/562 | 1.8 | +5.302 | +5.389 | 125
TH | C250SD-C300SD/AB-HB | Z/562 | 1.8 | +5.296 | +5.384 | 125
TH | C200SD-C250SD/AB-HB | Z/562 | 1.8 | +5.292 | +5.380 | 125
TH | C150SD-C200SD/AB-HB | Z/562 | 1.8 | +5.288 | +5.375 | 125
FASCIA | C350SD>/HB(10deg) | Z/561 | 3.5 | +4.909 | +5.061 | 64
TH | C350SD>/HB(10deg) | Z/562 | 1.8 | +4.562 | +4.687 | 125
FASCIA | C300SD-C350SD/HB(10deg) | Z/561 | 3.5 | +4.908 | +5.060 | 64
FASCIA | C200SD-C250SD/HB(10deg) | Z/561 | 3.5 | +4.909 | +5.061 | 64
TH | C350SD>/HB(10deg)-AB | Z/562 | 1.8 | +5.305 | +5.392 | 125
TH | C300SD-C350SD/HB(10deg)-AB | Z/562 | 1.8 | +5.300 | +5.388 | 125
TH | C250SD-C300SD/HB(10deg)-AB | Z/562 | 1.8 | +5.294 | +5.382 | 125
TH | C200SD-C250SD/HB(10deg)-AB | Z/562 | 1.8 | +5.292 | +5.380 | 125
TH | C150SD-C200SD/HB(10deg)-AB | Z/562 | 1.8 | +5.288 | +5.375 | 125
PLATE | C200SD/HB | Z/1031 | 3.7 | +4.775 | +5.192 | 79
TH | C200SD-C250SD/AB-HB | Z/562 | 1.8 | +5.704 | +5.806 | 125
TH | C150SD-C200SD/AB-HB | Z/562 | 1.8 | +5.694 | +5.796 | 125
TH | C200SD-C250SD/AB-HB | Z/562 | 1.8 | +5.519 | +5.615 | 125
TH | C150SD-C200SD/AB-HB | Z/562 | 1.8 | +5.511 | +5.607 | 125
TH | C200SD-C250SD/AB-HB | Z/562 | 1.8 | +5.435 | +5.528 | 125
TH | C150SD-C200SD/AB-HB | Z/562 | 1.8 | +5.428 | +5.522 | 125
TH | C200SD-C250SD/AB-HB | Z/562 | 1.8 | +5.349 | +5.440 | 125
TH | C150SD-C200SD/AB-HB | Z/562 | 1.8 | +5.344 | +5.435 | 125
FASCIA | C200SD-C250SD/HB(12deg) | Z/561 | 3.5 | +4.909 | +5.061 | 64
TH | C200SD-C250SD/HB(25deg)-AB | Z/562 | 1.8 | +5.704 | +5.806 | 125
TH | C200SD-C250SD/HB(18deg)-AB | Z/562 | 1.8 | +5.519 | +5.615 | 125
TH | C200SD-C250SD/HB(15deg)-AB | Z/562 | 1.8 | +5.435 | +5.528 | 125
TH | C200SD-C250SD/HB(12deg)-AB | Z/562 | 1.8 | +5.349 | +5.440 | 125
TH | C150SD-C200SD/HB(25deg)-AB | Z/562 | 1.8 | +5.694 | +5.796 | 125
TH | C150SD-C200SD/HB(18deg)-AB | Z/562 | 1.8 | +5.511 | +5.607 | 125
TH | C150SD-C200SD/HB(15deg)-AB | Z/562 | 1.8 | +5.428 | +5.522 | 125
TH | C150SD-C200SD/HB(12deg)-AB | Z/562 | 1.8 | +5.344 | +5.435 | 125
PLATE | C350SD/AB-HB | Z/1116 | 11.7 | +4.577 | +5.345 | 128
PLATE | C300SD/AB-HB | Z/1089 | 10.1 | +4.578 | +5.322 | 99
PLATE | C250SD/AB-HB | Z/1059 | 6.1 | +4.692 | +5.252 | 79
PLATE | C150SD/HB | Z/994 | 2.9 | +4.777 | +5.168 | 67
PLATE | C350SD/AB-HB | Z/1118 | 10.8 | +4.577 | +5.247 | 128
PLATE | C300SD/AB-HB | Z/1091 | 9.3 | +4.577 | +5.231 | 99
PLATE | C250SD/AB-HB | Z/1061 | 5.6 | +4.692 | +5.180 | 79
PLATE | C200SD/HB | Z/1035 | 3.3 | +4.777 | +5.137 | 79
PLATE | C150SD/HB | Z/996 | 2.7 | +4.777 | +5.120 | 67
PLATE | C350SD/AB-HB | Z/1120 | 10.5 | +4.577 | +5.205 | 128
PLATE | C300SD/AB-HB | Z/1093 | 9.1 | +4.577 | +5.192 | 99
PLATE | C250SD/AB-HB | Z/1063 | 5.4 | +4.692 | +5.149 | 79
PLATE | C200SD/HB | Z/1033 | 3.2 | +4.777 | +5.114 | 79
PLATE | C150SD/HB | Z/998 | 2.6 | +4.777 | +5.100 | 67
PLATE | C350SD/AB-HB | Z/666 | 10.1 | +4.577 | +5.164 | 128
PLATE | C300SD/AB-HB | Z/1542 | 8.8 | +4.577 | +5.153 | 99
PLATE | C250SD/HB | Z/1287 | 5.2 | +4.692 | +5.119 | 79
PLATE | C200SD/HB | Z/548 | 3.1 | +4.777 | +5.091 | 79
PLATE | C150SD/HB | Z/1000 | 2.5 | +4.777 | +5.080 | 67
PLATE | C350SD/HB(25deg)-AB | Z/1115 | 11.7 | +4.577 | +5.345 | 128
PLATE | C300SD/HB(25deg)-AB | Z/1088 | 10.1 | +4.578 | +5.322 | 99
PLATE | C250SD/HB(25deg)-AB | Z/1058 | 6.1 | +4.692 | +5.252 | 79
PLATE | C200SD/HB(25deg) | Z/1030 | 3.7 | +4.775 | +5.192 | 79
PLATE | C150SD/HB(25deg) | Z/993 | 2.9 | +4.777 | +5.168 | 67
PLATE | C350SD/HB(18deg)-AB | Z/1117 | 10.8 | +4.577 | +5.247 | 128
PLATE | C300SD/HB(18deg)-AB | Z/1090 | 9.3 | +4.577 | +5.231 | 99
PLATE | C250SD/HB(18deg)-AB | Z/1060 | 5.6 | +4.692 | +5.180 | 79
PLATE | C200SD/HB(18deg) | Z/1034 | 3.3 | +4.777 | +5.137 | 79
PLATE | C150SD/HB(18deg) | Z/995 | 2.7 | +4.777 | +5.120 | 67
PLATE | C350SD/HB(15deg)-AB | Z/1119 | 10.5 | +4.577 | +5.205 | 128
PLATE | C300SD/HB(15deg)-AB | Z/1092 | 9.1 | +4.577 | +5.192 | 99
PLATE | C250SD/HB(15deg)-AB | Z/1062 | 5.4 | +4.692 | +5.149 | 79
PLATE | C200SD/HB(15deg) | Z/1032 | 3.2 | +4.777 | +5.114 | 79
PLATE | C150SD/HB(15deg) | Z/997 | 2.6 | +4.777 | +5.100 | 67
PLATE | C350SD/HB(12deg)-AB | Z/1432 | 10.1 | +4.577 | +5.164 | 128
PLATE | C300SD/HB(12deg)-AB | Z/1543 | 8.8 | +4.577 | +5.153 | 99
PLATE | C250SD/HB(12deg) | Z/1289 | 5.2 | +4.692 | +5.119 | 79
PLATE | C200SD/HB(12deg) | Z/227 | 3.1 | +4.777 | +5.091 | 79
PLATE | C150SD/HB(12deg) | Z/220 | 2.5 | +4.777 | +5.080 | 67

# IfcMechanicalFastener: Bolt assembly (1100)
In: Undefined
Tekla Bolt - Location: Site
Name | NominalDiameter (mm) = Washer diameter (mm) = Bolt size (mm) | NominalLength (mm) = Bolt length (mm) | Material = Bolt standard | Washer count | Washer type | Washer name | Nut count = Bolt count | Nut type | Nut name | Slotted hole y (mm) | Slotted hole x (mm) | Bolt hole diameter (mm) | Bolt Name
17 x Bolt assembly | 12 | 30 | 8.8S | 6 | HARD | WASHERM12-HARD | 6 | 8.8-HEX | NUTM12-8.8-HEX | 0 | 0 | 18 | BOLTM12*30
96 x Bolt assembly | 5 | 11.6 | TEK_16TPIM | 4 | UNDEF_WASH | UNDEFINED_WASHERM5 | 2 | UNDEF_NUT | UNDEFINED_NUTM5 | 0 | 0 | 7 | TEKSCREW_M5*25
48 x Bolt assembly | 5 | 11.6 | TEK_16TPIM | 8 | UNDEF_WASH | UNDEFINED_WASHERM5 | 4 | UNDEF_NUT | UNDEFINED_NUTM5 | 0 | 0 | 7 | TEKSCREW_M5*25
80 x Bolt assembly | 16 | 40 | 8.8S | 6 | HARD | WASHERM16-HARD | 6 | 8.8-HEX | NUTM16-8.8-HEX | 0 | 4 | 18 | BOLTM16*40
160 x Bolt assembly | 16 | 40 | 8.8S | 6 | HARD | WASHERM16-HARD | 6 | 8.8-HEX | NUTM16-8.8-HEX | 4 | 0 | 18 | BOLTM16*40
60 x Bolt assembly | 12 | 40 | 8.8S | 6 | HARD | WASHERM12-HARD | 6 | 8.8-HEX | NUTM12-8.8-HEX | 0 | 0 | 18 | BOLTM12*40
200 x Bolt assembly | 5 | 25 | TEK_16TPIM | 8 | UNDEF_WASH | UNDEFINED_WASHERM5 | 2 | UNDEF_NUT | UNDEFINED_NUTM5 | 0 | 0 | 7 | TEKSCREW_M5*25
100 x Bolt assembly | 5 | 25 | TEK_16TPIM | 16 | UNDEF_WASH | UNDEFINED_WASHERM5 | 4 | UNDEF_NUT | UNDEFINED_NUTM5 | 0 | 0 | 7 | TEKSCREW_M5*25
99 x Bolt assembly | 12 | 35 | 8.8S | 6 | HARD | WASHERM12-HARD | 6 | 8.8-HEX | NUTM12-8.8-HEX | 0 | 0 | 18 | BOLTM12*35
40 x Bolt assembly | 16 | 35 | 8.8S | 4 | HARD | WASHERM16-HARD | 4 | 8.8-HEX | NUTM16-8.8-HEX | 0 | 4 | 18 | BOLTM16*35
80 x Bolt assembly | 16 | 35 | 8.8S | 4 | HARD | WASHERM16-HARD | 4 | 8.8-HEX | NUTM16-8.8-HEX | 4 | 0 | 18 | BOLTM16*35
40 x Bolt assembly | 12 | 30 | 8.8S | 4 | HARD | WASHERM12-HARD | 4 | 8.8-HEX | NUTM12-8.8-HEX | 4 | 8 | 14 | BOLTM12*30
80 x Bolt assembly | 12 | 30 | 8.8S | 4 | HARD | WASHERM12-HARD | 4 | 8.8-HEX | NUTM12-8.8-HEX | 8 | 4 | 14 | BOLTM12*30

# IfcMember: C:150-19 (10)
In: Undefined
Description: C:150-19; Material: STEEL/G450
Tekla Common - Phase: 1; Class: 5
Tekla Quantity - Weight: 6.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 139.7 m2; Net surface area: 0.8 m2; Height: 152 mm; Width: 64 mm; Length: 1386 mm
Pset_MemberCommon - LoadBearing: no
BaseQuantities - Length: 1386.01 mm; OuterSurfaceArea: 0.853003 m2; GrossSurfaceArea: 0 m2; CrossSectionArea: 0.000561 m2; NetVolume: 0.000804247 m3; GrossVolume: 0.000777553 m3; NetWeight: 6.31334 kg; GrossWeight: 6.10379 kg
Name | Bottom elevation | Top elevation | Reference
2 x HAUNCH BRACE | +4.266 | +5.354 | Z/2427
2 x HAUNCH BRACE | +4.113 | +5.200 | Z/2427
2 x HAUNCH BRACE | +4.050 | +5.138 | Z/2427
2 x HAUNCH BRACE | +3.989 | +5.077 | Z/2427
2 x HAUNCH BRACE | +3.949 | +5.037 | Z/2386

# IfcMember: C:150-24 (4)
In: Undefined
Description: C:150-24; Material: STEEL/G450
Tekla Common - Finish: 25 deg; Bottom elevation: +4.937; Top elevation: +6.868; Phase: 1; Class: 1
Tekla Quantity - Weight: 23.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 111.2 m2; Net surface area: 2.6 m2; Height: 152 mm; Width: 64 mm; Length: 4242.2 mm
Pset_MemberCommon - LoadBearing: no
BaseQuantities - Length: 4242.22 mm; OuterSurfaceArea: 2.62996 m2; GrossSurfaceArea: 0 m2; CrossSectionArea: 0.00071 m2; NetVolume: 0.00312974 m3; GrossVolume: 0.00301198 m3; NetWeight: 24.5685 kg; GrossWeight: 23.644 kg
Name | Reference
2 x RAFTER | Z/93
2 x RAFTER | Z/2407

# IfcMember: C:200-19 (20)
In: Undefined
Description: C:200-19; Material: STEEL/G450
Tekla Common - Phase: 1; Class: 5
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 138.5 m2; Net surface area: 0.8 m2; Height: 203 mm; Width: 76 mm
Pset_MemberCommon - LoadBearing: no
BaseQuantities - GrossSurfaceArea: 0 m2; CrossSectionArea: 0.000713 m2
Name | Bottom elevation | Top elevation | Weight (kg) | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | GrossVolume (m3) | NetWeight (kg) | GrossWeight (kg)
2 x HAUNCH BRACE | +4.277 | +5.191 | 6.1 | 1089.2 | Z/2491 | 1089.23 | 0.845183 | 0.000797601 | 0.000776622 | 6.26117 | 6.09648
2 x HAUNCH BRACE | +4.144 | +5.058 | 6.1 | 1089.2 | Z/2491 | 1089.23 | 0.845183 | 0.000797601 | 0.000776622 | 6.26117 | 6.09648
2 x HAUNCH BRACE | +4.090 | +5.003 | 6.1 | 1089.2 | Z/2491 | 1089.23 | 0.845183 | 0.000797601 | 0.000776622 | 6.26117 | 6.09648
2 x HAUNCH BRACE | +4.036 | +4.950 | 6.1 | 1089.2 | Z/2491 | 1089.23 | 0.845183 | 0.000797601 | 0.000776622 | 6.26117 | 6.09648
2 x HAUNCH BRACE | +4.265 | +5.262 | 6.8 | 1206.7 | Z/2486 | 1206.66 | 0.936141 | 0.000883587 | 0.000860346 | 6.93615 | 6.75372
2 x HAUNCH BRACE | +4.125 | +5.122 | 6.8 | 1206.7 | Z/2486 | 1206.66 | 0.936141 | 0.000883587 | 0.000860346 | 6.93615 | 6.75372
2 x HAUNCH BRACE | +4.068 | +5.065 | 6.8 | 1206.7 | Z/2486 | 1206.66 | 0.936141 | 0.000883587 | 0.000860346 | 6.93615 | 6.75372
2 x HAUNCH BRACE | +4.012 | +5.009 | 6.8 | 1206.7 | Z/2486 | 1206.66 | 0.936141 | 0.000883587 | 0.000860346 | 6.93615 | 6.75372
2 x HAUNCH BRACE | +4.000 | +4.914 | 6.1 | 1089.2 | Z/2441 | 1089.23 | 0.845183 | 0.000797601 | 0.000776622 | 6.26117 | 6.09648
2 x HAUNCH BRACE | +3.975 | +4.971 | 6.8 | 1206.7 | Z/2432 | 1206.66 | 0.936141 | 0.000883587 | 0.000860346 | 6.93615 | 6.75372

# IfcMember: C:200-24 (4)
In: Undefined
Description: C:200-24; Material: STEEL/G450
Tekla Common - Finish: 25 deg; Bottom elevation: +4.915; Top elevation: +6.870; Phase: 1; Class: 1
Tekla Quantity - Weight: 29.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 110 m2; Net surface area: 3.3 m2; Height: 203 mm; Width: 76 mm; Length: 4190.3 mm
Pset_MemberCommon - LoadBearing: no
BaseQuantities - Length: 4190.31 mm; OuterSurfaceArea: 3.26862 m2; GrossSurfaceArea: 0 m2; CrossSectionArea: 0.000903 m2; NetVolume: 0.00389598 m3; GrossVolume: 0.00378385 m3; NetWeight: 30.5835 kg; GrossWeight: 29.7032 kg
Name | Reference
2 x RAFTER | Z/5
2 x RAFTER | Z/2485

# IfcMember: C:250-19 (20)
In: Undefined
Description: C:250-19; Material: STEEL/G450
Tekla Common - Phase: 1; Class: 5
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.8 m2; Height: 254 mm; Width: 76 mm
Pset_MemberCommon - LoadBearing: no
BaseQuantities - GrossSurfaceArea: 0 m2; CrossSectionArea: 0.000808 m2
Name | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | GrossVolume (m3) | NetWeight (kg) | GrossWeight (kg)
2 x HAUNCH BRACE | +4.056 | +4.888 | 5.8 | 138.2 | 922.2 | Z/2501 | 922.217 | 0.808226 | 0.000762914 | 0.000745152 | 5.98887 | 5.84944
2 x HAUNCH BRACE | +4.105 | +4.937 | 5.8 | 138.2 | 922.2 | Z/2501 | 922.217 | 0.808226 | 0.000762914 | 0.000745152 | 5.98887 | 5.84944
2 x HAUNCH BRACE | +4.155 | +4.987 | 5.8 | 138.2 | 922.2 | Z/2501 | 922.217 | 0.808226 | 0.000762914 | 0.000745152 | 5.98887 | 5.84944
2 x HAUNCH BRACE | +4.275 | +5.107 | 5.8 | 138.2 | 922.2 | Z/2501 | 922.217 | 0.808226 | 0.000762914 | 0.000745152 | 5.98887 | 5.84944
2 x HAUNCH BRACE | +4.034 | +4.940 | 6.5 | 138 | 1027.3 | Z/2496 | 1027.32 | 0.900146 | 0.000849859 | 0.000830072 | 6.67139 | 6.51607
2 x HAUNCH BRACE | +4.086 | +4.992 | 6.5 | 138 | 1027.3 | Z/2496 | 1027.32 | 0.900146 | 0.000849859 | 0.000830072 | 6.67139 | 6.51607
2 x HAUNCH BRACE | +4.138 | +5.044 | 6.5 | 138 | 1027.3 | Z/2496 | 1027.32 | 0.900146 | 0.000849859 | 0.000830072 | 6.67139 | 6.51607
2 x HAUNCH BRACE | +4.264 | +5.170 | 6.5 | 138 | 1027.3 | Z/2496 | 1027.32 | 0.900146 | 0.000849859 | 0.000830072 | 6.67139 | 6.51607
2 x HAUNCH BRACE | +4.000 | +4.906 | 6.5 | 138 | 1027.3 | Z/2446 | 1027.32 | 0.900146 | 0.000849859 | 0.000830072 | 6.67139 | 6.51607
2 x HAUNCH BRACE | +4.023 | +4.855 | 5.8 | 138.2 | 922.2 | Z/2452 | 922.217 | 0.808226 | 0.000762914 | 0.000745152 | 5.98887 | 5.84944

# IfcMember: C:250-24 (8)
In: Undefined
Description: C:250-24; Material: STEEL/G450
Tekla Common - Finish: 25 deg; Bottom elevation: +4.892; Top elevation: +6.872; Phase: 1; Class: 1
Tekla Quantity - Weight: 33.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 109.7 m2; Net surface area: 3.6 m2; Height: 254 mm; Width: 76 mm; Length: 4138.4 mm
Pset_MemberCommon - LoadBearing: no
BaseQuantities - Length: 4138.39 mm; OuterSurfaceArea: 3.64222 m2; GrossSurfaceArea: 0 m2; CrossSectionArea: 0.001022 m2; NetVolume: 0.00434431 m3; GrossVolume: 0.00422943 m3; NetWeight: 34.1029 kg; GrossWeight: 33.201 kg
Name | Reference
4 x RAFTER | Z/132
2 x RAFTER | Z/2495
2 x RAFTER | Z/2490

# IfcMember: C:300-30 (28)
In: Undefined
Description: C:300-30; Material: STEEL/G450
Tekla Common - Phase: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 300 mm; Width: 96 mm
Pset_MemberCommon - LoadBearing: no
BaseQuantities - GrossSurfaceArea: 0 m2; CrossSectionArea: 0.001593 m2
Name | Bottom elevation | Top elevation | Class | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | GrossVolume (m3) | NetWeight (kg) | GrossWeight (kg)
2 x HAUNCH BRACE | +3.920 | +4.864 | 5 | 12.9 | 87.6 | 1.1 | 1034.2 | Z/2511 | 1034.25 | 1.13266 | 0.00168479 | 0.00164756 | 13.2256 | 12.9333
2 x HAUNCH BRACE | +4.049 | +4.893 | 5 | 11.1 | 87.6 | 1 | 892.8 | Z/2512 | 892.828 | 0.978226 | 0.00145442 | 0.00142227 | 11.4172 | 11.1649
2 x HAUNCH BRACE | +4.033 | +4.976 | 5 | 12.9 | 87.6 | 1.1 | 1034.2 | Z/2511 | 1034.25 | 1.13266 | 0.00168479 | 0.00164756 | 13.2256 | 12.9333
2 x HAUNCH BRACE | +4.168 | +5.112 | 5 | 12.9 | 87.6 | 1.1 | 1034.2 | Z/2511 | 1034.25 | 1.13266 | 0.00168479 | 0.00164756 | 13.2256 | 12.9333
2 x HAUNCH BRACE | +4.054 | +4.879 | 5 | 10.8 | 87.6 | 0.8 | 866.4 | Z/2506 | 866.367 | 0.949331 | 0.00141131 | 0.00138012 | 11.0788 | 10.834
2 x HAUNCH BRACE | +4.102 | +4.926 | 5 | 10.8 | 87.6 | 0.8 | 866.4 | Z/2506 | 866.367 | 0.949331 | 0.00141131 | 0.00138012 | 11.0788 | 10.834
2 x HAUNCH BRACE | +4.149 | +4.974 | 5 | 10.8 | 87.6 | 0.8 | 866.4 | Z/2506 | 866.367 | 0.949331 | 0.00141131 | 0.00138012 | 11.0788 | 10.834
2 x HAUNCH BRACE | +4.263 | +5.088 | 5 | 10.8 | 87.6 | 0.8 | 866.4 | Z/2506 | 866.367 | 0.949331 | 0.00141131 | 0.00138012 | 11.0788 | 10.834
4 x RAFTER | +4.873 | +6.874 | 1 | 51.2 | 87.4 | 4.5 | 4091.6 | Z/151 | 4091.56 | 4.47124 | 0.00666515 | 0.00651785 | 52.3214 | 51.1651 | Tekla Common - Finish: 25 deg
2 x RAFTER | +4.873 | +6.874 | 1 | 51.2 | 87.4 | 4.5 | 4091.6 | Z/2505 | 4091.56 | 4.47124 | 0.00666515 | 0.00651785 | 52.3214 | 51.1651 | Tekla Common - Finish: 25 deg
2 x RAFTER | +4.873 | +6.874 | 1 | 51.2 | 87.4 | 4.5 | 4091.6 | Z/2500 | 4091.56 | 4.47124 | 0.00666515 | 0.00651785 | 52.3214 | 51.1651 | Tekla Common - Finish: 25 deg
2 x HAUNCH BRACE | +4.023 | +4.848 | 5 | 10.8 | 87.6 | 0.8 | 866.4 | Z/2457 | 866.367 | 0.949331 | 0.00141131 | 0.00138012 | 11.0788 | 10.834
2 x HAUNCH BRACE | +4.048 | +4.792 | 5 | 9.3 | 87.6 | 0.8 | 751.4 | Z/2463 | 751.406 | 0.823794 | 0.00122404 | 0.00119699 | 9.60872 | 9.39637

# IfcMember: C:350-30 (18)
In: Undefined
Description: C:350-30; Material: STEEL/G450
Tekla Common - Phase: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 350 mm; Width: 125 mm
Pset_MemberCommon - LoadBearing: no
BaseQuantities - GrossSurfaceArea: 0 m2; CrossSectionArea: 0.001905 m2
Name | Bottom elevation | Top elevation | Class | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | GrossVolume (m3) | NetWeight (kg) | GrossWeight (kg)
2 x HAUNCH BRACE | +3.974 | +4.840 | 5 | 13.1 | 87.4 | 1.1 | 874.6 | Z/2513 | 874.596 | 1.14261 | 0.00170022 | 0.00166611 | 13.3467 | 13.0789
2 x HAUNCH BRACE | +4.024 | +4.889 | 5 | 13.1 | 87.4 | 1.1 | 874.6 | Z/2513 | 874.596 | 1.14261 | 0.00170022 | 0.00166611 | 13.3467 | 13.0789
2 x HAUNCH BRACE | +4.073 | +4.939 | 5 | 13.1 | 87.4 | 1.1 | 874.6 | Z/2513 | 874.596 | 1.14261 | 0.00170022 | 0.00166611 | 13.3467 | 13.0789
2 x HAUNCH BRACE | +4.113 | +5.129 | 5 | 16.3 | 87.4 | 1.4 | 1086.7 | Z/2515 | 1086.74 | 1.41882 | 0.00211262 | 0.00207023 | 16.584 | 16.2513
6 x RAFTER | +4.851 | +6.876 | 1 | 60.4 | 87.2 | 5.3 | 4040.7 | Z/171 | 4040.66 | 5.26483 | 0.00785504 | 0.00769746 | 61.6621 | 60.425 | Tekla Common - Finish: 25 deg
2 x RAFTER | +4.851 | +6.876 | 1 | 60.4 | 87.2 | 5.3 | 4040.7 | Z/2510 | 4040.66 | 5.26483 | 0.00785504 | 0.00769746 | 61.6621 | 60.425 | Tekla Common - Finish: 25 deg
2 x HAUNCH BRACE | +3.941 | +4.807 | 5 | 13.1 | 87.4 | 1.1 | 874.6 | Z/2468 | 874.596 | 1.14261 | 0.00170022 | 0.00166611 | 13.3467 | 13.0789

# IfcPlate: PLT3*267.6 (2)
In: Undefined
Description: PLT3*267.6; Material: STEEL/450
Tekla Common - Bottom elevation: +5.265; Top elevation: +5.456; Phase: 1; Class: 11
Tekla Quantity - Weight: 6.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.6 m2; Height: 267.6 mm; Width: 3 mm; Length: 1166 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 267.606 mm; NetArea: 0.566627 m2; GrossArea: 0.312033 m2; CrossSectionArea: 0.000009 m2; GrossVolume: 0.000850799 m3
Name | ASSEMBLY_POS = Reference | NetVolume (m3)
APEX BRACING PLATE | PL/1719 | 0.000835448
APEX BRACING PLATE | PL/1724 | 0.000835449

# IfcPlate: PLT3*274.1 (2)
In: Undefined
Description: PLT3*274.1; Material: STEEL/450
Tekla Common - Bottom elevation: +5.386; Top elevation: +5.584; Phase: 1; Class: 11
Tekla Quantity - Weight: 5.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.5 m2; Height: 274.1 mm; Width: 3 mm; Length: 1014.8 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 274.131 mm; NetArea: 0.493391 m2; GrossArea: 0.278189 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000727249 m3; GrossVolume: 0.0007426 m3
Name | ASSEMBLY_POS = Reference
APEX BRACING PLATE | PL/1720
APEX BRACING PLATE | PL/1725

# IfcPlate: PLT3*283.3 (2)
In: Undefined
Description: PLT3*283.3; Material: STEEL/450
Default - ASSEMBLY_POS: Z/2390
Tekla Common - Bottom elevation: +5.524; Top elevation: +5.719; Phase: 1; Class: 1
Tekla Quantity - Weight: 2.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.6 m2; Net surface area: 0.2 m2; Height: 283.3 mm; Width: 3 mm; Length: 422.1 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/2390
BaseQuantities - Width: 283.291 mm; NetArea: 0.187944 m2; GrossArea: 0.119564 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000276113 m3; GrossVolume: 0.000276113 m3

# IfcPlate: PLT3*283.5 (2)
In: Undefined
Description: PLT3*283.5; Material: STEEL/450
Tekla Common - Bottom elevation: +5.568; Top elevation: +5.775; Phase: 1; Class: 11
Tekla Quantity - Weight: 4.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.5 m2; Net surface area: 0.3 m2; Height: 283.5 mm; Width: 3 mm; Length: 865.2 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 283.474 mm; NetArea: 0.419942 m2; GrossArea: 0.245274 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000618758 m3; GrossVolume: 0.000634109 m3
Name | ASSEMBLY_POS = Reference
APEX BRACING PLATE | PL/1721
APEX BRACING PLATE | PL/1726

# IfcPlate: PLT3*292.3 (2)
In: Undefined
Description: PLT3*292.3; Material: STEEL/450
Tekla Common - Bottom elevation: +5.755; Top elevation: +5.971; Phase: 1; Class: 11
Tekla Quantity - Weight: 4.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.5 m2; Net surface area: 0.3 m2; Height: 292.3 mm; Width: 3 mm; Length: 767.1 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 292.257 mm; NetArea: 0.370743 m2; GrossArea: 0.224201 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000546067 m3; GrossVolume: 0.000561418 m3
Name | ASSEMBLY_POS = Reference
APEX BRACING PLATE | PL/1722
APEX BRACING PLATE | PL/1727

# IfcPlate: PLT3*294.7 (2)
In: Undefined
Description: PLT3*294.7; Material: STEEL/450
Default - ASSEMBLY_POS: Z/182
Tekla Common - Bottom elevation: +5.664; Top elevation: +5.866; Phase: 1; Class: 1
Tekla Quantity - Weight: 2.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.6 m2; Net surface area: 0.2 m2; Height: 294.7 mm; Width: 3 mm; Length: 429.3 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/182
BaseQuantities - Width: 294.722 mm; NetArea: 0.191471 m2; GrossArea: 0.126531 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000281369 m3; GrossVolume: 0.000281369 m3

# IfcPlate: PLT3*308.7 (4)
In: Undefined
Description: PLT3*308.7; Material: STEEL/450
Tekla Common - Bottom elevation: +4.777; Top elevation: +5.080; Phase: 1; Class: 1
Tekla Quantity - Weight: 2.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.6 m2; Net surface area: 0.2 m2; Height: 308.7 mm; Width: 3 mm; Length: 451.2 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - NetArea: 0.216526 m2; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Width (mm) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
2 x PLATE | Z/220 | 308.662 | 0.139258 | 0.000318536
2 x PLATE | Z/1000 | 308.673 | 0.139264 | 0.000318537

# IfcPlate: PLT3*310.4 (2)
In: Undefined
Description: PLT3*310.4; Material: STEEL/450
Tekla Common - Bottom elevation: +6.217; Top elevation: +6.451; Phase: 1; Class: 11
Tekla Quantity - Weight: 3.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.6 m2; Net surface area: 0.3 m2; Height: 310.4 mm; Width: 3 mm; Length: 633.9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 310.448 mm; NetArea: 0.301336 m2; GrossArea: 0.196783 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000443452 m3; GrossVolume: 0.000458803 m3
Name | ASSEMBLY_POS = Reference
APEX BRACING PLATE | PL/1723
APEX BRACING PLATE | PL/1728

# IfcPlate: PLT3*311 (2)
In: Undefined
Description: PLT3*311; Material: STEEL/450
Default - ASSEMBLY_POS: Z/1001
Tekla Common - Bottom elevation: +5.878; Top elevation: +6.092; Phase: 1; Class: 1
Tekla Quantity - Weight: 2.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.6 m2; Net surface area: 0.2 m2; Height: 311 mm; Width: 3 mm; Length: 438.1 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/1001
BaseQuantities - Width: 310.983 mm; NetArea: 0.196562 m2; GrossArea: 0.136236 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000288955 m3; GrossVolume: 0.000288955 m3

# IfcPlate: PLT3*314 (4)
In: Undefined
Description: PLT3*314; Material: STEEL/450
Tekla Common - Bottom elevation: +4.777; Top elevation: +5.100; Phase: 1; Class: 1
Tekla Quantity - Weight: 2.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.6 m2; Net surface area: 0.2 m2; Height: 314 mm; Width: 3 mm; Length: 464.4 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - NetArea: 0.223703 m2; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Width (mm) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
2 x PLATE | Z/997 | 314.009 | 0.145832 | 0.000329208
2 x PLATE | Z/998 | 314.03 | 0.145845 | 0.000329214

# IfcPlate: PLT3*318.7 (4)
In: Undefined
Description: PLT3*318.7; Material: STEEL/450
Tekla Common - Bottom elevation: +4.777; Top elevation: +5.120; Phase: 1; Class: 1
Tekla Quantity - Weight: 2.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.5 m2; Net surface area: 0.2 m2; Height: 318.7 mm; Width: 3 mm; Length: 477.9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - NetArea: 0.230962 m2; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Width (mm) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
2 x PLATE | Z/995 | 318.695 | 0.152296 | 0.000339996
2 x PLATE | Z/996 | 318.742 | 0.152323 | 0.000340008

# IfcPlate: PLT3*326 (2)
In: Undefined
Description: PLT3*326; Material: STEEL/450
Default - ASSEMBLY_POS: Z/1002
Tekla Common - Bottom elevation: +6.099; Top elevation: +6.324; Phase: 1; Class: 1
Tekla Quantity - Weight: 2.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.6 m2; Net surface area: 0.2 m2; Height: 326 mm; Width: 3 mm; Length: 444.2 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/1002
BaseQuantities - Width: 326.046 mm; NetArea: 0.201426 m2; GrossArea: 0.144845 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000296202 m3; GrossVolume: 0.000296202 m3

# IfcPlate: PLT3*327 (2)
In: Undefined
Description: PLT3*327; Material: STEEL/450
Default - ASSEMBLY_POS: Z/993
Tekla Common - Bottom elevation: +4.777; Top elevation: +5.168; Phase: 1; Class: 1
Tekla Quantity - Weight: 2.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.5 m2; Net surface area: 0.2 m2; Height: 327 mm; Width: 3.1 mm; Length: 510.2 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/993
BaseQuantities - Width: 327.001 mm; NetArea: 0.248283 m2; GrossArea: 0.166851 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000365726 m3; GrossVolume: 0.000365726 m3

# IfcPlate: PLT3*327.1 (2)
In: Undefined
Description: PLT3*327.1; Material: STEEL/450
Tekla Common - Bottom elevation: +4.777; Top elevation: +5.168; Phase: 1; Class: 1
Default - ASSEMBLY_POS: Z/994
Tekla Quantity - Weight: 2.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.5 m2; Net surface area: 0.2 m2; Height: 327.1 mm; Width: 3.1 mm; Length: 510.2 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/994
BaseQuantities - Width: 327.13 mm; NetArea: 0.248286 m2; GrossArea: 0.166929 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000365749 m3; GrossVolume: 0.000365749 m3

# IfcPlate: PLT3*329.8 (2)
In: Undefined
Description: PLT3*329.8; Material: STEEL/450
Tekla Common - Bottom elevation: +5.140; Top elevation: +5.381; Phase: 1; Class: 11
Tekla Quantity - Weight: 10.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.1 m2; Net surface area: 0.8 m2; Height: 329.8 mm; Width: 3 mm; Length: 1464.1 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 329.835 mm; GrossArea: 0.48291 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.0013279 m3; GrossVolume: 0.00134325 m3
Name | ASSEMBLY_POS = Reference | NetArea (m2)
APEX BRACING PLATE | PL/1737 | 0.897496
APEX BRACING PLATE | PL/1748 | 0.897495

# IfcPlate: PLT3*332.2 (2)
In: Undefined
Description: PLT3*332.2; Material: STEEL/450
Tekla Common - Bottom elevation: +4.777; Top elevation: +5.067; Phase: 1; Class: 1
Tekla Quantity - Weight: 2.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.6 m2; Net surface area: 0.2 m2; Height: 332.2 mm; Width: 3 mm; Length: 469.9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 332.153 mm; NetArea: 0.212394 m2; GrossArea: 0.156074 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000312391 m3; GrossVolume: 0.000312391 m3
Name | ASSEMBLY_POS = Reference
PLATE | Z/2426
PLATE | Z/2388

# IfcPlate: PLT3*332.7 (2)
In: Undefined
Description: PLT3*332.7; Material: STEEL/450
Tekla Common - Bottom elevation: +4.777; Top elevation: +5.067; Phase: 1; Class: 1
Tekla Quantity - Weight: 2.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.6 m2; Net surface area: 0.2 m2; Height: 332.7 mm; Width: 3 mm; Length: 471.1 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 332.726 mm; GrossArea: 0.156745 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000310685 m3; GrossVolume: 0.000310685 m3
Name | ASSEMBLY_POS = Reference | NetArea (m2)
PLATE | Z/2425 | 0.211248
PLATE | Z/2389 | 0.211247

# IfcPlate: PLT3*333.3 (4)
In: Undefined
Description: PLT3*333.3; Material: STEEL/450
Tekla Common - Bottom elevation: +4.777; Top elevation: +5.091; Phase: 1; Class: 1
Tekla Quantity - Weight: 3.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.3 m2; Height: 333.3 mm; Width: 3 mm; Length: 496.9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - NetArea: 0.266193 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000392276 m3; GrossVolume: 0.000392276 m3
Name | ASSEMBLY_POS = Reference | Width (mm) | GrossArea (m2)
2 x PLATE | Z/227 | 333.291 | 0.165615
2 x PLATE | Z/548 | 333.309 | 0.165626

# IfcPlate: PLT3*336 (2)
In: Undefined
Description: PLT3*336; Material: STEEL/450
Tekla Common - Bottom elevation: +5.254; Top elevation: +5.502; Phase: 1; Class: 11
Tekla Quantity - Weight: 9.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.1 m2; Net surface area: 0.8 m2; Height: 336 mm; Width: 3 mm; Length: 1265.3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 336.02 mm; NetArea: 0.775185 m2; GrossArea: 0.42518 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00114666 m3; GrossVolume: 0.00116202 m3
Name | ASSEMBLY_POS = Reference
APEX BRACING PLATE | PL/1739
APEX BRACING PLATE | PL/1750

# IfcPlate: PLT3*339.2 (2)
In: Undefined
Description: PLT3*339.2; Material: STEEL/450
Tekla Common - Bottom elevation: +3.832; Top elevation: +4.212; Phase: 1; Class: 11
Tekla Quantity - Weight: 2.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.8 m2; Net surface area: 0.2 m2; Height: 339.2 mm; Width: 3 mm; Length: 493.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 339.193 mm; NetArea: 0.216977 m2; GrossArea: 0.167434 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000318415 m3; GrossVolume: 0.000333767 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1713
HAUNCH BRACING PLATE | PL/1734

# IfcPlate: PLT3*340.9 (2)
In: Undefined
Description: PLT3*340.9; Material: STEEL/450
Default - ASSEMBLY_POS: Z/1032
Tekla Common - Bottom elevation: +4.777; Top elevation: +5.114; Phase: 1; Class: 1
Tekla Quantity - Weight: 3.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.3 m2; Height: 340.9 mm; Width: 3.1 mm; Length: 511.9 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/1032
BaseQuantities - Width: 340.879 mm; NetArea: 0.276668 m2; GrossArea: 0.174498 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000407881 m3; GrossVolume: 0.000407881 m3

# IfcPlate: PLT3*341 (2)
In: Undefined
Description: PLT3*341; Material: STEEL/450
Tekla Common - Bottom elevation: +4.777; Top elevation: +5.114; Phase: 1; Class: 1
Default - ASSEMBLY_POS: Z/1033
Tekla Quantity - Weight: 3.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.3 m2; Height: 340.9 mm; Width: 3.2 mm; Length: 511.9 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/1033
BaseQuantities - Width: 341.04 mm; NetArea: 0.276668 m2; GrossArea: 0.174592 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000407881 m3; GrossVolume: 0.000407881 m3

# IfcPlate: PLT3*344.7 (2)
In: Undefined
Description: PLT3*344.7; Material: STEEL/450
Tekla Common - Bottom elevation: +5.428; Top elevation: +5.684; Phase: 1; Class: 11
Tekla Quantity - Weight: 7.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.1 m2; Net surface area: 0.6 m2; Height: 344.7 mm; Width: 3 mm; Length: 1068.8 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 344.733 mm; NetArea: 0.652522 m2; GrossArea: 0.368444 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000964894 m3; GrossVolume: 0.000980245 m3
Name | ASSEMBLY_POS = Reference
APEX BRACING PLATE | PL/1741
APEX BRACING PLATE | PL/1752

# IfcPlate: PLT3*347.8 (2)
In: Undefined
Description: PLT3*347.8; Material: STEEL/450
Default - ASSEMBLY_POS: Z/1034
Tekla Common - Bottom elevation: +4.777; Top elevation: +5.137; Phase: 1; Class: 1
Tekla Quantity - Weight: 3.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.3 m2; Height: 347.8 mm; Width: 3.2 mm; Length: 527.1 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/1034
BaseQuantities - Width: 347.803 mm; NetArea: 0.287435 m2; GrossArea: 0.183329 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000423916 m3; GrossVolume: 0.000423916 m3

# IfcPlate: PLT3*348.1 (2)
In: Undefined
Description: PLT3*348.1; Material: STEEL/450
Tekla Common - Bottom elevation: +4.777; Top elevation: +5.137; Phase: 1; Class: 1
Default - ASSEMBLY_POS: Z/1035
Tekla Quantity - Weight: 3.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.3 m2; Height: 348.1 mm; Width: 3.3 mm; Length: 527.2 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/1035
BaseQuantities - Width: 348.096 mm; NetArea: 0.287435 m2; GrossArea: 0.183505 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000423916 m3; GrossVolume: 0.000423916 m3

# IfcPlate: PLT3*352.8 (6)
In: Undefined
Description: PLT3*352.8; Material: STEEL/450
Tekla Common - Phase: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 352.8 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Class | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Length (mm) | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) | GrossVolume (m3)
APEX BRACING PLATE | PL/1743 | +5.607 | +5.871 | 11 | 6.7 | 86.1 | 0.6 | 939.9 | 352.76 | 0.570407 | 0.331544 | 0.000843191 | 0.000858542
APEX BRACING PLATE | PL/1754 | +5.607 | +5.871 | 11 | 6.7 | 86.1 | 0.6 | 939.9 | 352.76 | 0.570405 | 0.331544 | 0.00084319 | 0.000858542
PLATE | Z/2396 | +4.777 | +5.076 | 1 | 2.9 | 86.5 | 0.3 | 504.9 | 352.79 | 0.2603 | 0.178118 | 0.000383495 | 0.000383495
PLATE | Z/2395 | +4.777 | +5.076 | 1 | 2.9 | 86.5 | 0.3 | 504.9 | 352.79 | 0.260303 | 0.178118 | 0.0003835 | 0.0003835
PLATE | Z/2395 | +4.777 | +5.076 | 1 | 2.9 | 86.5 | 0.3 | 504.9 | 352.79 | 0.260302 | 0.178118 | 0.0003835 | 0.0003835
PLATE | Z/2396 | +4.777 | +5.076 | 1 | 2.9 | 86.5 | 0.3 | 504.9 | 352.79 | 0.260303 | 0.178118 | 0.0003835 | 0.0003835

# IfcPlate: PLT3*355.5 (2)
In: Undefined
Description: PLT3*355.5; Material: STEEL/450
Default - ASSEMBLY_POS: Z/1003
