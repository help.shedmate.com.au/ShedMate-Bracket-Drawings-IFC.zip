Properties of the parts of a building model (IFC2X3), part 1 of 4

# File
Description: ViewDefinition[CoordinationView_V2.0, QuantityTakeOffAddOnView], Option [BaseQuantities:On], Option [GridExport:On], Option [Assemblies:On], Option [Bolts:On], Option [Rebars:On], Option [PourObjects:Off], Option [Welds:Off], Option [SurfaceTreatments:Off], Option [LocationBy:0], Option [ViewColors:Off], Option [SectionedSpine:Off], Option [PropertySets:On], Option [Export all:Off]
File name: Apex & Haunch brcing plate (Gable).ifc
Time: 2026-07-14T15:18:36
Author: DESKTOP-BKNQL56\admin
Organization: Structural Designer
Written by: IFC Database Version: Work
Made in: Tekla Structures 2019 Service Pack 13, IFC Export Version: 4.0.0.0 Oct 18 2021

# IfcBuildingStorey, Undefined
In: Undefined
Elevation: 0 mm

# IfcBeam: C:150-15 (148)
In: Undefined
Description: C:150-15; Material: STEEL/300PLUS
Default - ASSEMBLY_POS: Z/561
Tekla Common - Phase: 1; Class: 1
Tekla Quantity - Weight: 3.5 kg; Volume: 0 m3; Gross footprint area: 0.1 m2; Area per tons: 176.5 m2; Net surface area: 0.6 m2; Height: 152 mm; Width: 64 mm; Length: 1000 mm
Pset_BeamCommon - LoadBearing: no; Reference: Z/561
BaseQuantities - Length: 1000 mm; OuterSurfaceArea: 0.613915 m2; NetVolume: 0.0004575 m3; NetWeight: 3.59138 kg
Name | Bottom elevation | Top elevation
28 x FASCIA | +4.909 | +5.061
16 x FASCIA | +4.906 | +5.058
32 x FASCIA | +4.902 | +5.054
16 x FASCIA | +4.896 | +5.048
24 x FASCIA | +4.908 | +5.060
16 x FASCIA | +4.895 | +5.047
16 x FASCIA | +4.905 | +5.057

# IfcBeam: C:150-19 (10)
In: Undefined
Description: C:150-19; Material: STEEL/G450
Tekla Common - Phase: 1; Class: 5
Tekla Quantity - Weight: 12.1 kg; Volume: 0 m3; Gross footprint area: 0.2 m2; Area per tons: 139.7 m2; Net surface area: 1.7 m2; Height: 152 mm; Width: 64 mm; Length: 2757.7 mm
Pset_BeamCommon - LoadBearing: no
BaseQuantities - Length: 2757.68 mm; OuterSurfaceArea: 1.69603 m2; NetVolume: 0.00160017 m3; NetWeight: 12.5613 kg
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation
APEX BRACE | Z/2387 | +6.220 | +6.372
APEX BRACE | Z/2387 | +5.758 | +5.910
APEX BRACE | Z/2387 | +5.571 | +5.723
APEX BRACE | Z/2387 | +5.389 | +5.541
APEX BRACE | Z/2428 | +6.220 | +6.372
APEX BRACE | Z/2428 | +5.758 | +5.910
APEX BRACE | Z/2428 | +5.571 | +5.723
APEX BRACE | Z/2428 | +5.389 | +5.541
2 x APEX BRACE | Z/2387 | +5.268 | +5.420

# IfcBeam: C:150-24 (26)
In: Undefined
Description: C:150-24; Material: STEEL/G450
Tekla Common - Phase: 1; Class: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 111.2 m2; Height: 152 mm; Width: 64 mm
Pset_BeamCommon - LoadBearing: no
Name | Finish | Bottom elevation | Top elevation | ASSEMBLY_POS = Reference | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x COLUMN | 25 deg | +0.000 | +5.050 | Z/92 | 28.1 | 3.1 | 5050.1 | 5050.09 | 3.13051 | 0.00372575 | 29.2472
2 x RAFTER | 18 deg | +4.908 | +6.307 | Z/90 | 22.6 | 2.5 | 4060.8 | 4060.78 | 2.51754 | 0.00299588 | 23.5177
2 x RAFTER | 18 deg | +4.908 | +6.307 | Z/2400 | 22.6 | 2.5 | 4060.8 | 4060.78 | 2.51754 | 0.00299588 | 23.5177
2 x COLUMN | 18 deg | +0.000 | +5.057 | Z/89 | 28.2 | 3.1 | 5056.8 | 5056.79 | 3.13466 | 0.0037307 | 29.286
2 x RAFTER | 15 deg | +4.896 | +6.080 | Z/87 | 22.3 | 2.5 | 4006.2 | 4006.17 | 2.4837 | 0.00295559 | 23.2014
2 x RAFTER | 15 deg | +4.896 | +6.080 | Z/2394 | 22.3 | 2.5 | 4006.2 | 4006.17 | 2.4837 | 0.00295559 | 23.2014
2 x COLUMN | 15 deg | +0.000 | +5.060 | Z/86 | 28.2 | 3.1 | 5059.9 | 5059.86 | 3.13656 | 0.00373296 | 29.3038
2 x RAFTER | 12 deg | +4.886 | +5.858 | Z/61 | 22.1 | 2.5 | 3964 | 3964.01 | 2.45758 | 0.00292449 | 22.9572
2 x RAFTER | 12 deg | +4.886 | +5.858 | Z/2385 | 22.1 | 2.5 | 3964 | 3964.01 | 2.45758 | 0.00292449 | 22.9572
2 x COLUMN | 12 deg | +0.000 | +5.063 | Z/2393 | 28.2 | 3.1 | 5063.1 | 5063.14 | 3.1386 | 0.00373538 | 29.3228
2 x RAFTER | 12 deg | +4.879 | +5.713 | Z/2392 | 22 | 2.5 | 3941.4 | 3941.37 | 2.44355 | 0.00290779 | 22.8261
2 x RAFTER | 12 deg | +4.879 | +5.713 | Z/2424 | 22 | 2.5 | 3941.4 | 3941.38 | 2.44355 | 0.00290779 | 22.8262
COLUMN | 12 deg | +0.000 | +5.063 | Z/2391 | 28.2 | 3.1 | 5063.1 | 5063.14 | 3.1386 | 0.00373538 | 29.3228
COLUMN | 12 deg | +0.000 | +5.063 | Z/2429 | 28.2 | 3.1 | 5063.1 | 5063.14 | 3.1386 | 0.00373538 | 29.3228

# IfcBeam: C:200-19 (20)
In: Undefined
Description: C:200-19; Material: STEEL/G450
Default - ASSEMBLY_POS: Z/2433
Tekla Common - Phase: 1; Class: 5
Tekla Quantity - Weight: 16.3 kg; Volume: 0 m3; Gross footprint area: 0.2 m2; Area per tons: 138.5 m2; Net surface area: 2.3 m2; Height: 203 mm; Width: 76 mm; Length: 2911.4 mm
Pset_BeamCommon - LoadBearing: no; Reference: Z/2433
BaseQuantities - Length: 2911.41 mm; OuterSurfaceArea: 2.25664 m2; NetVolume: 0.00213191 m3; NetWeight: 16.7355 kg
Name | Bottom elevation | Top elevation
2 x APEX BRACE | +5.210 | +5.413
2 x APEX BRACE | +6.005 | +6.208
2 x APEX BRACE | +5.564 | +5.767
2 x APEX BRACE | +5.385 | +5.588
2 x APEX BRACE | +5.257 | +5.460
2 x APEX BRACE | +6.050 | +6.253
2 x APEX BRACE | +5.610 | +5.813
2 x APEX BRACE | +5.431 | +5.634
2 x APEX BRACE | +5.096 | +5.299
2 x APEX BRACE | +5.143 | +5.346

# IfcBeam: C:200-24 (26)
In: Undefined
Description: C:200-24; Material: STEEL/G450
Tekla Common - Phase: 1; Class: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 110 m2; Height: 203 mm; Width: 76 mm
Pset_BeamCommon - LoadBearing: no
Name | Finish | Bottom elevation | Top elevation | ASSEMBLY_POS = Reference | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x COLUMN | 25 deg | +0.000 | +5.050 | Z/111 | 35.8 | 3.9 | 5050.1 | 5050.09 | 3.93891 | 0.00469537 | 36.8587
2 x RAFTER | 18 deg | +4.876 | +6.310 | Z/4 | 28.5 | 3.1 | 4017.4 | 4017.4 | 3.13382 | 0.00373522 | 29.3215
2 x RAFTER | 18 deg | +4.876 | +6.310 | Z/2484 | 28.5 | 3.1 | 4017.4 | 4017.4 | 3.13382 | 0.00373522 | 29.3215
2 x COLUMN | 18 deg | +0.000 | +5.057 | Z/109 | 35.8 | 3.9 | 5056.8 | 5056.8 | 3.94414 | 0.00470161 | 36.9076
2 x RAFTER | 15 deg | +4.861 | +6.083 | Z/107 | 28.1 | 3.1 | 3966.1 | 3966.1 | 3.09383 | 0.00368752 | 28.947
2 x RAFTER | 15 deg | +4.861 | +6.083 | Z/2442 | 28.1 | 3.1 | 3966.1 | 3966.1 | 3.09383 | 0.00368752 | 28.947
2 x COLUMN | 15 deg | +0.000 | +5.060 | Z/106 | 35.8 | 3.9 | 5059.9 | 5059.86 | 3.94653 | 0.00470446 | 36.93
2 x RAFTER | 12 deg | +4.846 | +5.861 | Z/64 | 27.8 | 3.1 | 3927.1 | 3927.11 | 3.06344 | 0.00365127 | 28.6625
2 x RAFTER | 12 deg | +4.846 | +5.861 | Z/2414 | 27.8 | 3.1 | 3927.1 | 3927.11 | 3.06343 | 0.00365127 | 28.6625
2 x COLUMN | 12 deg | +0.000 | +5.063 | Z/2398 | 35.8 | 3.9 | 5063.3 | 5063.16 | 3.9491 | 0.00470752 | 36.9541
2 x RAFTER | 12 deg | +4.838 | +5.716 | Z/2399 | 27.8 | 3 | 3906.1 | 3906.14 | 3.04709 | 0.00363177 | 28.5094
2 x RAFTER | 12 deg | +4.838 | +5.716 | Z/2431 | 27.8 | 3 | 3906.1 | 3906.14 | 3.04708 | 0.00363177 | 28.5094
COLUMN | 12 deg | +0.000 | +5.063 | Z/2430 | 35.8 | 3.9 | 5063.3 | 5063.16 | 3.9491 | 0.00470752 | 36.9541
COLUMN | 12 deg | +0.000 | +5.063 | Z/2436 | 35.8 | 3.9 | 5063.3 | 5063.16 | 3.9491 | 0.00470752 | 36.9541

# IfcBeam: C:250-19 (20)
In: Undefined
Description: C:250-19; Material: STEEL/G450
Default - ASSEMBLY_POS: Z/2447
Tekla Common - Phase: 1; Class: 5
Tekla Quantity - Weight: 18.5 kg; Volume: 0 m3; Gross footprint area: 0.2 m2; Area per tons: 138 m2; Net surface area: 2.5 m2; Height: 254 mm; Width: 76 mm; Length: 2911.4 mm
Pset_BeamCommon - LoadBearing: no; Reference: Z/2447
BaseQuantities - Length: 2911.41 mm; OuterSurfaceArea: 2.54797 m2; NetVolume: 0.00240849 m3; NetWeight: 18.9067 kg
Name | Bottom elevation | Top elevation
2 x APEX BRACE | +5.118 | +5.372
2 x APEX BRACE | +5.293 | +5.547
2 x APEX BRACE | +5.473 | +5.727
2 x APEX BRACE | +5.915 | +6.169
2 x APEX BRACE | +5.159 | +5.413
2 x APEX BRACE | +5.334 | +5.588
2 x APEX BRACE | +5.513 | +5.767
2 x APEX BRACE | +5.954 | +6.208
2 x APEX BRACE | +5.045 | +5.299
2 x APEX BRACE | +5.002 | +5.256

# IfcBeam: C:250-24 (52)
In: Undefined
Description: C:250-24; Material: STEEL/G450
Tekla Common - Phase: 1; Class: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 109.7 m2; Height: 254 mm; Width: 76 mm
Pset_BeamCommon - LoadBearing: no
Name | Finish | Bottom elevation | Top elevation | ASSEMBLY_POS = Reference | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
4 x COLUMN | 25 deg | +0.000 | +5.050 | Z/1472 | 40.5 | 4.5 | 5050.1 | 5050.08 | 4.44415 | 0.00530137 | 41.6158
4 x RAFTER | 18 deg | +4.844 | +6.313 | Z/129 | 31.9 | 3.5 | 3974 | 3974.01 | 3.49764 | 0.00417175 | 32.7483
2 x RAFTER | 18 deg | +4.844 | +6.313 | Z/2494 | 31.9 | 3.5 | 3974 | 3974.01 | 3.49764 | 0.00417175 | 32.7483
4 x COLUMN | 18 deg | +0.000 | +5.057 | Z/1470 | 40.6 | 4.5 | 5056.8 | 5056.79 | 4.45005 | 0.00530842 | 41.6711
4 x RAFTER | 15 deg | +4.825 | +6.086 | Z/126 | 31.5 | 3.5 | 3926 | 3926.04 | 3.45544 | 0.0041214 | 32.353
2 x RAFTER | 15 deg | +4.825 | +6.086 | Z/2493 | 31.5 | 3.5 | 3926 | 3926.04 | 3.45544 | 0.0041214 | 32.353
4 x COLUMN | 15 deg | +0.000 | +5.060 | Z/1468 | 40.6 | 4.5 | 5059.9 | 5059.86 | 4.45275 | 0.00531164 | 41.6964
4 x RAFTER | 12 deg | +4.807 | +5.865 | Z/2406 | 31.2 | 3.5 | 3890.2 | 3890.2 | 3.42392 | 0.00408378 | 32.0576
2 x RAFTER | 12 deg | +4.807 | +5.865 | Z/2492 | 31.2 | 3.5 | 3890.2 | 3890.2 | 3.42392 | 0.00408377 | 32.0576
5 x COLUMN | 12 deg | +0.000 | +5.063 | Z/2404 | 40.6 | 4.5 | 5063.3 | 5063.25 | 4.45573 | 0.0053152 | 41.7243
2 x RAFTER | 18 deg | +4.844 | +6.313 | Z/2489 | 31.9 | 3.5 | 3974 | 3974.01 | 3.49764 | 0.00417175 | 32.7483
2 x RAFTER | 15 deg | +4.825 | +6.086 | Z/2488 | 31.5 | 3.5 | 3926 | 3926.04 | 3.45544 | 0.0041214 | 32.353
2 x RAFTER | 12 deg | +4.807 | +5.865 | Z/2487 | 31.2 | 3.5 | 3890.2 | 3890.2 | 3.42392 | 0.00408377 | 32.0576
4 x RAFTER | 12 deg | +4.796 | +5.719 | Z/2405 | 31.1 | 3.5 | 3870.9 | 3870.9 | 3.40694 | 0.00406352 | 31.8986
2 x RAFTER | 12 deg | +4.796 | +5.719 | Z/2445 | 31.1 | 3.5 | 3870.9 | 3870.9 | 3.40694 | 0.00406351 | 31.8986
COLUMN | 12 deg | +0.000 | +5.063 | Z/2444 | 40.6 | 4.5 | 5063.3 | 5063.25 | 4.45573 | 0.0053152 | 41.7243
2 x RAFTER | 12 deg | +4.796 | +5.719 | Z/2438 | 31.1 | 3.5 | 3870.9 | 3870.9 | 3.40694 | 0.00406351 | 31.8986
COLUMN | 12 deg | +0.000 | +5.063 | Z/2437 | 40.6 | 4.5 | 5063.3 | 5063.25 | 4.45573 | 0.0053152 | 41.7243
COLUMN | 12 deg | +0.000 | +5.063 | Z/2443 | 40.6 | 4.5 | 5063.3 | 5063.25 | 4.45573 | 0.0053152 | 41.7243

# IfcBeam: C:300-30 (72)
In: Undefined
Description: C:300-30; Material: STEEL/G450
Tekla Common - Phase: 1
Tekla Quantity - Volume: 0 m3; Area per tons: 87.4 m2; Height: 300 mm; Width: 96 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Class | Weight (kg) | Gross footprint area (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg) | Finish
2 x APEX BRACE | Z/2458 | +5.026 | +5.326 | 5 | 36.4 | 0.3 | 3.2 | 2911.4 | 2911.41 | 3.18252 | 0.00474269 | 37.2301
2 x APEX BRACE | Z/2458 | +5.202 | +5.502 | 5 | 36.4 | 0.3 | 3.2 | 2911.4 | 2911.41 | 3.18252 | 0.00474269 | 37.2301
2 x APEX BRACE | Z/2458 | +5.382 | +5.682 | 5 | 36.4 | 0.3 | 3.2 | 2911.4 | 2911.41 | 3.18252 | 0.00474269 | 37.2301
2 x APEX BRACE | Z/2458 | +5.825 | +6.125 | 5 | 36.4 | 0.3 | 3.2 | 2911.4 | 2911.41 | 3.18252 | 0.00474269 | 37.2301
2 x APEX BRACE | Z/2458 | +5.072 | +5.372 | 5 | 36.4 | 0.3 | 3.2 | 2911.4 | 2911.41 | 3.18252 | 0.00474269 | 37.2301
4 x RAFTER | Z/2413 | +4.772 | +5.868 | 1 | 48.2 | 0 | 4.2 | 3856.9 | 3856.9 | 4.215 | 0.00628289 | 49.3207 | 12 deg
2 x RAFTER | Z/2502 | +4.772 | +5.868 | 1 | 48.2 | 0 | 4.2 | 3856.9 | 3856.9 | 4.21499 | 0.00628289 | 49.3207 | 12 deg
5 x COLUMN | Z/2411 | +0.000 | +5.063 | 1 | 63.3 | 0 | 5.5 | 5062.8 | 5062.81 | 5.53185 | 0.00824732 | 64.7414 | 12 deg
2 x APEX BRACE | Z/2458 | +5.247 | +5.547 | 5 | 36.4 | 0.3 | 3.2 | 2911.4 | 2911.41 | 3.18252 | 0.00474269 | 37.2301
4 x RAFTER | Z/145 | +4.793 | +6.090 | 1 | 48.6 | 0 | 4.2 | 3889.9 | 3889.9 | 4.25103 | 0.00633665 | 49.7427 | 15 deg
2 x RAFTER | Z/2503 | +4.793 | +6.090 | 1 | 48.6 | 0 | 4.2 | 3889.9 | 3889.9 | 4.25103 | 0.00633665 | 49.7427 | 15 deg
4 x COLUMN | Z/1484 | +0.000 | +5.060 | 1 | 63.3 | 0 | 5.5 | 5059.9 | 5059.86 | 5.52863 | 0.00824251 | 64.7037 | 15 deg
2 x APEX BRACE | Z/2458 | +5.427 | +5.727 | 5 | 36.4 | 0.3 | 3.2 | 2911.4 | 2911.41 | 3.18252 | 0.00474269 | 37.2301
4 x RAFTER | Z/148 | +4.815 | +6.317 | 1 | 49.2 | 0 | 4.2 | 3934.9 | 3934.88 | 4.30015 | 0.00640992 | 50.3179 | 18 deg
2 x RAFTER | Z/2504 | +4.815 | +6.317 | 1 | 49.2 | 0 | 4.2 | 3934.9 | 3934.88 | 4.30015 | 0.00640992 | 50.3179 | 18 deg
4 x COLUMN | Z/1486 | +0.000 | +5.057 | 1 | 63.2 | 0 | 5.5 | 5056.8 | 5056.79 | 5.52527 | 0.00823751 | 64.6645 | 18 deg
2 x APEX BRACE | Z/2458 | +5.869 | +6.169 | 5 | 36.4 | 0.3 | 3.2 | 2911.4 | 2911.41 | 3.18252 | 0.00474269 | 37.2301
4 x COLUMN | Z/1488 | +0.000 | +5.050 | 1 | 63.2 | 0 | 5.5 | 5050.1 | 5050.09 | 5.51796 | 0.0082266 | 64.5788 | 25 deg
2 x RAFTER | Z/2497 | +4.772 | +5.868 | 1 | 48.2 | 0 | 4.2 | 3856.9 | 3856.9 | 4.21499 | 0.00628289 | 49.3207 | 12 deg
2 x RAFTER | Z/2498 | +4.793 | +6.090 | 1 | 48.6 | 0 | 4.2 | 3889.9 | 3889.9 | 4.25103 | 0.00633665 | 49.7427 | 15 deg
2 x RAFTER | Z/2499 | +4.815 | +6.317 | 1 | 49.2 | 0 | 4.2 | 3934.9 | 3934.88 | 4.30015 | 0.00640992 | 50.3179 | 18 deg
2 x APEX BRACE | Z/2458 | +4.956 | +5.256 | 5 | 36.4 | 0.3 | 3.2 | 2911.4 | 2911.41 | 3.18252 | 0.00474269 | 37.2301
4 x RAFTER | Z/2412 | +4.760 | +5.722 | 1 | 48 | 0 | 4.2 | 3839.1 | 3839.12 | 4.19557 | 0.00625392 | 49.0933 | 12 deg
2 x RAFTER | Z/2456 | +4.760 | +5.722 | 1 | 48 | 0 | 4.2 | 3839.1 | 3839.11 | 4.19557 | 0.00625391 | 49.0932 | 12 deg
COLUMN | Z/2455 | +0.000 | +5.063 | 1 | 63.3 | 0 | 5.5 | 5062.8 | 5062.81 | 5.53185 | 0.00824732 | 64.7414 | 12 deg
2 x APEX BRACE | Z/2458 | +4.910 | +5.210 | 5 | 36.4 | 0.3 | 3.2 | 2911.4 | 2911.41 | 3.18252 | 0.00474269 | 37.2301
2 x RAFTER | Z/2451 | +4.760 | +5.722 | 1 | 48 | 0 | 4.2 | 3839.1 | 3839.11 | 4.19557 | 0.00625391 | 49.0932 | 12 deg
COLUMN | Z/2450 | +0.000 | +5.063 | 1 | 63.3 | 0 | 5.5 | 5062.8 | 5062.81 | 5.53185 | 0.00824732 | 64.7414 | 12 deg
COLUMN | Z/2454 | +0.000 | +5.063 | 1 | 63.3 | 0 | 5.5 | 5062.8 | 5062.81 | 5.53185 | 0.00824732 | 64.7414 | 12 deg

# IfcBeam: C:350-30 (62)
In: Undefined
Description: C:350-30; Material: STEEL/G450
Tekla Common - Phase: 1
Tekla Quantity - Volume: 0 m3; Area per tons: 87.2 m2; Height: 350 mm; Width: 125 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Class | Weight (kg) | Gross footprint area (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg) | Finish
2 x APEX BRACE | Z/2514 | +5.042 | +5.392 | 5 | 36.8 | 0.3 | 3.2 | 2457.7 | 2457.72 | 3.20384 | 0.00477781 | 37.5058
6 x RAFTER | Z/2420 | +4.734 | +5.871 | 1 | 57.1 | 0 | 5 | 3820.7 | 3820.71 | 4.97845 | 0.00742746 | 58.3056 | 12 deg
5 x COLUMN | Z/2418 | +0.000 | +5.063 | 1 | 75.7 | 0 | 6.6 | 5063 | 5063.04 | 6.59596 | 0.00984254 | 77.264 | 12 deg
2 x APEX BRACE | Z/2514 | +5.235 | +5.585 | 5 | 36.8 | 0.3 | 3.2 | 2457.7 | 2457.72 | 3.20384 | 0.00477781 | 37.5058
6 x RAFTER | Z/165 | +4.758 | +6.093 | 1 | 57.6 | 0 | 5 | 3850.6 | 3850.62 | 5.0174 | 0.00748561 | 58.762 | 15 deg
4 x COLUMN | Z/1499 | +0.000 | +5.060 | 1 | 75.7 | 0 | 6.6 | 5059.9 | 5059.86 | 6.59182 | 0.00983636 | 77.2154 | 15 deg
2 x APEX BRACE | Z/2514 | +5.433 | +5.783 | 5 | 36.8 | 0.3 | 3.2 | 2457.7 | 2457.72 | 3.20384 | 0.00477781 | 37.5058
6 x RAFTER | Z/168 | +4.784 | +6.320 | 1 | 58.2 | 0 | 5.1 | 3892.4 | 3892.35 | 5.07173 | 0.00756673 | 59.3988 | 18 deg
4 x COLUMN | Z/1501 | +0.000 | +5.057 | 1 | 75.7 | 0 | 6.6 | 5056.8 | 5056.8 | 6.58784 | 0.00983041 | 77.1687 | 18 deg
2 x APEX BRACE | Z/2514 | +5.920 | +6.270 | 5 | 36.8 | 0.3 | 3.2 | 2457.7 | 2457.72 | 3.20384 | 0.00477781 | 37.5058
4 x COLUMN | Z/1503 | +0.000 | +5.050 | 1 | 75.5 | 0 | 6.6 | 5050.1 | 5050.09 | 6.5791 | 0.00981737 | 77.0663 | 25 deg
2 x RAFTER | Z/2507 | +4.734 | +5.871 | 1 | 57.1 | 0 | 5 | 3820.7 | 3820.71 | 4.97845 | 0.00742746 | 58.3056 | 12 deg
2 x RAFTER | Z/2508 | +4.758 | +6.093 | 1 | 57.6 | 0 | 5 | 3850.6 | 3850.62 | 5.0174 | 0.00748561 | 58.762 | 15 deg
2 x RAFTER | Z/2509 | +4.784 | +6.320 | 1 | 58.2 | 0 | 5.1 | 3892.4 | 3892.35 | 5.07173 | 0.00756673 | 59.3988 | 18 deg
2 x APEX BRACE | Z/2469 | +4.940 | +5.290 | 5 | 36.8 | 0.3 | 3.2 | 2457.7 | 2457.72 | 3.20384 | 0.00477781 | 37.5058
4 x RAFTER | Z/2419 | +4.719 | +5.725 | 1 | 56.9 | 0 | 5 | 3804.6 | 3804.56 | 4.95743 | 0.00739607 | 58.0592 | 12 deg
2 x RAFTER | Z/2467 | +4.719 | +5.725 | 1 | 56.9 | 0 | 5 | 3804.6 | 3804.56 | 4.95743 | 0.00739607 | 58.0592 | 12 deg
COLUMN | Z/2466 | +0.000 | +5.063 | 1 | 75.7 | 0 | 6.6 | 5063 | 5063.04 | 6.59596 | 0.00984254 | 77.264 | 12 deg
2 x RAFTER | Z/2462 | +4.719 | +5.725 | 1 | 56.9 | 0 | 5 | 3804.6 | 3804.56 | 4.95743 | 0.00739607 | 58.0592 | 12 deg
COLUMN | Z/2461 | +0.000 | +5.063 | 1 | 75.7 | 0 | 6.6 | 5063 | 5063.04 | 6.59596 | 0.00984254 | 77.264 | 12 deg
COLUMN | Z/2465 | +0.000 | +5.063 | 1 | 75.7 | 0 | 6.6 | 5063 | 5063.04 | 6.59596 | 0.00984254 | 77.264 | 12 deg

# IfcBeam: PLT1.6*60 (148)
In: Undefined
Description: PLT1.6*60; Material: STEEL/250
Default - ASSEMBLY_POS: Z/52
Tekla Common - Phase: 1; Class: 1
Tekla Quantity - Weight: 0.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 164.6 m2; Net surface area: 0 m2; Height: 60 mm; Width: 1.6 mm; Length: 297.9 mm
Pset_BeamCommon - LoadBearing: no; Reference: Z/52
BaseQuantities - Length: 297.881 mm; OuterSurfaceArea: 0.0371807 m2; NetVolume: 0.0000287808 m3; NetWeight: 0.225929 kg
Name | Bottom elevation | Top elevation
52 x FASCIA BRACKET | +4.906 | +5.063
32 x FASCIA BRACKET | +4.903 | +5.060
32 x FASCIA BRACKET | +4.900 | +5.057
32 x FASCIA BRACKET | +4.893 | +5.050

# IfcBeam: TH:75-95 (296)
In: Undefined
Description: TH:75-95; Material: STEEL/300PLUS
Default - ASSEMBLY_POS: Z/562
Tekla Common - Phase: 1; Class: 1
Tekla Quantity - Weight: 1.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 0 m2; Net surface area: 0.5 m2; Height: 75 mm; Width: 125 mm; Length: 1000 mm
Pset_BeamCommon - LoadBearing: no; Reference: Z/562
BaseQuantities - Length: 1000 mm; OuterSurfaceArea: 4.5602e-07 m2; NetVolume: 0.000231901 m3; NetWeight: 1.82042 kg
Name | Bottom elevation | Top elevation
52 x TH | +4.562 | +4.687
8 x TH | +5.365 | +5.455
32 x TH | +4.559 | +4.684
8 x TH | +5.453 | +5.547
32 x TH | +4.556 | +4.681
8 x TH | +5.541 | +5.637
24 x TH | +4.549 | +4.674
8 x TH | +5.732 | +5.834
8 x TH | +5.360 | +5.450
8 x TH | +5.447 | +5.540
8 x TH | +5.537 | +5.633
8 x TH | +4.550 | +4.675
8 x TH | +5.722 | +5.824
8 x TH | +5.713 | +5.815
8 x TH | +5.526 | +5.622
8 x TH | +5.441 | +5.534
8 x TH | +5.355 | +5.445
4 x TH | +5.704 | +5.806
4 x TH | +5.519 | +5.615
4 x TH | +5.435 | +5.528
4 x TH | +5.349 | +5.440
4 x TH | +5.694 | +5.796
4 x TH | +5.511 | +5.607
4 x TH | +5.428 | +5.522
4 x TH | +5.344 | +5.435
2 x TH | +5.306 | +5.394
2 x TH | +5.305 | +5.392
2 x TH | +5.302 | +5.389
2 x TH | +5.300 | +5.388
2 x TH | +5.296 | +5.384
2 x TH | +5.294 | +5.382
4 x TH | +5.292 | +5.380
4 x TH | +5.288 | +5.375

# IfcColumn: C:150-24 (10)
In: Undefined
Description: C:150-24; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Phase: 1; Class: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 111.2 m2; Net surface area: 3.1 m2; Height: 152 mm; Width: 64 mm
Pset_ColumnCommon - LoadBearing: no
Name | Finish | Top elevation | ASSEMBLY_POS = Reference | Weight (kg) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x COLUMN | 25 deg | +5.050 | Z/92 | 28.1 | 5050.1 | 5050.09 | 3.13051 | 0.00372575 | 29.2472
2 x COLUMN | 18 deg | +5.057 | Z/89 | 28.2 | 5056.8 | 5056.79 | 3.13466 | 0.0037307 | 29.286
2 x COLUMN | 15 deg | +5.060 | Z/86 | 28.2 | 5059.9 | 5059.86 | 3.13656 | 0.00373296 | 29.3038
3 x COLUMN | 12 deg | +5.063 | Z/2393 | 28.2 | 5063.1 | 5063.14 | 3.1386 | 0.00373538 | 29.3228
COLUMN | 12 deg | +5.063 | Z/2391 | 28.2 | 5063.1 | 5063.14 | 3.1386 | 0.00373538 | 29.3228

# IfcColumn: C:200-24 (10)
In: Undefined
Description: C:200-24; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Phase: 1; Class: 1
Tekla Quantity - Weight: 35.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 110 m2; Net surface area: 3.9 m2; Height: 203 mm; Width: 76 mm
Pset_ColumnCommon - LoadBearing: no
Name | Finish | Top elevation | ASSEMBLY_POS = Reference | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x COLUMN | 25 deg | +5.050 | Z/111 | 5050.1 | 5050.09 | 3.93891 | 0.00469537 | 36.8587
2 x COLUMN | 18 deg | +5.057 | Z/109 | 5056.8 | 5056.8 | 3.94414 | 0.00470161 | 36.9076
2 x COLUMN | 15 deg | +5.060 | Z/106 | 5059.9 | 5059.86 | 3.94653 | 0.00470446 | 36.93
3 x COLUMN | 12 deg | +5.063 | Z/2398 | 5063.3 | 5063.16 | 3.9491 | 0.00470752 | 36.9541
COLUMN | 12 deg | +5.063 | Z/2430 | 5063.3 | 5063.16 | 3.9491 | 0.00470752 | 36.9541

# IfcColumn: C:250-24 (20)
In: Undefined
Description: C:250-24; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Phase: 1; Class: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 109.7 m2; Net surface area: 4.5 m2; Height: 254 mm; Width: 76 mm
Pset_ColumnCommon - LoadBearing: no
Name | Finish | Top elevation | ASSEMBLY_POS = Reference | Weight (kg) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
4 x COLUMN | 25 deg | +5.050 | Z/1472 | 40.5 | 5050.1 | 5050.08 | 4.44415 | 0.00530137 | 41.6158
4 x COLUMN | 18 deg | +5.057 | Z/1470 | 40.6 | 5056.8 | 5056.79 | 4.45005 | 0.00530842 | 41.6711
4 x COLUMN | 15 deg | +5.060 | Z/1468 | 40.6 | 5059.9 | 5059.86 | 4.45275 | 0.00531164 | 41.6964
6 x COLUMN | 12 deg | +5.063 | Z/2404 | 40.6 | 5063.3 | 5063.25 | 4.45573 | 0.0053152 | 41.7243
COLUMN | 12 deg | +5.063 | Z/2444 | 40.6 | 5063.3 | 5063.25 | 4.45573 | 0.0053152 | 41.7243
COLUMN | 12 deg | +5.063 | Z/2437 | 40.6 | 5063.3 | 5063.25 | 4.45573 | 0.0053152 | 41.7243

# IfcColumn: C:300-30 (20)
In: Undefined
Description: C:300-30; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Phase: 1; Class: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.4 m2; Net surface area: 5.5 m2; Height: 300 mm; Width: 96 mm
Pset_ColumnCommon - LoadBearing: no
Name | Finish | Top elevation | ASSEMBLY_POS = Reference | Weight (kg) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
6 x COLUMN | 12 deg | +5.063 | Z/2411 | 63.3 | 5062.8 | 5062.81 | 5.53185 | 0.00824732 | 64.7414
4 x COLUMN | 15 deg | +5.060 | Z/1484 | 63.3 | 5059.9 | 5059.86 | 5.52863 | 0.00824251 | 64.7037
4 x COLUMN | 18 deg | +5.057 | Z/1486 | 63.2 | 5056.8 | 5056.79 | 5.52527 | 0.00823751 | 64.6645
4 x COLUMN | 25 deg | +5.050 | Z/1488 | 63.2 | 5050.1 | 5050.09 | 5.51796 | 0.0082266 | 64.5788
COLUMN | 12 deg | +5.063 | Z/2455 | 63.3 | 5062.8 | 5062.81 | 5.53185 | 0.00824732 | 64.7414
COLUMN | 12 deg | +5.063 | Z/2450 | 63.3 | 5062.8 | 5062.81 | 5.53185 | 0.00824732 | 64.7414

# IfcColumn: C:350-30 (20)
In: Undefined
Description: C:350-30; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Phase: 1; Class: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.2 m2; Net surface area: 6.6 m2; Height: 350 mm; Width: 125 mm
Pset_ColumnCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Finish | Top elevation | Weight (kg) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
6 x COLUMN | Z/2418 | 12 deg | +5.063 | 75.7 | 5063 | 5063.04 | 6.59596 | 0.00984254 | 77.264
4 x COLUMN | Z/1499 | 15 deg | +5.060 | 75.7 | 5059.9 | 5059.86 | 6.59182 | 0.00983636 | 77.2154
4 x COLUMN | Z/1501 | 18 deg | +5.057 | 75.7 | 5056.8 | 5056.8 | 6.58784 | 0.00983041 | 77.1687
4 x COLUMN | Z/1503 | 25 deg | +5.050 | 75.5 | 5050.1 | 5050.09 | 6.5791 | 0.00981737 | 77.0663
COLUMN | Z/2466 | 12 deg | +5.063 | 75.7 | 5063 | 5063.04 | 6.59596 | 0.00984254 | 77.264
COLUMN | Z/2461 | 12 deg | +5.063 | 75.7 | 5063 | 5063.04 | 6.59596 | 0.00984254 | 77.264

# IfcElementAssembly (1488)
In: Undefined
PredefinedType: RIGID_FRAME
Name | ASSEMBLY_POSITION_CODE = Assembly/Cast unit position code | ASSEMBLY_POS = Assembly/Cast unit Mark | Assembly/Cast unit weight (kg) | Assembly/Cast unit bottom elevation | Assembly/Cast unit top elevation | Width (mm)
APEX BRACING PLATE | C350SD>/HB(12deg)-AB | PL/1931 | 23.7 | +5.039 | +5.430 | 128
HAUNCH BRACING PLATE | C350SD>/HB(12deg)-AB | PL/1930 | 12.1 | +4.435 | +5.329 | 128
2 x FASCIA BRACKET | C350SD>/HB | Z/52 | 0.2 | +4.906 | +5.063 | 157.2
2 x FASCIA BRACKET | C350SD>/HB(12deg) | Z/52 | 0.2 | +4.906 | +5.063 | 157.2
4 x COLUMN | C350SD>/HB | Z/2418 | 75.7 | +0.000 | +5.063 | 125
2 x RAFTER | C350SD>/AB-HB | Z/2420 | 57.1 | +4.734 | +5.871 | 125
2 x RAFTER | C350SD>/HB(12deg)-AB | Z/2420 | 57.1 | +4.734 | +5.871 | 125
2 x COLUMN | C350SD>/HB(12deg) | Z/2418 | 75.7 | +0.000 | +5.063 | 125
2 x APEX BRACE | C350SD>/HB(12deg)-HB | Z/2514 | 36.8 | +5.042 | +5.392 | 125
2 x HAUNCH BRACE | C350SD>/HB(12deg)-AB | Z/2513 | 13.1 | +3.974 | +4.840 | 125
4 x FASCIA | C350SD>/HB | Z/561 | 3.5 | +4.909 | +5.061 | 64
4 x TH | C350SD>/HB | Z/562 | 1.8 | +4.562 | +4.687 | 125
3 x TH | C350SD>/AB-HB | Z/562 | 1.8 | +5.365 | +5.455 | 125
3 x FASCIA | C350SD>/HB(12deg) | Z/561 | 3.5 | +4.909 | +5.061 | 64
3 x TH | C350SD>/HB(12deg) | Z/562 | 1.8 | +4.562 | +4.687 | 125
3 x TH | C350SD>/HB(12deg)-AB | Z/562 | 1.8 | +5.365 | +5.455 | 125
PLATE | C350SD>/AB-HB | Z/1432 | 10.1 | +4.577 | +5.164 | 128
PLATE | C350SD>/HB(12deg)-AB | Z/666 | 10.1 | +4.577 | +5.164 | 128
2 x PLATE | C350SD>/AB | Z/667 | 11.1 | +5.433 | +5.887 | 128
APEX BRACING PLATE | C350SD>/HB(15deg)-AB | PL/1933 | 19.6 | +5.232 | +5.630 | 128
HAUNCH BRACING PLATE | C350SD>/HB(15deg)-AB | PL/1932 | 13.1 | +4.484 | +5.423 | 128
2 x FASCIA BRACKET | C350SD>/HB | Z/52 | 0.2 | +4.903 | +5.060 | 157.2
2 x FASCIA BRACKET | C350SD>/HB(15deg) | Z/52 | 0.2 | +4.903 | +5.060 | 157.2
2 x COLUMN | C350SD>/HB | Z/1499 | 75.7 | +0.000 | +5.060 | 125
2 x RAFTER | C350SD>/AB-HB | Z/165 | 57.6 | +4.758 | +6.093 | 125
2 x RAFTER | C350SD>/HB(15deg)-AB | Z/165 | 57.6 | +4.758 | +6.093 | 125
2 x COLUMN | C350SD>/HB(15deg) | Z/1499 | 75.7 | +0.000 | +5.060 | 125
2 x APEX BRACE | C350SD>/HB(15deg)-HB | Z/2514 | 36.8 | +5.235 | +5.585 | 125
2 x HAUNCH BRACE | C350SD>/HB(15deg)-AB | Z/2513 | 13.1 | +4.024 | +4.889 | 125
3 x FASCIA | C350SD>/HB | Z/561 | 3.5 | +4.906 | +5.058 | 64
3 x TH | C350SD>/HB | Z/562 | 1.8 | +4.559 | +4.684 | 125
3 x TH | C350SD>/AB-HB | Z/562 | 1.8 | +5.453 | +5.547 | 125
3 x FASCIA | C350SD>/HB(15deg) | Z/561 | 3.5 | +4.906 | +5.058 | 64
3 x TH | C350SD>/HB(15deg) | Z/562 | 1.8 | +4.559 | +4.684 | 125
3 x TH | C350SD>/HB(15deg)-AB | Z/562 | 1.8 | +5.453 | +5.547 | 125
PLATE | C350SD>/AB-HB | Z/1119 | 10.5 | +4.577 | +5.205 | 128
PLATE | C350SD>/HB(15deg)-AB | Z/1120 | 10.5 | +4.577 | +5.205 | 128
2 x PLATE | C350SD>/HB(15deg)-HB | Z/1121 | 11.4 | +5.638 | +6.119 | 128
APEX BRACING PLATE | C350SD>/HB(18deg)-AB | PL/1935 | 16.8 | +5.430 | +5.834 | 128
HAUNCH BRACING PLATE | C350SD>/HB(18deg)-AB | PL/1934 | 14.4 | +4.534 | +5.526 | 128
2 x FASCIA BRACKET | C350SD>/HB | Z/52 | 0.2 | +4.900 | +5.057 | 157.2
2 x FASCIA BRACKET | C350SD>/HB(18deg) | Z/52 | 0.2 | +4.900 | +5.057 | 157.2
2 x COLUMN | C350SD>/HB | Z/1501 | 75.7 | +0.000 | +5.057 | 125
2 x RAFTER | C350SD>/AB-HB | Z/168 | 58.2 | +4.784 | +6.320 | 125
2 x RAFTER | C350SD>/HB(18deg)-AB | Z/168 | 58.2 | +4.784 | +6.320 | 125
2 x COLUMN | C350SD>/HB(18deg) | Z/1501 | 75.7 | +0.000 | +5.057 | 125
2 x APEX BRACE | C350SD>/HB(18deg)-HB | Z/2514 | 36.8 | +5.433 | +5.783 | 125
2 x HAUNCH BRACE | C350SD>/HB(18deg)-AB | Z/2513 | 13.1 | +4.073 | +4.939 | 125
3 x FASCIA | C350SD>/HB | Z/561 | 3.5 | +4.902 | +5.054 | 64
3 x TH | C350SD>/HB | Z/562 | 1.8 | +4.556 | +4.681 | 125
3 x TH | C350SD>/AB-HB | Z/562 | 1.8 | +5.541 | +5.637 | 125
3 x FASCIA | C350SD>/HB(18deg) | Z/561 | 3.5 | +4.902 | +5.054 | 64
3 x TH | C350SD>/HB(18deg) | Z/562 | 1.8 | +4.556 | +4.681 | 125
3 x TH | C350SD>/HB(18deg)-AB | Z/562 | 1.8 | +5.541 | +5.637 | 125
PLATE | C350SD>/AB-HB | Z/1117 | 10.8 | +4.577 | +5.247 | 128
PLATE | C350SD>/HB(18deg)-AB | Z/1118 | 10.8 | +4.577 | +5.247 | 128
2 x PLATE | C350SD>/HB(18deg)-HB | Z/1122 | 11.7 | +5.849 | +6.357 | 128
APEX BRACING PLATE | C350SD>/HB(25deg)-AB | PL/1937 | 12.9 | +5.917 | +6.330 | 128
HAUNCH BRACING PLATE | C350SD>/HB(25deg)-AB | PL/1936 | 18.7 | +4.724 | +5.899 | 128
2 x FASCIA BRACKET | C350SD>/HB | Z/52 | 0.2 | +4.893 | +5.050 | 157.2
2 x FASCIA BRACKET | C350SD>/HB(25deg) | Z/52 | 0.2 | +4.893 | +5.050 | 157.2
2 x COLUMN | C350SD>/HB | Z/1503 | 75.5 | +0.000 | +5.050 | 125
2 x RAFTER | C350SD>/AB-HB | Z/171 | 60.4 | +4.851 | +6.876 | 125
2 x RAFTER | C350SD>/HB(25deg)-AB | Z/171 | 60.4 | +4.851 | +6.876 | 125
2 x COLUMN | C350SD>/HB(25deg) | Z/1503 | 75.5 | +0.000 | +5.050 | 125
2 x APEX BRACE | C350SD>/HB(25deg)-HB | Z/2514 | 36.8 | +5.920 | +6.270 | 125
2 x HAUNCH BRACE | C350SD>/HB(25deg)-AB | Z/2515 | 16.3 | +4.113 | +5.129 | 125
3 x FASCIA | C350SD>/HB | Z/561 | 3.5 | +4.896 | +5.048 | 64
3 x TH | C350SD>/HB | Z/562 | 1.8 | +4.549 | +4.674 | 125
3 x TH | C350SD>/AB-HB | Z/562 | 1.8 | +5.732 | +5.834 | 125
3 x FASCIA | C350SD>/HB(25deg) | Z/561 | 3.5 | +4.896 | +5.048 | 64
3 x TH | C350SD>/HB(25deg) | Z/562 | 1.8 | +4.549 | +4.674 | 125
3 x TH | C350SD>/HB(25deg)-AB | Z/562 | 1.8 | +5.732 | +5.834 | 125
PLATE | C350SD>/AB-HB | Z/1115 | 11.7 | +4.577 | +5.345 | 128
PLATE | C350SD>/HB(25deg)-AB | Z/1116 | 11.7 | +4.577 | +5.345 | 128
2 x PLATE | C350SD>/HB(25deg)-HB | Z/1123 | 12.4 | +6.373 | +6.947 | 128
APEX BRACING PLATE | C350SD>/HB(25deg)-AB | PL/1948 | 12.9 | +5.917 | +6.330 | 128
APEX BRACING PLATE | C350SD>/HB(18deg)-AB | PL/1946 | 16.8 | +5.430 | +5.834 | 128
APEX BRACING PLATE | C350SD>/HB(15deg)-AB | PL/1944 | 19.6 | +5.232 | +5.630 | 128
APEX BRACING PLATE | C350SD>/HB(12deg)-AB | PL/1942 | 23.7 | +5.039 | +5.430 | 128
HAUNCH BRACING PLATE | C350SD>/HB(25deg)-AB | PL/1947 | 18.7 | +4.724 | +5.899 | 128
HAUNCH BRACING PLATE | C350SD>/HB(18deg)-AB | PL/1945 | 14.4 | +4.534 | +5.526 | 128
HAUNCH BRACING PLATE | C350SD>/HB(15deg)-AB | PL/1943 | 13.1 | +4.484 | +5.423 | 128
HAUNCH BRACING PLATE | C350SD>/HB(12deg)-AB | PL/1941 | 12.1 | +4.435 | +5.329 | 128
APEX BRACING PLATE | C350SD/HB(12deg)-AB | PL/1920 | 18.7 | +5.023 | +5.414 | 99
APEX BRACING PLATE | C350SD/HB(12deg)-AB | PL/1909 | 18.7 | +5.023 | +5.414 | 99
HAUNCH BRACING PLATE | C350SD/HB(12deg)-AB | PL/1919 | 9.8 | +4.494 | +5.334 | 99
4 x FASCIA BRACKET | C350SD/HB | Z/52 | 0.2 | +4.906 | +5.063 | 157.2
2 x FASCIA BRACKET | C350SD/HB(12deg) | Z/52 | 0.2 | +4.906 | +5.063 | 157.2
3 x COLUMN | C350SD/HB | Z/2418 | 75.7 | +0.000 | +5.063 | 125
2 x RAFTER | C350SD/AB-HB | Z/2420 | 57.1 | +4.734 | +5.871 | 125
2 x RAFTER | C350SD/HB(12deg)-AB | Z/2507 | 57.1 | +4.734 | +5.871 | 125
2 x COLUMN | C350SD/HB(12deg) | Z/2418 | 75.7 | +0.000 | +5.063 | 125
2 x APEX BRACE | C350SD/HB(12deg)-HB | Z/2458 | 36.4 | +5.026 | +5.326 | 96
HAUNCH BRACING PLATE | C350SD/HB(12deg)-AB | PL/1908 | 9.8 | +4.494 | +5.334 | 99
2 x HAUNCH BRACE | C350SD/HB(12deg)-AB | Z/2511 | 12.9 | +3.920 | +4.864 | 96
2 x FASCIA | C300SD-C350SD/HB | Z/561 | 3.5 | +4.909 | +5.061 | 64
6 x TH | C300SD-C350SD/HB | Z/562 | 1.8 | +4.562 | +4.687 | 125
TH | C300SD-C350SD/AB-HB | Z/562 | 1.8 | +5.365 | +5.455 | 125
FASCIA | C300SD-C350SD/HB(12deg) | Z/561 | 3.5 | +4.909 | +5.061 | 64
4 x TH | C300SD-C350SD/HB(12deg) | Z/562 | 1.8 | +4.562 | +4.687 | 125
TH | C300SD-C350SD/HB(12deg)-AB | Z/562 | 1.8 | +5.365 | +5.455 | 125
PLATE | C350SD/AB-HB | Z/1432 | 10.1 | +4.577 | +5.164 | 128
PLATE | C350SD/HB(12deg)-AB | Z/666 | 10.1 | +4.577 | +5.164 | 128
2 x PLATE | C350SD/AB | Z/667 | 11.1 | +5.433 | +5.887 | 128
APEX BRACING PLATE | C350SD/HB(15deg)-AB | PL/1922 | 15.4 | +5.199 | +5.597 | 99
HAUNCH BRACING PLATE | C350SD/HB(15deg)-AB | PL/1921 | 10.6 | +4.523 | +5.400 | 99
2 x FASCIA BRACKET | C350SD/HB | Z/52 | 0.2 | +4.903 | +5.060 | 157.2
2 x FASCIA BRACKET | C350SD/HB(15deg) | Z/52 | 0.2 | +4.903 | +5.060 | 157.2
2 x COLUMN | C350SD/HB | Z/1499 | 75.7 | +0.000 | +5.060 | 125
2 x RAFTER | C350SD/AB-HB | Z/165 | 57.6 | +4.758 | +6.093 | 125
2 x RAFTER | C350SD/HB(15deg)-AB | Z/2508 | 57.6 | +4.758 | +6.093 | 125
2 x COLUMN | C350SD/HB(15deg) | Z/1499 | 75.7 | +0.000 | +5.060 | 125
APEX BRACING PLATE | C350SD/HB(15deg)-AB | PL/1911 | 15.4 | +5.199 | +5.597 | 99
2 x APEX BRACE | C350SD/HB(15deg)-HB | Z/2458 | 36.4 | +5.202 | +5.502 | 96
HAUNCH BRACING PLATE | C350SD/HB(15deg)-AB | PL/1910 | 10.6 | +4.523 | +5.400 | 99
2 x HAUNCH BRACE | C350SD/HB(15deg)-AB | Z/2512 | 11.1 | +4.049 | +4.893 | 96
4 x FASCIA | C300SD-C350SD/HB | Z/561 | 3.5 | +4.906 | +5.058 | 64
4 x TH | C300SD-C350SD/HB | Z/562 | 1.8 | +4.559 | +4.684 | 125
TH | C300SD-C350SD/AB-HB | Z/562 | 1.8 | +5.453 | +5.547 | 125
4 x FASCIA | C300SD-C350SD/HB(15deg) | Z/561 | 3.5 | +4.906 | +5.058 | 64
4 x TH | C300SD-C350SD/HB(15deg) | Z/562 | 1.8 | +4.559 | +4.684 | 125
TH | C300SD-C350SD/HB(15deg)-AB | Z/562 | 1.8 | +5.453 | +5.547 | 125
PLATE | C350SD/AB-HB | Z/1119 | 10.5 | +4.577 | +5.205 | 128
PLATE | C350SD/HB(15deg)-AB | Z/1120 | 10.5 | +4.577 | +5.205 | 128
2 x PLATE | C350SD/HB(15deg)-HB | Z/1121 | 11.4 | +5.638 | +6.119 | 128
APEX BRACING PLATE | C350SD/HB(18deg)-AB | PL/1924 | 13.3 | +5.379 | +5.783 | 99
HAUNCH BRACING PLATE | C350SD/HB(18deg)-AB | PL/1923 | 11.4 | +4.606 | +5.529 | 99
2 x FASCIA BRACKET | C350SD/HB | Z/52 | 0.2 | +4.900 | +5.057 | 157.2
2 x FASCIA BRACKET | C350SD/HB(18deg) | Z/52 | 0.2 | +4.900 | +5.057 | 157.2
2 x COLUMN | C350SD/HB | Z/1501 | 75.7 | +0.000 | +5.057 | 125
2 x RAFTER | C350SD/AB-HB | Z/168 | 58.2 | +4.784 | +6.320 | 125
2 x RAFTER | C350SD/HB(18deg)-AB | Z/2509 | 58.2 | +4.784 | +6.320 | 125
2 x COLUMN | C350SD/HB(18deg) | Z/1501 | 75.7 | +0.000 | +5.057 | 125
APEX BRACING PLATE | C350SD/HB(18deg)-AB | PL/1913 | 13.3 | +5.379 | +5.783 | 99
2 x APEX BRACE | C350SD/HB(18deg)-HB | Z/2458 | 36.4 | +5.382 | +5.682 | 96
HAUNCH BRACING PLATE | C350SD/HB(18deg)-AB | PL/1912 | 11.4 | +4.606 | +5.529 | 99
2 x HAUNCH BRACE | C350SD/HB(18deg)-AB | Z/2511 | 12.9 | +4.033 | +4.976 | 96
4 x FASCIA | C300SD-C350SD/HB | Z/561 | 3.5 | +4.902 | +5.054 | 64
4 x TH | C300SD-C350SD/HB | Z/562 | 1.8 | +4.556 | +4.681 | 125
TH | C300SD-C350SD/AB-HB | Z/562 | 1.8 | +5.541 | +5.637 | 125
4 x FASCIA | C300SD-C350SD/HB(18deg) | Z/561 | 3.5 | +4.902 | +5.054 | 64
4 x TH | C300SD-C350SD/HB(18deg) | Z/562 | 1.8 | +4.556 | +4.681 | 125
TH | C300SD-C350SD/HB(18deg)-AB | Z/562 | 1.8 | +5.541 | +5.637 | 125
PLATE | C350SD/AB-HB | Z/1117 | 10.8 | +4.577 | +5.247 | 128
PLATE | C350SD/HB(18deg)-AB | Z/1118 | 10.8 | +4.577 | +5.247 | 128
2 x PLATE | C350SD/HB(18deg)-HB | Z/1122 | 11.7 | +5.849 | +6.357 | 128
APEX BRACING PLATE | C350SD/HB(25deg)-AB | PL/1926 | 10.3 | +5.822 | +6.235 | 99
HAUNCH BRACING PLATE | C350SD/HB(25deg)-AB | PL/1925 | 14.9 | +4.742 | +5.820 | 99
2 x FASCIA BRACKET | C350SD/HB | Z/52 | 0.2 | +4.893 | +5.050 | 157.2
2 x FASCIA BRACKET | C350SD/HB(25deg) | Z/52 | 0.2 | +4.893 | +5.050 | 157.2
2 x COLUMN | C350SD/HB | Z/1503 | 75.5 | +0.000 | +5.050 | 125
2 x RAFTER | C350SD/AB-HB | Z/171 | 60.4 | +4.851 | +6.876 | 125
2 x RAFTER | C350SD/HB(25deg)-AB | Z/2510 | 60.4 | +4.851 | +6.876 | 125
2 x COLUMN | C350SD/HB(25deg) | Z/1503 | 75.5 | +0.000 | +5.050 | 125
APEX BRACING PLATE | C350SD/HB(25deg)-AB | PL/1915 | 10.3 | +5.822 | +6.235 | 99
2 x APEX BRACE | C350SD/HB(25deg)-HB | Z/2458 | 36.4 | +5.825 | +6.125 | 96
HAUNCH BRACING PLATE | C350SD/HB(25deg)-AB | PL/1914 | 14.9 | +4.742 | +5.820 | 99
2 x HAUNCH BRACE | C350SD/HB(25deg)-AB | Z/2511 | 12.9 | +4.168 | +5.112 | 96
4 x FASCIA | C300SD-C350SD/HB | Z/561 | 3.5 | +4.896 | +5.048 | 64
TH | C300SD-C350SD/HB | Z/562 | 1.8 | +4.549 | +4.674 | 125
TH | C300SD-C350SD/AB-HB | Z/562 | 1.8 | +5.732 | +5.834 | 125
4 x FASCIA | C300SD-C350SD/HB(25deg) | Z/561 | 3.5 | +4.896 | +5.048 | 64
TH | C300SD-C350SD/HB(25deg) | Z/562 | 1.8 | +4.549 | +4.674 | 125
TH | C300SD-C350SD/HB(25deg)-AB | Z/562 | 1.8 | +5.732 | +5.834 | 125
PLATE | C350SD/AB-HB | Z/1115 | 11.7 | +4.577 | +5.345 | 128
PLATE | C350SD/HB(25deg)-AB | Z/1116 | 11.7 | +4.577 | +5.345 | 128
2 x PLATE | C350SD/HB(25deg)-HB | Z/1123 | 12.4 | +6.373 | +6.947 | 128
APEX BRACING PLATE | C300SD-C350SD/HB(12deg)-AB | PL/1898 | 17.6 | +5.069 | +5.411 | 99
HAUNCH BRACING PLATE | C300SD-C350SD/HB(12deg)-AB | PL/1897 | 9.1 | +4.509 | +5.300 | 554.6
2 x FASCIA BRACKET | C300SD-C350SD/HB | Z/52 | 0.2 | +4.906 | +5.063 | 157.2
2 x FASCIA BRACKET | C300SD-C350SD/HB(12deg) | Z/52 | 0.2 | +4.906 | +5.063 | 157.2
4 x COLUMN | C300SD-C350SD/HB | Z/2411 | 63.3 | +0.000 | +5.063 | 96
2 x RAFTER | C300SD-C350SD/AB-HB | Z/2413 | 48.2 | +4.772 | +5.868 | 96
2 x RAFTER | C300SD-C350SD/HB(12deg)-AB | Z/2502 | 48.2 | +4.772 | +5.868 | 96
2 x COLUMN | C300SD-C350SD/HB(12deg) | Z/2411 | 63.3 | +0.000 | +5.063 | 96
APEX BRACING PLATE | C300SD-C350SD/HB(12deg)-AB | PL/1887 | 17.6 | +5.069 | +5.411 | 99
2 x APEX BRACE | C300SD-C350SD/HB(12deg)-HB | Z/2458 | 36.4 | +5.072 | +5.372 | 96
HAUNCH BRACING PLATE | C300SD-C350SD/HB(12deg)-AB | PL/1886 | 9.1 | +4.509 | +5.300 | 554.6
2 x HAUNCH BRACE | C300SD-C350SD/HB(12deg)-AB | Z/2506 | 10.8 | +4.054 | +4.879 | 96
4 x FASCIA | C300SD-C350SD/HB | Z/561 | 3.5 | +4.908 | +5.060 | 64
3 x TH | C300SD-C350SD/AB-HB | Z/562 | 1.8 | +5.360 | +5.450 | 125
3 x FASCIA | C300SD-C350SD/HB(12deg) | Z/561 | 3.5 | +4.908 | +5.060 | 64
3 x TH | C300SD-C350SD/HB(12deg)-AB | Z/562 | 1.8 | +5.360 | +5.450 | 125
PLATE | C300SD-C350SD/AB-HB | Z/1543 | 8.8 | +4.577 | +5.153 | 99
PLATE | C300SD-C350SD/HB(12deg)-AB | Z/1542 | 8.8 | +4.577 | +5.153 | 99
2 x PLATE | C300SD-C350SD/AB | Z/957 | 9.3 | +5.479 | +5.882 | 99
APEX BRACING PLATE | C300SD-C350SD/HB(15deg)-AB | PL/1900 | 14.6 | +5.244 | +5.594 | 99
HAUNCH BRACING PLATE | C300SD-C350SD/HB(15deg)-AB | PL/1899 | 9.8 | +4.556 | +5.385 | 562.81
2 x FASCIA BRACKET | C300SD-C350SD/HB | Z/52 | 0.2 | +4.903 | +5.060 | 157.2
2 x FASCIA BRACKET | C300SD-C350SD/HB(15deg) | Z/52 | 0.2 | +4.903 | +5.060 | 157.2
2 x COLUMN | C300SD-C350SD/HB | Z/1484 | 63.3 | +0.000 | +5.060 | 96
2 x RAFTER | C300SD-C350SD/AB-HB | Z/145 | 48.6 | +4.793 | +6.090 | 96
2 x RAFTER | C300SD-C350SD/HB(15deg)-AB | Z/2503 | 48.6 | +4.793 | +6.090 | 96
2 x COLUMN | C300SD-C350SD/HB(15deg) | Z/1484 | 63.3 | +0.000 | +5.060 | 96
APEX BRACING PLATE | C300SD-C350SD/HB(15deg)-AB | PL/1889 | 14.6 | +5.244 | +5.594 | 99
2 x APEX BRACE | C300SD-C350SD/HB(15deg)-HB | Z/2458 | 36.4 | +5.247 | +5.547 | 96
HAUNCH BRACING PLATE | C300SD-C350SD/HB(15deg)-AB | PL/1888 | 9.8 | +4.556 | +5.385 | 562.81
2 x HAUNCH BRACE | C300SD-C350SD/HB(15deg)-AB | Z/2506 | 10.8 | +4.102 | +4.926 | 96
3 x TH | C300SD-C350SD/AB-HB | Z/562 | 1.8 | +5.447 | +5.540 | 125
3 x TH | C300SD-C350SD/HB(15deg)-AB | Z/562 | 1.8 | +5.447 | +5.540 | 125
PLATE | C300SD-C350SD/AB-HB | Z/1092 | 9.1 | +4.577 | +5.192 | 99
PLATE | C300SD-C350SD/HB(15deg)-AB | Z/1093 | 9.1 | +4.577 | +5.192 | 99
2 x PLATE | C300SD-C350SD/AB | Z/1094 | 9.6 | +5.683 | +6.112 | 99
APEX BRACING PLATE | C300SD-C350SD/HB(18deg)-AB | PL/1902 | 12.6 | +5.424 | +5.780 | 99
HAUNCH BRACING PLATE | C300SD-C350SD/HB(18deg)-AB | PL/1901 | 10.6 | +4.604 | +5.479 | 570.302
2 x FASCIA BRACKET | C300SD-C350SD/HB | Z/52 | 0.2 | +4.900 | +5.057 | 157.2
2 x FASCIA BRACKET | C300SD-C350SD/HB(18deg) | Z/52 | 0.2 | +4.900 | +5.057 | 157.2
2 x COLUMN | C300SD-C350SD/HB | Z/1486 | 63.2 | +0.000 | +5.057 | 96
2 x RAFTER | C300SD-C350SD/AB-HB | Z/148 | 49.2 | +4.815 | +6.317 | 96
2 x RAFTER | C300SD-C350SD/HB(18deg)-AB | Z/2504 | 49.2 | +4.815 | +6.317 | 96
2 x COLUMN | C300SD-C350SD/HB(18deg) | Z/1486 | 63.2 | +0.000 | +5.057 | 96
APEX BRACING PLATE | C300SD-C350SD/HB(18deg)-AB | PL/1891 | 12.6 | +5.424 | +5.780 | 99
2 x APEX BRACE | C300SD-C350SD/HB(18deg)-HB | Z/2458 | 36.4 | +5.427 | +5.727 | 96
HAUNCH BRACING PLATE | C300SD-C350SD/HB(18deg)-AB | PL/1890 | 10.6 | +4.604 | +5.479 | 570.302
2 x HAUNCH BRACE | C300SD-C350SD/HB(18deg)-AB | Z/2506 | 10.8 | +4.149 | +4.974 | 96
3 x TH | C300SD-C350SD/AB-HB | Z/562 | 1.8 | +5.537 | +5.633 | 125
3 x TH | C300SD-C350SD/HB(18deg)-AB | Z/562 | 1.8 | +5.537 | +5.633 | 125
PLATE | C300SD-C350SD/AB-HB | Z/1090 | 9.3 | +4.577 | +5.231 | 99
PLATE | C300SD-C350SD/HB(18deg)-AB | Z/1091 | 9.3 | +4.577 | +5.231 | 99
2 x PLATE | C300SD-C350SD/AB | Z/1095 | 9.8 | +5.893 | +6.348 | 99
APEX BRACING PLATE | C300SD-C350SD/HB(25deg)-AB | PL/1904 | 9.8 | +5.866 | +6.234 | 99
HAUNCH BRACING PLATE | C300SD-C350SD/HB(25deg)-AB | PL/1903 | 13.9 | +4.718 | +5.753 | 99
2 x FASCIA BRACKET | C300SD-C350SD/HB | Z/52 | 0.2 | +4.893 | +5.050 | 157.2
2 x FASCIA BRACKET | C300SD-C350SD/HB(25deg) | Z/52 | 0.2 | +4.893 | +5.050 | 157.2
2 x COLUMN | C300SD-C350SD/HB | Z/1488 | 63.2 | +0.000 | +5.050 | 96
2 x RAFTER | C300SD-C350SD/AB-HB | Z/151 | 51.2 | +4.873 | +6.874 | 96
2 x RAFTER | C300SD-C350SD/HB(25deg)-AB | Z/2505 | 51.2 | +4.873 | +6.874 | 96
2 x COLUMN | C300SD-C350SD/HB(25deg) | Z/1488 | 63.2 | +0.000 | +5.050 | 96
APEX BRACING PLATE | C300SD-C350SD/HB(25deg)-AB | PL/1893 | 9.8 | +5.866 | +6.234 | 99
2 x APEX BRACE | C300SD-C350SD/HB(25deg)-HB | Z/2458 | 36.4 | +5.869 | +6.169 | 96
HAUNCH BRACING PLATE | C300SD-C350SD/HB(25deg)-AB | PL/1892 | 13.9 | +4.718 | +5.753 | 99
2 x HAUNCH BRACE | C300SD-C350SD/HB(25deg)-AB | Z/2506 | 10.8 | +4.263 | +5.088 | 96
3 x TH | C300SD-C350SD/HB | Z/562 | 1.8 | +4.550 | +4.675 | 125
3 x TH | C300SD-C350SD/AB-HB | Z/562 | 1.8 | +5.722 | +5.824 | 125
3 x TH | C300SD-C350SD/HB(25deg) | Z/562 | 1.8 | +4.550 | +4.675 | 125
3 x TH | C300SD-C350SD/HB(25deg)-AB | Z/562 | 1.8 | +5.722 | +5.824 | 125
PLATE | C300SD-C350SD/AB-HB | Z/1088 | 10.1 | +4.578 | +5.322 | 99
PLATE | C300SD-C350SD/HB(25deg)-AB | Z/1089 | 10.1 | +4.578 | +5.322 | 99
2 x PLATE | C300SD-C350SD/HB(25deg)-HB | Z/1096 | 10.5 | +6.416 | +6.935 | 99
APEX BRACING PLATE | C300SD/HB(12deg)-AB | PL/1876 | 13.3 | +5.115 | +5.457 | 79
HAUNCH BRACING PLATE | C300SD/HB(12deg)-AB | PL/1875 | 7.2 | +4.550 | +5.291 | 79
4 x FASCIA BRACKET | C300SD/HB | Z/52 | 0.2 | +4.906 | +5.063 | 157.2
2 x FASCIA BRACKET | C300SD/HB(12deg) | Z/52 | 0.2 | +4.906 | +5.063 | 157.2
3 x COLUMN | C300SD/HB | Z/2411 | 63.3 | +0.000 | +5.063 | 96
2 x RAFTER | C300SD/AB-HB | Z/2413 | 48.2 | +4.772 | +5.868 | 96
2 x RAFTER | C300SD/HB(12deg)-AB | Z/2497 | 48.2 | +4.772 | +5.868 | 96
2 x COLUMN | C300SD/HB(12deg) | Z/2411 | 63.3 | +0.000 | +5.063 | 96
APEX BRACING PLATE | C300SD/HB(12deg)-AB | PL/1865 | 13.3 | +5.115 | +5.457 | 79
2 x APEX BRACE | C300SD/HB(12deg)-HB | Z/2447 | 18.5 | +5.118 | +5.372 | 76
HAUNCH BRACING PLATE | C300SD/HB(12deg)-AB | PL/1804 | 7.2 | +4.550 | +5.291 | 79
2 x HAUNCH BRACE | C300SD/HB(12deg)-AB | Z/2501 | 5.8 | +4.056 | +4.888 | 76
6 x FASCIA | C250SD-C300SD/HB | Z/561 | 3.5 | +4.908 | +5.060 | 64
6 x TH | C250SD-C300SD/HB | Z/562 | 1.8 | +4.562 | +4.687 | 125
TH | C250SD-C300SD/AB-HB | Z/562 | 1.8 | +5.360 | +5.450 | 125
4 x FASCIA | C250SD-C300SD/HB(12deg) | Z/561 | 3.5 | +4.908 | +5.060 | 64
4 x TH | C250SD-C300SD/HB(12deg) | Z/562 | 1.8 | +4.562 | +4.687 | 125
TH | C250SD-C300SD/HB(12deg)-AB | Z/562 | 1.8 | +5.360 | +5.450 | 125
PLATE | C300SD/AB-HB | Z/1543 | 8.8 | +4.577 | +5.153 | 99
PLATE | C300SD/HB(12deg)-AB | Z/1542 | 8.8 | +4.577 | +5.153 | 99
2 x PLATE | C300SD/AB | Z/957 | 9.3 | +5.479 | +5.882 | 99
APEX BRACING PLATE | C300SD/HB(15deg)-AB | PL/1878 | 11.1 | +5.290 | +5.640 | 79
HAUNCH BRACING PLATE | C300SD/HB(15deg)-AB | PL/1877 | 7.7 | +4.600 | +5.372 | 79
2 x FASCIA BRACKET | C300SD/HB | Z/52 | 0.2 | +4.903 | +5.060 | 157.2
2 x FASCIA BRACKET | C300SD/HB(15deg) | Z/52 | 0.2 | +4.903 | +5.060 | 157.2
2 x COLUMN | C300SD/HB | Z/1484 | 63.3 | +0.000 | +5.060 | 96
2 x RAFTER | C300SD/AB-HB | Z/145 | 48.6 | +4.793 | +6.090 | 96
2 x RAFTER | C300SD/HB(15deg)-AB | Z/2498 | 48.6 | +4.793 | +6.090 | 96
2 x COLUMN | C300SD/HB(15deg) | Z/1484 | 63.3 | +0.000 | +5.060 | 96
APEX BRACING PLATE | C300SD/HB(15deg)-AB | PL/1867 | 11.1 | +5.290 | +5.640 | 79
2 x APEX BRACE | C300SD/HB(15deg)-HB | Z/2447 | 18.5 | +5.293 | +5.547 | 76
HAUNCH BRACING PLATE | C300SD/HB(15deg)-AB | PL/1866 | 7.7 | +4.600 | +5.372 | 79
2 x HAUNCH BRACE | C300SD/HB(15deg)-AB | Z/2501 | 5.8 | +4.105 | +4.937 | 76
FASCIA | C250SD-C300SD/HB | Z/561 | 3.5 | +4.906 | +5.058 | 64
4 x TH | C250SD-C300SD/HB | Z/562 | 1.8 | +4.559 | +4.684 | 125
TH | C250SD-C300SD/AB-HB | Z/562 | 1.8 | +5.447 | +5.540 | 125
FASCIA | C250SD-C300SD/HB(15deg) | Z/561 | 3.5 | +4.906 | +5.058 | 64
4 x TH | C250SD-C300SD/HB(15deg) | Z/562 | 1.8 | +4.559 | +4.684 | 125
TH | C250SD-C300SD/HB(15deg)-AB | Z/562 | 1.8 | +5.447 | +5.540 | 125
PLATE | C300SD/AB-HB | Z/1092 | 9.1 | +4.577 | +5.192 | 99
PLATE | C300SD/HB(15deg)-AB | Z/1093 | 9.1 | +4.577 | +5.192 | 99
2 x PLATE | C300SD/AB | Z/1094 | 9.6 | +5.683 | +6.112 | 99
APEX BRACING PLATE | C300SD/HB(18deg)-AB | PL/1880 | 9.6 | +5.470 | +5.826 | 79
HAUNCH BRACING PLATE | C300SD/HB(18deg)-AB | PL/1879 | 8.4 | +4.649 | +5.460 | 79
2 x FASCIA BRACKET | C300SD/HB | Z/52 | 0.2 | +4.900 | +5.057 | 157.2
2 x FASCIA BRACKET | C300SD/HB(18deg) | Z/52 | 0.2 | +4.900 | +5.057 | 157.2
2 x COLUMN | C300SD/HB | Z/1486 | 63.2 | +0.000 | +5.057 | 96
2 x RAFTER | C300SD/AB-HB | Z/148 | 49.2 | +4.815 | +6.317 | 96
2 x RAFTER | C300SD/HB(18deg)-AB | Z/2499 | 49.2 | +4.815 | +6.317 | 96
2 x COLUMN | C300SD/HB(18deg) | Z/1486 | 63.2 | +0.000 | +5.057 | 96
APEX BRACING PLATE | C300SD/HB(18deg)-AB | PL/1869 | 9.6 | +5.470 | +5.826 | 79
2 x APEX BRACE | C300SD/HB(18deg)-HB | Z/2447 | 18.5 | +5.473 | +5.727 | 76
HAUNCH BRACING PLATE | C300SD/HB(18deg)-AB | PL/1868 | 8.4 | +4.649 | +5.460 | 79
2 x HAUNCH BRACE | C300SD/HB(18deg)-AB | Z/2501 | 5.8 | +4.155 | +4.987 | 76
4 x FASCIA | C250SD-C300SD/HB | Z/561 | 3.5 | +4.902 | +5.054 | 64
4 x TH | C250SD-C300SD/HB | Z/562 | 1.8 | +4.556 | +4.681 | 125
TH | C250SD-C300SD/AB-HB | Z/562 | 1.8 | +5.537 | +5.633 | 125
4 x FASCIA | C250SD-C300SD/HB(18deg) | Z/561 | 3.5 | +4.902 | +5.054 | 64
4 x TH | C250SD-C300SD/HB(18deg) | Z/562 | 1.8 | +4.556 | +4.681 | 125
TH | C250SD-C300SD/HB(18deg)-AB | Z/562 | 1.8 | +5.537 | +5.633 | 125
PLATE | C300SD/AB-HB | Z/1090 | 9.3 | +4.577 | +5.231 | 99
PLATE | C300SD/HB(18deg)-AB | Z/1091 | 9.3 | +4.577 | +5.231 | 99
2 x PLATE | C300SD/AB | Z/1095 | 9.8 | +5.893 | +6.348 | 99
APEX BRACING PLATE | C300SD/HB(25deg)-AB | PL/1882 | 7.7 | +5.912 | +6.280 | 79
HAUNCH BRACING PLATE | C300SD/HB(25deg)-AB | PL/1881 | 10.8 | +4.769 | +5.713 | 79
2 x FASCIA BRACKET | C300SD/HB | Z/52 | 0.2 | +4.893 | +5.050 | 157.2
2 x FASCIA BRACKET | C300SD/HB(25deg) | Z/52 | 0.2 | +4.893 | +5.050 | 157.2
2 x COLUMN | C300SD/HB | Z/1488 | 63.2 | +0.000 | +5.050 | 96
2 x RAFTER | C300SD/AB-HB | Z/151 | 51.2 | +4.873 | +6.874 | 96
2 x RAFTER | C300SD/HB(25deg)-AB | Z/2500 | 51.2 | +4.873 | +6.874 | 96
2 x COLUMN | C300SD/HB(25deg) | Z/1488 | 63.2 | +0.000 | +5.050 | 96
APEX BRACING PLATE | C300SD/HB(25deg)-AB | PL/1871 | 7.7 | +5.912 | +6.280 | 79
2 x APEX BRACE | C300SD/HB(25deg)-HB | Z/2447 | 18.5 | +5.915 | +6.169 | 76
HAUNCH BRACING PLATE | C300SD/HB(25deg)-AB | PL/1870 | 10.8 | +4.769 | +5.713 | 79
2 x HAUNCH BRACE | C300SD/HB(25deg)-AB | Z/2501 | 5.8 | +4.275 | +5.107 | 76
FASCIA | C250SD-C300SD/HB | Z/561 | 3.5 | +4.896 | +5.048 | 64
TH | C250SD-C300SD/HB | Z/562 | 1.8 | +4.550 | +4.675 | 125
TH | C250SD-C300SD/AB-HB | Z/562 | 1.8 | +5.722 | +5.824 | 125
FASCIA | C250SD-C300SD/HB(25deg) | Z/561 | 3.5 | +4.896 | +5.048 | 64
TH | C250SD-C300SD/HB(25deg) | Z/562 | 1.8 | +4.550 | +4.675 | 125
TH | C250SD-C300SD/HB(25deg)-AB | Z/562 | 1.8 | +5.722 | +5.824 | 125
PLATE | C300SD/AB-HB | Z/1088 | 10.1 | +4.578 | +5.322 | 99
PLATE | C300SD/HB(25deg)-AB | Z/1089 | 10.1 | +4.578 | +5.322 | 99
2 x PLATE | C300SD/HB(25deg)-HB | Z/1096 | 10.5 | +6.416 | +6.935 | 99
PLATE | C350SD>/AB-HB | Z/666 | 10.1 | +4.577 | +5.164 | 128
PLATE | C300SD-C350SD/AB-HB | Z/1542 | 8.8 | +4.577 | +5.153 | 99
PLATE | C350SD>/HB(12deg)-AB | Z/1432 | 10.1 | +4.577 | +5.164 | 128
PLATE | C300SD-C350SD/HB(12deg)-AB | Z/1543 | 8.8 | +4.577 | +5.153 | 99
PLATE | C350SD>/AB-HB | Z/1120 | 10.5 | +4.577 | +5.205 | 128
PLATE | C300SD-C350SD/AB-HB | Z/1093 | 9.1 | +4.577 | +5.192 | 99
PLATE | C350SD>/HB(15deg)-AB | Z/1119 | 10.5 | +4.577 | +5.205 | 128
PLATE | C300SD-C350SD/HB(15deg)-AB | Z/1092 | 9.1 | +4.577 | +5.192 | 99
PLATE | C350SD>/AB-HB | Z/1118 | 10.8 | +4.577 | +5.247 | 128
PLATE | C300SD-C350SD/AB-HB | Z/1091 | 9.3 | +4.577 | +5.231 | 99
PLATE | C350SD>/HB(18deg)-AB | Z/1117 | 10.8 | +4.577 | +5.247 | 128
PLATE | C300SD-C350SD/HB(18deg)-AB | Z/1090 | 9.3 | +4.577 | +5.231 | 99
PLATE | C350SD>/AB-HB | Z/1116 | 11.7 | +4.577 | +5.345 | 128
PLATE | C300SD-C350SD/AB-HB | Z/1089 | 10.1 | +4.578 | +5.322 | 99
PLATE | C350SD>/HB(25deg)-AB | Z/1115 | 11.7 | +4.577 | +5.345 | 128
PLATE | C300SD-C350SD/HB(25deg)-AB | Z/1088 | 10.1 | +4.578 | +5.322 | 99
APEX BRACING PLATE | C250SD-C300SD/HB(12deg)-AB | PL/1794 | 12.6 | +5.156 | +5.454 | 79
APEX BRACING PLATE | C250SD-C300SD/HB(12deg)-AB | PL/1783 | 12.6 | +5.156 | +5.454 | 79
2 x APEX BRACE | C250SD-C300SD/HB(12deg)-HB | Z/2447 | 18.5 | +5.159 | +5.413 | 76
APEX BRACING PLATE | C250SD-C300SD/HB(15deg)-AB | PL/1796 | 10.5 | +5.331 | +5.637 | 79
APEX BRACING PLATE | C250SD-C300SD/HB(15deg)-AB | PL/1785 | 10.5 | +5.331 | +5.637 | 79
2 x APEX BRACE | C250SD-C300SD/HB(15deg)-HB | Z/2447 | 18.5 | +5.334 | +5.588 | 76
APEX BRACING PLATE | C250SD-C300SD/HB(18deg)-AB | PL/1798 | 9.1 | +5.510 | +5.822 | 79
APEX BRACING PLATE | C250SD-C300SD/HB(18deg)-AB | PL/1787 | 9.1 | +5.510 | +5.822 | 79
2 x APEX BRACE | C250SD-C300SD/HB(18deg)-HB | Z/2447 | 18.5 | +5.513 | +5.767 | 76
APEX BRACING PLATE | C250SD-C300SD/HB(25deg)-AB | PL/1800 | 7.2 | +5.951 | +6.278 | 79
APEX BRACING PLATE | C250SD-C300SD/HB(25deg)-AB | PL/1789 | 7.2 | +5.951 | +6.278 | 79
2 x APEX BRACE | C250SD-C300SD/HB(25deg)-HB | Z/2447 | 18.5 | +5.954 | +6.208 | 76
HAUNCH BRACING PLATE | C250SD-C300SD/HB(12deg)-AB | PL/1793 | 6.7 | +4.603 | +5.299 | 79
HAUNCH BRACING PLATE | C250SD-C300SD/HB(12deg)-AB | PL/1782 | 6.7 | +4.603 | +5.299 | 79
2 x HAUNCH BRACE | C250SD-C300SD/HB(12deg)-AB | Z/2496 | 6.5 | +4.034 | +4.940 | 76
HAUNCH BRACING PLATE | C250SD-C300SD/HB(15deg)-AB | PL/1795 | 7.2 | +4.654 | +5.383 | 79
HAUNCH BRACING PLATE | C250SD-C300SD/HB(15deg)-AB | PL/1784 | 7.2 | +4.654 | +5.383 | 79
2 x HAUNCH BRACE | C250SD-C300SD/HB(15deg)-AB | Z/2496 | 6.5 | +4.086 | +4.992 | 76
HAUNCH BRACING PLATE | C250SD-C300SD/HB(18deg)-AB | PL/1797 | 7.8 | +4.707 | +5.474 | 79
HAUNCH BRACING PLATE | C250SD-C300SD/HB(18deg)-AB | PL/1786 | 7.8 | +4.707 | +5.474 | 79
2 x HAUNCH BRACE | C250SD-C300SD/HB(18deg)-AB | Z/2496 | 6.5 | +4.138 | +5.044 | 76
HAUNCH BRACING PLATE | C250SD-C300SD/HB(25deg)-AB | PL/1799 | 10 | +4.833 | +5.735 | 79
HAUNCH BRACING PLATE | C250SD-C300SD/HB(25deg)-AB | PL/1788 | 10 | +4.833 | +5.735 | 79
2 x HAUNCH BRACE | C250SD-C300SD/HB(25deg)-AB | Z/2496 | 6.5 | +4.264 | +5.170 | 76
2 x FASCIA BRACKET | C250SD-C300SD/HB | Z/52 | 0.2 | +4.893 | +5.050 | 157.2
2 x FASCIA BRACKET | C250SD-C300SD/HB | Z/52 | 0.2 | +4.900 | +5.057 | 157.2
2 x FASCIA BRACKET | C250SD-C300SD/HB | Z/52 | 0.2 | +4.903 | +5.060 | 157.2
2 x FASCIA BRACKET | C250SD-C300SD/HB | Z/52 | 0.2 | +4.906 | +5.063 | 157.2
2 x FASCIA BRACKET | C250SD-C300SD/HB(25deg) | Z/52 | 0.2 | +4.893 | +5.050 | 157.2
2 x FASCIA BRACKET | C250SD-C300SD/HB(18deg) | Z/52 | 0.2 | +4.900 | +5.057 | 157.2
2 x FASCIA BRACKET | C250SD-C300SD/HB(12deg) | Z/52 | 0.2 | +4.906 | +5.063 | 157.2
2 x FASCIA BRACKET | C250SD-C300SD/HB(15deg) | Z/52 | 0.2 | +4.903 | +5.060 | 157.2
2 x COLUMN | C250SD-C300SD/HB | Z/1472 | 40.5 | +0.000 | +5.050 | 76
2 x COLUMN | C250SD-C300SD/HB | Z/1470 | 40.6 | +0.000 | +5.057 | 76
2 x COLUMN | C250SD-C300SD/HB | Z/1468 | 40.6 | +0.000 | +5.060 | 76
4 x COLUMN | C250SD-C300SD/HB | Z/2404 | 40.6 | +0.000 | +5.063 | 76
2 x RAFTER | C250SD-C300SD/AB-HB | Z/132 | 33.2 | +4.892 | +6.872 | 76
2 x RAFTER | C250SD-C300SD/HB(25deg)-AB | Z/2495 | 33.2 | +4.892 | +6.872 | 76
2 x COLUMN | C250SD-C300SD/HB(25deg) | Z/1472 | 40.5 | +0.000 | +5.050 | 76
2 x RAFTER | C250SD-C300SD/AB-HB | Z/129 | 31.9 | +4.844 | +6.313 | 76
2 x RAFTER | C250SD-C300SD/HB(18deg)-AB | Z/2494 | 31.9 | +4.844 | +6.313 | 76
2 x COLUMN | C250SD-C300SD/HB(18deg) | Z/1470 | 40.6 | +0.000 | +5.057 | 76
2 x RAFTER | C250SD-C300SD/AB-HB | Z/126 | 31.5 | +4.825 | +6.086 | 76
2 x RAFTER | C250SD-C300SD/HB(15deg)-AB | Z/2493 | 31.5 | +4.825 | +6.086 | 76
2 x COLUMN | C250SD-C300SD/HB(15deg) | Z/1468 | 40.6 | +0.000 | +5.060 | 76
2 x RAFTER | C250SD-C300SD/AB-HB | Z/2406 | 31.2 | +4.807 | +5.865 | 76
2 x RAFTER | C250SD-C300SD/HB(12deg)-AB | Z/2492 | 31.2 | +4.807 | +5.865 | 76
2 x COLUMN | C250SD-C300SD/HB(12deg) | Z/2404 | 40.6 | +0.000 | +5.063 | 76
3 x FASCIA | C250SD-C300SD/HB | Z/561 | 3.5 | +4.895 | +5.047 | 64
3 x TH | C250SD-C300SD/HB | Z/562 | 1.8 | +4.549 | +4.674 | 125
3 x TH | C250SD-C300SD/AB-HB | Z/562 | 1.8 | +5.713 | +5.815 | 125
3 x TH | C250SD-C300SD/AB-HB | Z/562 | 1.8 | +5.526 | +5.622 | 125
3 x FASCIA | C250SD-C300SD/HB | Z/561 | 3.5 | +4.905 | +5.057 | 64
3 x TH | C250SD-C300SD/AB-HB | Z/562 | 1.8 | +5.441 | +5.534 | 125
3 x TH | C250SD-C300SD/AB-HB | Z/562 | 1.8 | +5.355 | +5.445 | 125
3 x FASCIA | C250SD-C300SD/HB(25deg) | Z/561 | 3.5 | +4.895 | +5.047 | 64
3 x TH | C250SD-C300SD/HB(25deg) | Z/562 | 1.8 | +4.549 | +4.674 | 125
3 x FASCIA | C250SD-C300SD/HB(15deg) | Z/561 | 3.5 | +4.905 | +5.057 | 64
3 x TH | C250SD-C300SD/HB(25deg)-AB | Z/562 | 1.8 | +5.713 | +5.815 | 125
3 x TH | C250SD-C300SD/HB(18deg)-AB | Z/562 | 1.8 | +5.526 | +5.622 | 125
3 x TH | C250SD-C300SD/HB(15deg)-AB | Z/562 | 1.8 | +5.441 | +5.534 | 125
3 x TH | C250SD-C300SD/HB(12deg)-AB | Z/562 | 1.8 | +5.355 | +5.445 | 125
PLATE | C250SD-C300SD/AB-HB | Z/1058 | 6.1 | +4.692 | +5.252 | 79
PLATE | C250SD-C300SD/AB-HB | Z/1060 | 5.6 | +4.692 | +5.180 | 79
PLATE | C250SD-C300SD/AB-HB | Z/1062 | 5.4 | +4.692 | +5.149 | 79
PLATE | C250SD-C300SD/HB | Z/1289 | 5.2 | +4.692 | +5.119 | 79
PLATE | C250SD-C300SD/HB(25deg)-AB | Z/1059 | 6.1 | +4.692 | +5.252 | 79
2 x PLATE | C250SD-C300SD/AB | Z/1066 | 4.7 | +6.540 | +6.924 | 79
PLATE | C250SD-C300SD/HB(18deg)-AB | Z/1061 | 5.6 | +4.692 | +5.180 | 79
2 x PLATE | C250SD-C300SD/AB | Z/1065 | 4.4 | +5.996 | +6.341 | 79
PLATE | C250SD-C300SD/HB(15deg)-AB | Z/1063 | 5.4 | +4.692 | +5.149 | 79
2 x PLATE | C250SD-C300SD/AB | Z/1064 | 4.2 | +5.776 | +6.105 | 79
PLATE | C250SD-C300SD/HB(12deg) | Z/1287 | 5.2 | +4.692 | +5.119 | 79
2 x PLATE | C250SD-C300SD/AB | Z/1288 | 4.2 | +5.562 | +5.877 | 79
PLATE | C250SD-C300SD/AB-HB | Z/1059 | 6.1 | +4.692 | +5.252 | 79
PLATE | C250SD-C300SD/AB-HB | Z/1061 | 5.6 | +4.692 | +5.180 | 79
PLATE | C250SD-C300SD/AB-HB | Z/1063 | 5.4 | +4.692 | +5.149 | 79
PLATE | C250SD-C300SD/HB | Z/1287 | 5.2 | +4.692 | +5.119 | 79
PLATE | C250SD-C300SD/HB(25deg)-AB | Z/1058 | 6.1 | +4.692 | +5.252 | 79
PLATE | C250SD-C300SD/HB(18deg)-AB | Z/1060 | 5.6 | +4.692 | +5.180 | 79
PLATE | C250SD-C300SD/HB(15deg)-AB | Z/1062 | 5.4 | +4.692 | +5.149 | 79
PLATE | C250SD-C300SD/HB(12deg) | Z/1289 | 5.2 | +4.692 | +5.119 | 79
APEX BRACING PLATE | C250SD/HB(12deg)-AB | PL/1772 | 9.6 | +5.207 | +5.505 | 79
APEX BRACING PLATE | C250SD/HB(25deg)-AB | PL/1778 | 5.6 | +6.002 | +6.329 | 79
APEX BRACING PLATE | C250SD/HB(18deg)-AB | PL/1776 | 7.2 | +5.561 | +5.874 | 79
APEX BRACING PLATE | C250SD/HB(15deg)-AB | PL/1774 | 8.2 | +5.382 | +5.688 | 79
HAUNCH BRACING PLATE | C250SD/HB(25deg)-AB | PL/1777 | 7.7 | +4.889 | +5.692 | 79
HAUNCH BRACING PLATE | C250SD/HB(18deg)-AB | PL/1775 | 6.1 | +4.757 | +5.453 | 79
HAUNCH BRACING PLATE | C250SD/HB(15deg)-AB | PL/1773 | 5.6 | +4.702 | +5.368 | 79
HAUNCH BRACING PLATE | C250SD/HB(12deg)-AB | PL/1771 | 5.2 | +4.648 | +5.288 | 79
2 x FASCIA BRACKET | C250SD/HB | Z/52 | 0.2 | +4.893 | +5.050 | 157.2
2 x FASCIA BRACKET | C250SD/HB | Z/52 | 0.2 | +4.900 | +5.057 | 157.2
2 x FASCIA BRACKET | C250SD/HB | Z/52 | 0.2 | +4.903 | +5.060 | 157.2
4 x FASCIA BRACKET | C250SD/HB | Z/52 | 0.2 | +4.906 | +5.063 | 157.2
2 x FASCIA BRACKET | C250SD/HB(25deg) | Z/52 | 0.2 | +4.893 | +5.050 | 157.2
2 x FASCIA BRACKET | C250SD/HB(18deg) | Z/52 | 0.2 | +4.900 | +5.057 | 157.2
2 x FASCIA BRACKET | C250SD/HB(12deg) | Z/52 | 0.2 | +4.906 | +5.063 | 157.2
2 x FASCIA BRACKET | C250SD/HB(15deg) | Z/52 | 0.2 | +4.903 | +5.060 | 157.2
2 x COLUMN | C250SD/HB | Z/1472 | 40.5 | +0.000 | +5.050 | 76
2 x COLUMN | C250SD/HB | Z/1470 | 40.6 | +0.000 | +5.057 | 76
2 x COLUMN | C250SD/HB | Z/1468 | 40.6 | +0.000 | +5.060 | 76
3 x COLUMN | C250SD/HB | Z/2404 | 40.6 | +0.000 | +5.063 | 76
2 x RAFTER | C250SD/AB-HB | Z/132 | 33.2 | +4.892 | +6.872 | 76
2 x RAFTER | C250SD/HB(25deg)-AB | Z/2490 | 33.2 | +4.892 | +6.872 | 76
2 x COLUMN | C250SD/HB(25deg) | Z/1472 | 40.5 | +0.000 | +5.050 | 76
2 x RAFTER | C250SD/AB-HB | Z/129 | 31.9 | +4.844 | +6.313 | 76
2 x RAFTER | C250SD/HB(18deg)-AB | Z/2489 | 31.9 | +4.844 | +6.313 | 76
2 x COLUMN | C250SD/HB(18deg) | Z/1470 | 40.6 | +0.000 | +5.057 | 76
2 x RAFTER | C250SD/AB-HB | Z/126 | 31.5 | +4.825 | +6.086 | 76
2 x RAFTER | C250SD/HB(15deg)-AB | Z/2488 | 31.5 | +4.825 | +6.086 | 76
2 x COLUMN | C250SD/HB(15deg) | Z/1468 | 40.6 | +0.000 | +5.060 | 76
2 x RAFTER | C250SD/AB-HB | Z/2406 | 31.2 | +4.807 | +5.865 | 76
2 x RAFTER | C250SD/HB(12deg)-AB | Z/2487 | 31.2 | +4.807 | +5.865 | 76
2 x COLUMN | C250SD/HB(12deg) | Z/2404 | 40.6 | +0.000 | +5.063 | 76
APEX BRACING PLATE | C250SD/HB(12deg)-AB | PL/1761 | 9.6 | +5.207 | +5.505 | 79
2 x APEX BRACE | C250SD/HB(12deg)-HB | Z/2433 | 16.3 | +5.210 | +5.413 | 76
APEX BRACING PLATE | C250SD/HB(25deg)-AB | PL/1767 | 5.6 | +6.002 | +6.329 | 79
2 x APEX BRACE | C250SD/HB(25deg)-HB | Z/2433 | 16.3 | +6.005 | +6.208 | 76
APEX BRACING PLATE | C250SD/HB(18deg)-AB | PL/1765 | 7.2 | +5.561 | +5.874 | 79
2 x APEX BRACE | C250SD/HB(18deg)-HB | Z/2433 | 16.3 | +5.564 | +5.767 | 76
APEX BRACING PLATE | C250SD/HB(15deg)-AB | PL/1763 | 8.2 | +5.382 | +5.688 | 79
2 x APEX BRACE | C250SD/HB(15deg)-HB | Z/2433 | 16.3 | +5.385 | +5.588 | 76
HAUNCH BRACING PLATE | C250SD/HB(25deg)-AB | PL/1766 | 7.7 | +4.889 | +5.692 | 79
HAUNCH BRACING PLATE | C250SD/HB(18deg)-AB | PL/1764 | 6.1 | +4.757 | +5.453 | 79
HAUNCH BRACING PLATE | C250SD/HB(15deg)-AB | PL/1762 | 5.6 | +4.702 | +5.368 | 79
HAUNCH BRACING PLATE | C250SD/HB(12deg)-AB | PL/1760 | 5.2 | +4.648 | +5.288 | 79
2 x HAUNCH BRACE | C250SD/HB(25deg)-AB | Z/2491 | 6.1 | +4.277 | +5.191 | 76
2 x HAUNCH BRACE | C250SD/HB(18deg)-AB | Z/2491 | 6.1 | +4.144 | +5.058 | 76
2 x HAUNCH BRACE | C250SD/HB(15deg)-AB | Z/2491 | 6.1 | +4.090 | +5.003 | 76
2 x HAUNCH BRACE | C250SD/HB(12deg)-AB | Z/2491 | 6.1 | +4.036 | +4.950 | 76
2 x FASCIA | C200SD-C250SD/HB | Z/561 | 3.5 | +4.895 | +5.047 | 64
2 x TH | C200SD-C250SD/HB | Z/562 | 1.8 | +4.549 | +4.674 | 125
TH | C200SD-C250SD/AB-HB | Z/562 | 1.8 | +5.713 | +5.815 | 125
2 x FASCIA | C200SD-C250SD/HB | Z/561 | 3.5 | +4.902 | +5.054 | 64
2 x TH | C200SD-C250SD/HB | Z/562 | 1.8 | +4.556 | +4.681 | 125
TH | C200SD-C250SD/AB-HB | Z/562 | 1.8 | +5.526 | +5.622 | 125
2 x FASCIA | C200SD-C250SD/HB | Z/561 | 3.5 | +4.905 | +5.057 | 64
