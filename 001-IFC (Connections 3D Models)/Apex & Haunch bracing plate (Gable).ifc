Properties of the parts of a building model (IFC2X3), part 3 of 4

# IfcPlate: PLT3*355.5 (2)
Tekla Common - Bottom elevation: +6.646; Top elevation: +6.900; Phase: 1; Class: 1
Tekla Quantity - Weight: 2.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.6 m2; Net surface area: 0.2 m2; Height: 355.5 mm; Width: 3 mm; Length: 448.3 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/1003
BaseQuantities - Width: 355.548 mm; NetArea: 0.211784 m2; GrossArea: 0.159386 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000311633 m3; GrossVolume: 0.000311633 m3

# IfcPlate: PLT3*356.2 (2)
In: Undefined
Description: PLT3*356.2; Material: STEEL/450
Tekla Common - Bottom elevation: +4.772; Top elevation: +5.245; Phase: 1; Class: 11
Tekla Quantity - Weight: 2.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.6 m2; Net surface area: 0.3 m2; Height: 356.2 mm; Width: 3 mm; Length: 541.7 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 356.224 mm; NetArea: 0.254523 m2; GrossArea: 0.192965 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000374054 m3; GrossVolume: 0.000389405 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1714
HAUNCH BRACING PLATE | PL/1729

# IfcPlate: PLT3*359.2 (2)
In: Undefined
Description: PLT3*359.2; Material: STEEL/450
Tekla Common - Bottom elevation: +4.812; Top elevation: +5.297; Phase: 1; Class: 11
Tekla Quantity - Weight: 3.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.6 m2; Net surface area: 0.3 m2; Height: 359.2 mm; Width: 3 mm; Length: 555.2 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 359.188 mm; NetArea: 0.264651 m2; GrossArea: 0.199435 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000389051 m3; GrossVolume: 0.000404402 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1715
HAUNCH BRACING PLATE | PL/1730

# IfcPlate: PLT3*359.8 (2)
In: Undefined
Description: PLT3*359.8; Material: STEEL/450
Default - ASSEMBLY_POS: Z/2397
Tekla Common - Bottom elevation: +5.469; Top elevation: +5.723; Phase: 1; Class: 1
Tekla Quantity - Weight: 3.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.3 m2; Height: 359.8 mm; Width: 3 mm; Length: 519.2 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/2397
BaseQuantities - Width: 359.788 mm; NetArea: 0.292934 m2; GrossArea: 0.186786 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000432182 m3; GrossVolume: 0.000432182 m3

# IfcPlate: PLT3*363.3 (2)
In: Undefined
Description: PLT3*363.3; Material: STEEL/450
Tekla Common - Bottom elevation: +4.873; Top elevation: +5.378; Phase: 1; Class: 11
Tekla Quantity - Weight: 3.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.6 m2; Net surface area: 0.3 m2; Height: 363.3 mm; Width: 3 mm; Length: 579.3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 363.344 mm; NetArea: 0.282314 m2; GrossArea: 0.210476 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000415228 m3; GrossVolume: 0.000430579 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1716
HAUNCH BRACING PLATE | PL/1731

# IfcPlate: PLT3*363.8 (4)
In: Undefined
Description: PLT3*363.8; Material: STEEL/450
Tekla Common - Bottom elevation: +4.775; Top elevation: +5.192; Phase: 1; Class: 1
Tekla Quantity - Weight: 3.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.3 m2; Height: 363.8 mm; Width: 3 mm; Length: 564.9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 363.821 mm; NetArea: 0.315463 m2; GrossArea: 0.205516 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00046552 m3; GrossVolume: 0.00046552 m3
Name | ASSEMBLY_POS = Reference
2 x PLATE | Z/1030
2 x PLATE | Z/1031

# IfcPlate: PLT3*367.1 (2)
In: Undefined
Description: PLT3*367.1; Material: STEEL/450
Tekla Common - Bottom elevation: +4.935; Top elevation: +5.464; Phase: 1; Class: 11
Tekla Quantity - Weight: 3.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.6 m2; Net surface area: 0.3 m2; Height: 367.1 mm; Width: 3 mm; Length: 609.4 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 367.145 mm; NetArea: 0.303813 m2; GrossArea: 0.223723 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00044709 m3; GrossVolume: 0.000462441 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1717
HAUNCH BRACING PLATE | PL/1732

# IfcPlate: PLT3*368.7 (2)
In: Undefined
Description: PLT3*368.7; Material: STEEL/450
Tekla Common - Bottom elevation: +6.047; Top elevation: +6.327; Phase: 1; Class: 11
Tekla Quantity - Weight: 5.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.1 m2; Net surface area: 0.5 m2; Height: 368.7 mm; Width: 3 mm; Length: 764.8 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 368.667 mm; NetArea: 0.454467 m2; GrossArea: 0.281952 m2; CrossSectionArea: 0.000009 m2; GrossVolume: 0.00068665 m3
Name | ASSEMBLY_POS = Reference | NetVolume (m3)
APEX BRACING PLATE | PL/1745 | 0.0006713
APEX BRACING PLATE | PL/1756 | 0.000671299

# IfcPlate: PLT3*373.7 (2)
In: Undefined
Description: PLT3*373.7; Material: STEEL/450
Default - ASSEMBLY_POS: Z/187
Tekla Common - Bottom elevation: +5.609; Top elevation: +5.872; Phase: 1; Class: 1
Tekla Quantity - Weight: 3.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.3 m2; Height: 373.7 mm; Width: 3 mm; Length: 529.1 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/187
BaseQuantities - Width: 373.729 mm; NetArea: 0.298692 m2; GrossArea: 0.197735 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000440768 m3; GrossVolume: 0.000440768 m3

# IfcPlate: PLT3*374.5 (2)
In: Undefined
Description: PLT3*374.5; Material: STEEL/450
Tekla Common - Bottom elevation: +5.088; Top elevation: +5.700; Phase: 1; Class: 11
Tekla Quantity - Weight: 4.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.3 m2; Height: 374.5 mm; Width: 3 mm; Length: 718.9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 374.546 mm; NetArea: 0.378565 m2; GrossArea: 0.269245 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000557871 m3; GrossVolume: 0.000573222 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1718
HAUNCH BRACING PLATE | PL/1733

# IfcPlate: PLT3*380.1 (4)
In: Undefined
Description: PLT3*380.1; Material: STEEL/450
Tekla Common - Phase: 1; Class: 11
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 380.1 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Length (mm) | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) | GrossVolume (m3)
APEX BRACING PLATE | PL/1781 | +5.042 | +5.333 | 14.6 | 85.8 | 1.2 | 1762.2 | 380.054 | 1.26109 | 0.669729 | 0.00186957 | 0.00188493
APEX BRACING PLATE | PL/1759 | +5.093 | +5.384 | 11.4 | 86 | 1 | 1473 | 380.055 | 0.97141 | 0.559804 | 0.00143849 | 0.00145384
APEX BRACING PLATE | PL/1792 | +5.042 | +5.333 | 14.6 | 85.8 | 1.2 | 1762.2 | 380.054 | 1.26109 | 0.669729 | 0.00186957 | 0.00188493
APEX BRACING PLATE | PL/1770 | +5.093 | +5.384 | 11.4 | 86 | 1 | 1473 | 380.055 | 0.97141 | 0.559804 | 0.00143848 | 0.00145384

# IfcPlate: PLT3*385.9 (4)
In: Undefined
Description: PLT3*385.9; Material: STEEL/450
Tekla Common - Phase: 1; Class: 11
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 385.9 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Length (mm) | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) | GrossVolume (m3)
APEX BRACING PLATE | PL/1783 | +5.156 | +5.454 | 12.6 | 85.8 | 1.1 | 1515.9 | 385.9 | 1.08337 | 0.584979 | 0.00160578 | 0.00162113
APEX BRACING PLATE | PL/1794 | +5.156 | +5.454 | 12.6 | 85.8 | 1.1 | 1515.9 | 385.9 | 1.08337 | 0.584979 | 0.00160578 | 0.00162113
APEX BRACING PLATE | PL/1761 | +5.207 | +5.505 | 9.6 | 86 | 0.8 | 1275.9 | 385.899 | 0.838788 | 0.492384 | 0.00124177 | 0.00125713
APEX BRACING PLATE | PL/1772 | +5.207 | +5.505 | 9.6 | 86 | 0.8 | 1275.9 | 385.899 | 0.838787 | 0.492384 | 0.00124177 | 0.00125713

# IfcPlate: PLT3*393.6 (2)
In: Undefined
Description: PLT3*393.6; Material: STEEL/450
Default - ASSEMBLY_POS: Z/1036
Tekla Common - Bottom elevation: +5.822; Top elevation: +6.099; Phase: 1; Class: 1
Tekla Quantity - Weight: 3.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.3 m2; Height: 393.6 mm; Width: 3 mm; Length: 541.3 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/1036
BaseQuantities - Width: 393.583 mm; NetArea: 0.307078 m2; GrossArea: 0.213063 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000453276 m3; GrossVolume: 0.000453276 m3

# IfcPlate: PLT3*394 (4)
In: Undefined
Description: PLT3*394; Material: STEEL/450
Tekla Common - Phase: 1; Class: 11
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 394 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Length (mm) | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) | GrossVolume (m3)
APEX BRACING PLATE | PL/1785 | +5.331 | +5.637 | 10.5 | 86 | 0.8 | 1272.3 | 393.994 | 0.905185 | 0.501282 | 0.00134126 | 0.00135661
APEX BRACING PLATE | PL/1796 | +5.331 | +5.637 | 10.5 | 86 | 0.8 | 1272.3 | 393.994 | 0.905184 | 0.501282 | 0.00134126 | 0.00135661
APEX BRACING PLATE | PL/1763 | +5.382 | +5.688 | 8.2 | 86.1 | 0.6 | 1082 | 393.995 | 0.705856 | 0.426297 | 0.00104458 | 0.00105993
APEX BRACING PLATE | PL/1774 | +5.382 | +5.688 | 8.2 | 86.1 | 0.6 | 1082 | 393.995 | 0.705856 | 0.426297 | 0.00104458 | 0.00105993

# IfcPlate: PLT3*401.3 (4)
In: Undefined
Description: PLT3*401.3; Material: STEEL/450
Tekla Common - Phase: 1; Class: 11
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 401.3 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Length (mm) | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) | GrossVolume (m3)
APEX BRACING PLATE | PL/1787 | +5.510 | +5.822 | 9.1 | 86 | 0.8 | 1112.6 | 401.264 | 0.785927 | 0.44644 | 0.00116421 | 0.00117956
APEX BRACING PLATE | PL/1798 | +5.510 | +5.822 | 9.1 | 86 | 0.8 | 1112.6 | 401.264 | 0.785927 | 0.44644 | 0.00116421 | 0.00117956
APEX BRACING PLATE | PL/1765 | +5.561 | +5.874 | 7.2 | 86.1 | 0.6 | 955.6 | 401.265 | 0.616922 | 0.383455 | 0.000912631 | 0.000927982
APEX BRACING PLATE | PL/1776 | +5.561 | +5.874 | 7.2 | 86.1 | 0.6 | 955.6 | 401.265 | 0.616922 | 0.383455 | 0.000912631 | 0.000927982

# IfcPlate: PLT3*410.8 (4)
In: Undefined
Description: PLT3*410.8; Material: STEEL/450
Default - ASSEMBLY_POS: Z/2403
Tekla Common - Bottom elevation: +5.422; Top elevation: +5.727; Phase: 1; Class: 1
Tekla Quantity - Weight: 3.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.1 m2; Net surface area: 0.3 m2; Height: 410.8 mm; Width: 3 mm; Length: 536.6 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/2403
BaseQuantities - Width: 410.79 mm; NetArea: 0.347447 m2; GrossArea: 0.220441 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00051341 m3; GrossVolume: 0.00051341 m3

# IfcPlate: PLT3*412 (2)
In: Undefined
Description: PLT3*412; Material: STEEL/450
Default - ASSEMBLY_POS: Z/1037
Tekla Common - Bottom elevation: +6.041; Top elevation: +6.332; Phase: 1; Class: 1
Tekla Quantity - Weight: 3.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.3 m2; Height: 412 mm; Width: 3 mm; Length: 550.3 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/1037
BaseQuantities - Width: 411.971 mm; NetArea: 0.315115 m2; GrossArea: 0.226702 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000465263 m3; GrossVolume: 0.000465263 m3

# IfcPlate: PLT3*414.9 (4)
In: Undefined
Description: PLT3*414.9; Material: STEEL/450
Tekla Common - Phase: 1; Class: 11
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.1 m2; Height: 414.9 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Net surface area (m2) | Length (mm) | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) | GrossVolume (m3)
APEX BRACING PLATE | PL/1789 | +5.951 | +6.278 | 7.2 | 0.6 | 895.7 | 414.895 | 0.617621 | 0.371627 | 0.000914273 | 0.000929624
APEX BRACING PLATE | PL/1800 | +5.951 | +6.278 | 7.2 | 0.6 | 895.7 | 414.895 | 0.617621 | 0.371627 | 0.000914273 | 0.000929624
APEX BRACING PLATE | PL/1767 | +6.002 | +6.329 | 5.6 | 0.5 | 786.3 | 414.885 | 0.491525 | 0.326239 | 0.000726508 | 0.000741858
APEX BRACING PLATE | PL/1778 | +6.002 | +6.329 | 5.6 | 0.5 | 786.3 | 414.885 | 0.491524 | 0.326239 | 0.000726508 | 0.000741858

# IfcPlate: PLT3*424.7 (4)
In: Undefined
Description: PLT3*424.7; Material: STEEL/450
Default - ASSEMBLY_POS: Z/1288
Tekla Common - Bottom elevation: +5.562; Top elevation: +5.877; Phase: 1; Class: 1
Tekla Quantity - Weight: 4.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.1 m2; Height: 424.7 mm; Width: 3 mm; Length: 549.8 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/1288
BaseQuantities - Width: 424.728 mm; NetArea: 0.354893 m2; GrossArea: 0.23353 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000524514 m3; GrossVolume: 0.000524514 m3
Name | Net surface area (m2)
3 x PLATE | 0.5
PLATE | 0.3

# IfcPlate: PLT3*425.4 (2)
In: Undefined
Description: PLT3*425.4; Material: STEEL/450
Tekla Common - Bottom elevation: +4.999; Top elevation: +5.336; Phase: 1; Class: 11
Tekla Quantity - Weight: 15.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 1.2 m2; Height: 425.4 mm; Width: 3 mm; Length: 1770.2 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 425.357 mm; GrossArea: 0.752951 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00198959 m3; GrossVolume: 0.00200494 m3
Name | ASSEMBLY_POS = Reference | NetArea (m2)
APEX BRACING PLATE | PL/1803 | 1.34127
APEX BRACING PLATE | PL/1874 | 1.34126

# IfcPlate: PLT3*426.1 (8)
In: Undefined
Description: PLT3*426.1; Material: STEEL/450
Tekla Common - Bottom elevation: +4.692; Top elevation: +5.119; Phase: 1; Class: 1
Tekla Quantity - Weight: 5.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.1 m2; Height: 426.1 mm; Width: 3 mm; Length: 656.1 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - NetArea: 0.449082 m2; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Net surface area (m2) | Width (mm) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
3 x PLATE | Z/1289 | 0.5 | 426.082 | 0.27956 | 0.000664572
3 x PLATE | Z/1287 | 0.5 | 426.096 | 0.279571 | 0.000664571
PLATE | Z/1287 | 0.3 | 426.096 | 0.279571 | 0.000664571
PLATE | Z/1289 | 0.3 | 426.082 | 0.27956 | 0.000664572

# IfcPlate: PLT3*430.9 (2)
In: Undefined
Description: PLT3*430.9; Material: STEEL/450
Tekla Common - Bottom elevation: +5.115; Top elevation: +5.457; Phase: 1; Class: 11
Tekla Quantity - Weight: 13.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 1.2 m2; Height: 430.9 mm; Width: 3 mm; Length: 1525.4 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 430.893 mm; NetArea: 1.15203 m2; GrossArea: 0.657302 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.0017085 m3; GrossVolume: 0.00172385 m3
Name | ASSEMBLY_POS = Reference
APEX BRACING PLATE | PL/1865
APEX BRACING PLATE | PL/1876

# IfcPlate: PLT3*435.4 (4)
In: Undefined
Description: PLT3*435.4; Material: STEEL/450
Default - ASSEMBLY_POS: Z/1062
Tekla Common - Bottom elevation: +4.692; Top elevation: +5.149; Phase: 1; Class: 1
Tekla Quantity - Weight: 5.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.1 m2; Net surface area: 0.5 m2; Height: 435.4 mm; Width: 3 mm; Length: 675.7 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/1062
BaseQuantities - Width: 435.438 mm; NetArea: 0.465321 m2; GrossArea: 0.294207 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000688788 m3; GrossVolume: 0.000688788 m3

# IfcPlate: PLT3*435.5 (4)
In: Undefined
Description: PLT3*435.5; Material: STEEL/450
Tekla Common - Bottom elevation: +4.692; Top elevation: +5.149; Phase: 1; Class: 1
Tekla Quantity - Weight: 5.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.1 m2; Net surface area: 0.5 m2; Height: 435.4 mm; Width: 3 mm; Length: 675.7 mm
Default - ASSEMBLY_POS: Z/1063
Pset_PlateCommon - LoadBearing: no; Reference: Z/1063
BaseQuantities - Width: 435.459 mm; NetArea: 0.465321 m2; GrossArea: 0.294224 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000688799 m3; GrossVolume: 0.000688799 m3

# IfcPlate: PLT3*438.3 (2)
In: Undefined
Description: PLT3*438.3; Material: STEEL/450
Tekla Common - Bottom elevation: +3.821; Top elevation: +4.274; Phase: 1; Class: 11
Tekla Quantity - Weight: 3.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.3 m2; Height: 438.3 mm; Width: 3 mm; Length: 580.7 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 438.252 mm; NetArea: 0.330006 m2; GrossArea: 0.254484 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000486485 m3; GrossVolume: 0.000501837 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1735
HAUNCH BRACING PLATE | PL/1746

# IfcPlate: PLT3*438.4 (2)
In: Undefined
Description: PLT3*438.4; Material: STEEL/450
Tekla Common - Bottom elevation: +5.290; Top elevation: +5.640; Phase: 1; Class: 11
Tekla Quantity - Weight: 11.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 1 m2; Height: 438.4 mm; Width: 3 mm; Length: 1284.2 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 438.427 mm; NetArea: 0.962351 m2; GrossArea: 0.563036 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00142673 m3; GrossVolume: 0.00144208 m3
Name | ASSEMBLY_POS = Reference
APEX BRACING PLATE | PL/1867
APEX BRACING PLATE | PL/1878

# IfcPlate: PLT3*443.8 (4)
In: Undefined
Description: PLT3*443.8; Material: STEEL/450
Default - ASSEMBLY_POS: Z/1060
Tekla Common - Bottom elevation: +4.692; Top elevation: +5.180; Phase: 1; Class: 1
Tekla Quantity - Weight: 5.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.5 m2; Height: 443.8 mm; Width: 3 mm; Length: 695.5 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/1060
BaseQuantities - Width: 443.844 mm; NetArea: 0.48188 m2; GrossArea: 0.308713 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000713477 m3; GrossVolume: 0.000713477 m3

# IfcPlate: PLT3*443.9 (4)
In: Undefined
Description: PLT3*443.9; Material: STEEL/450
Tekla Common - Bottom elevation: +4.692; Top elevation: +5.180; Phase: 1; Class: 1
Default - ASSEMBLY_POS: Z/1061
Tekla Quantity - Weight: 5.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.5 m2; Height: 443.9 mm; Width: 3 mm; Length: 695.6 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/1061
BaseQuantities - Width: 443.894 mm; NetArea: 0.481881 m2; GrossArea: 0.308754 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000713497 m3; GrossVolume: 0.000713497 m3

# IfcPlate: PLT3*444.6 (4)
In: Undefined
Description: PLT3*444.6; Material: STEEL/450
Default - ASSEMBLY_POS: Z/1064
Tekla Common - Bottom elevation: +5.776; Top elevation: +6.105; Phase: 1; Class: 1
Tekla Quantity - Weight: 4.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.1 m2; Height: 444.6 mm; Width: 3 mm; Length: 566.8 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/1064
BaseQuantities - Width: 444.577 mm; NetArea: 0.365885 m2; GrossArea: 0.252 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000540905 m3; GrossVolume: 0.000540905 m3
Name | Net surface area (m2)
3 x PLATE | 0.5
PLATE | 0.3

# IfcPlate: PLT3*445 (2)
In: Undefined
Description: PLT3*445; Material: STEEL/450
Tekla Common - Bottom elevation: +5.470; Top elevation: +5.826; Phase: 1; Class: 11
Tekla Quantity - Weight: 9.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.8 m2; Height: 445 mm; Width: 3 mm; Length: 1126.8 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 445.015 mm; GrossArea: 0.501441 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00123823 m3; GrossVolume: 0.00125358 m3
Name | ASSEMBLY_POS = Reference | NetArea (m2)
APEX BRACING PLATE | PL/1869 | 0.835472
APEX BRACING PLATE | PL/1880 | 0.835471

# IfcPlate: PLT3*448.1 (2)
In: Undefined
Description: PLT3*448.1; Material: STEEL/450
Default - ASSEMBLY_POS: Z/1038
Tekla Common - Bottom elevation: +6.585; Top elevation: +6.912; Phase: 1; Class: 1
Tekla Quantity - Weight: 3.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.1 m2; Net surface area: 0.3 m2; Height: 448.1 mm; Width: 3 mm; Length: 558.1 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/1038
BaseQuantities - Width: 448.062 mm; NetArea: 0.332573 m2; GrossArea: 0.250076 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000491299 m3; GrossVolume: 0.000491299 m3

# IfcPlate: PLT3*456.6 (2)
In: Undefined
Description: PLT3*456.6; Material: STEEL/450
Tekla Common - Bottom elevation: +5.912; Top elevation: +6.280; Phase: 1; Class: 11
Tekla Quantity - Weight: 7.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.6 m2; Height: 456.6 mm; Width: 3 mm; Length: 915.2 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 456.577 mm; NetArea: 0.656586 m2; GrossArea: 0.417837 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000972393 m3; GrossVolume: 0.000987743 m3
Name | ASSEMBLY_POS = Reference
APEX BRACING PLATE | PL/1871
APEX BRACING PLATE | PL/1882

# IfcPlate: PLT3*458.3 (4)
In: Undefined
Description: PLT3*458.3; Material: STEEL/450
Tekla Common - Bottom elevation: +4.692; Top elevation: +5.099; Phase: 1; Class: 1
Tekla Quantity - Weight: 5.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.1 m2; Net surface area: 0.3 m2; Height: 458.3 mm; Width: 3 mm; Length: 679.4 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 458.296 mm; GrossArea: 0.311382 m2; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | NetArea (m2) | NetVolume (m3) = GrossVolume (m3)
2 x PLATE | Z/2440 | 0.439846 | 0.000650793
2 x PLATE | Z/2401 | 0.439847 | 0.000650794

# IfcPlate: PLT3*459.7 (4)
In: Undefined
Description: PLT3*459.7; Material: STEEL/450
Default - ASSEMBLY_POS: Z/1058
Tekla Common - Bottom elevation: +4.692; Top elevation: +5.252; Phase: 1; Class: 1
Tekla Quantity - Weight: 6.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.5 m2; Height: 459.7 mm; Width: 3.1 mm; Length: 743.7 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/1058
BaseQuantities - Width: 459.656 mm; NetArea: 0.521886 m2; GrossArea: 0.341847 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.0007731 m3; GrossVolume: 0.0007731 m3

# IfcPlate: PLT3*459.8 (8)
In: Undefined
Description: PLT3*459.8; Material: STEEL/450
Tekla Common - Bottom elevation: +4.692; Phase: 1; Class: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 459.7 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000009 m2
Name | Top elevation | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Tekla Quantity, Width (mm) | Length (mm) | ASSEMBLY_POS = Reference | BaseQuantities, Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
4 x PLATE | +5.252 | 6.1 | 86 | 0.5 | 3.1 | 743.7 | Z/1059 | 459.8 | 0.521888 | 0.341971 | 0.000773137
2 x PLATE | +5.099 | 5.2 | 86.1 | 0.3 | 3 | 681.3 | Z/2439 | 459.788 | 0.438155 | 0.313255 | 0.000648273
2 x PLATE | +5.099 | 5.2 | 86.1 | 0.3 | 3 | 681.3 | Z/2402 | 459.788 | 0.438154 | 0.313255 | 0.000648271

# IfcPlate: PLT3*460.4 (2)
In: Undefined
Description: PLT3*460.4; Material: STEEL/450
Tekla Common - Bottom elevation: +4.953; Top elevation: +5.290; Phase: 1; Class: 11
Tekla Quantity - Weight: 20.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 1.7 m2; Height: 460.4 mm; Width: 3 mm; Length: 2031 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 460.357 mm; NetArea: 1.76527 m2; GrossArea: 0.935004 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00262226 m3; GrossVolume: 0.00264773 m3
Name | ASSEMBLY_POS = Reference
APEX BRACING PLATE | PL/1885
APEX BRACING PLATE | PL/1896

# IfcPlate: PLT3*461 (2)
In: Undefined
Description: PLT3*461; Material: STEEL/450
Tekla Common - Bottom elevation: +4.670; Top elevation: +5.245; Phase: 1; Class: 11
Tekla Quantity - Weight: 4.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.3 m2; Height: 461 mm; Width: 3 mm; Length: 643.8 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 460.998 mm; NetArea: 0.393458 m2; GrossArea: 0.29678 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000580766 m3; GrossVolume: 0.000596117 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1736
HAUNCH BRACING PLATE | PL/1747

# IfcPlate: PLT3*463 (4)
In: Undefined
Description: PLT3*463; Material: STEEL/450
Default - ASSEMBLY_POS: Z/1065
Tekla Common - Bottom elevation: +5.996; Top elevation: +6.341; Phase: 1; Class: 1
Tekla Quantity - Weight: 4.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.1 m2; Height: 463 mm; Width: 3 mm; Length: 580.3 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/1065
BaseQuantities - NetArea: 0.376626 m2; GrossArea: 0.268651 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000556923 m3; GrossVolume: 0.000556923 m3
Name | Net surface area (m2) | Width (mm)
2 x PLATE | 0.5 | 462.974
PLATE | 0.5 | 462.973
PLATE | 0.3 | 462.973

# IfcPlate: PLT3*465 (2)
In: Undefined
Description: PLT3*465; Material: STEEL/450
Tekla Common - Bottom elevation: +4.707; Top elevation: +5.298; Phase: 1; Class: 11
Tekla Quantity - Weight: 4.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Height: 465 mm; Width: 3 mm; Length: 661.5 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 464.963 mm; NetArea: 0.410607 m2; GrossArea: 0.307576 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000606248 m3; GrossVolume: 0.000621599 m3
Name | ASSEMBLY_POS = Reference | Net surface area (m2)
HAUNCH BRACING PLATE | PL/1738 | 0.5
HAUNCH BRACING PLATE | PL/1749 | 0.3

# IfcPlate: PLT3*465.9 (2)
In: Undefined
Description: PLT3*465.9; Material: STEEL/450
Tekla Common - Bottom elevation: +5.069; Top elevation: +5.411; Phase: 1; Class: 11
Tekla Quantity - Weight: 17.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 1.4 m2; Height: 465.9 mm; Width: 3 mm; Length: 1741.9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 465.897 mm; NetArea: 1.50923 m2; GrossArea: 0.811527 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00224145 m3; GrossVolume: 0.00226693 m3
Name | ASSEMBLY_POS = Reference
APEX BRACING PLATE | PL/1887
APEX BRACING PLATE | PL/1898

# IfcPlate: PLT3*470.5 (2)
In: Undefined
Description: PLT3*470.5; Material: STEEL/450
Tekla Common - Bottom elevation: +4.764; Top elevation: +5.380; Phase: 1; Class: 11
Tekla Quantity - Weight: 5.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.1 m2; Height: 470.5 mm; Width: 3 mm; Length: 693.1 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 470.517 mm; NetArea: 0.440518 m2; GrossArea: 0.326119 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000650693 m3; GrossVolume: 0.000666044 m3
Name | ASSEMBLY_POS = Reference | Net surface area (m2)
HAUNCH BRACING PLATE | PL/1740 | 0.5
HAUNCH BRACING PLATE | PL/1751 | 0.3

# IfcPlate: PLT3*473.4 (2)
In: Undefined
Description: PLT3*473.4; Material: STEEL/450
Tekla Common - Bottom elevation: +5.244; Top elevation: +5.594; Phase: 1; Class: 11
Tekla Quantity - Weight: 14.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 1.2 m2; Height: 473.4 mm; Width: 3 mm; Length: 1455.9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 473.427 mm; NetArea: 1.25244 m2; GrossArea: 0.689262 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00185952 m3; GrossVolume: 0.001885 m3
Name | ASSEMBLY_POS = Reference
APEX BRACING PLATE | PL/1889
APEX BRACING PLATE | PL/1900

# IfcPlate: PLT3*474.3 (2)
In: Undefined
Description: PLT3*474.3; Material: STEEL/450
Tekla Common - Bottom elevation: +3.847; Top elevation: +4.299; Phase: 1; Class: 11
Tekla Quantity - Weight: 4.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.3 m2; Height: 474.3 mm; Width: 3 mm; Length: 616.7 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 474.312 mm; NetArea: 0.359592 m2; GrossArea: 0.292527 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000530405 m3; GrossVolume: 0.000545757 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1757
HAUNCH BRACING PLATE | PL/1768

# IfcPlate: PLT3*475.6 (2)
In: Undefined
Description: PLT3*475.6; Material: STEEL/450
Tekla Common - Bottom elevation: +4.821; Top elevation: +5.469; Phase: 1; Class: 11
Tekla Quantity - Weight: 5.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.1 m2; Net surface area: 0.5 m2; Height: 475.6 mm; Width: 3 mm; Length: 732.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 475.584 mm; NetArea: 0.476922 m2; GrossArea: 0.348409 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000704787 m3; GrossVolume: 0.000720138 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1742
HAUNCH BRACING PLATE | PL/1753

# IfcPlate: PLT3*480 (2)
In: Undefined
Description: PLT3*480; Material: STEEL/450
Tekla Common - Bottom elevation: +5.424; Top elevation: +5.780; Phase: 1; Class: 11
Tekla Quantity - Weight: 12.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 1.1 m2; Height: 480 mm; Width: 3 mm; Length: 1268.4 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 480.017 mm; NetArea: 1.08054 m2; GrossArea: 0.608838 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00160382 m3; GrossVolume: 0.0016293 m3
Name | ASSEMBLY_POS = Reference
APEX BRACING PLATE | PL/1891
APEX BRACING PLATE | PL/1902

# IfcPlate: PLT3*485.5 (2)
In: Undefined
Description: PLT3*485.5; Material: STEEL/450
Tekla Common - Bottom elevation: +4.961; Top elevation: +5.717; Phase: 1; Class: 11
Tekla Quantity - Weight: 7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.1 m2; Net surface area: 0.6 m2; Height: 485.5 mm; Width: 3 mm; Length: 876.4 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 485.474 mm; NetArea: 0.603617 m2; GrossArea: 0.425468 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000893052 m3; GrossVolume: 0.000908403 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1744
HAUNCH BRACING PLATE | PL/1755

# IfcPlate: PLT3*491.6 (2)
In: Undefined
Description: PLT3*491.6; Material: STEEL/450
Tekla Common - Bottom elevation: +5.866; Top elevation: +6.234; Phase: 1; Class: 11
Tekla Quantity - Weight: 9.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.8 m2; Height: 491.6 mm; Width: 3 mm; Length: 1013.8 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 491.577 mm; NetArea: 0.837817 m2; GrossArea: 0.49836 m2; CrossSectionArea: 0.000009 m2; GrossVolume: 0.00126819 m3
Name | ASSEMBLY_POS = Reference | NetVolume (m3)
APEX BRACING PLATE | PL/1893 | 0.00124272
APEX BRACING PLATE | PL/1904 | 0.00124271

# IfcPlate: PLT3*499.1 (4)
In: Undefined
Description: PLT3*499.1; Material: STEEL/450
Default - ASSEMBLY_POS: Z/1066
Tekla Common - Bottom elevation: +6.540; Top elevation: +6.924; Phase: 1; Class: 1
Tekla Quantity - Weight: 4.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.1 m2; Height: 499.1 mm; Width: 3 mm; Length: 597.2 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/1066
BaseQuantities - Width: 499.069 mm; NetArea: 0.400777 m2; GrossArea: 0.298047 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000592931 m3; GrossVolume: 0.000592931 m3
Name | Net surface area (m2)
3 x PLATE | 0.5
PLATE | 0.3

# IfcPlate: PLT3*502.8 (2)
In: Undefined
Description: PLT3*502.8; Material: STEEL/450
Tekla Common - Bottom elevation: +4.613; Top elevation: +5.238; Phase: 1; Class: 11
Tekla Quantity - Weight: 5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.1 m2; Net surface area: 0.3 m2; Height: 502.8 mm; Width: 3 mm; Length: 673 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 502.778 mm; NetArea: 0.429874 m2; GrossArea: 0.338394 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00063493 m3; GrossVolume: 0.000650281 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1758
HAUNCH BRACING PLATE | PL/1769

# IfcPlate: PLT3*507.7 (2)
In: Undefined
Description: PLT3*507.7; Material: STEEL/450
Tekla Common - Bottom elevation: +4.648; Top elevation: +5.288; Phase: 1; Class: 11
Tekla Quantity - Weight: 5.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.1 m2; Net surface area: 0.5 m2; Height: 507.7 mm; Width: 3 mm; Length: 689.3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 507.738 mm; NetArea: 0.448943 m2; GrossArea: 0.349983 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000663292 m3; GrossVolume: 0.000678643 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1760
HAUNCH BRACING PLATE | PL/1771

# IfcPlate: PLT3*509.6 (2)
In: Undefined
Description: PLT3*509.6; Material: STEEL/450
Tekla Common - Bottom elevation: +4.907; Top elevation: +5.293; Phase: 1; Class: 11
Tekla Quantity - Weight: 21.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.7 m2; Net surface area: 2 m2; Height: 509.6 mm; Width: 3 mm; Length: 2039.7 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 509.607 mm; NetArea: 1.86569 m2; GrossArea: 1.03946 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00277261 m3; GrossVolume: 0.00279808 m3
Name | ASSEMBLY_POS = Reference
APEX BRACING PLATE | PL/1907
APEX BRACING PLATE | PL/1918

# IfcPlate: PLT3*514.7 (2)
In: Undefined
Description: PLT3*514.7; Material: STEEL/450
Tekla Common - Bottom elevation: +4.702; Top elevation: +5.368; Phase: 1; Class: 11
Tekla Quantity - Weight: 5.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.1 m2; Net surface area: 0.5 m2; Height: 514.7 mm; Width: 3 mm; Length: 718.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 514.687 mm; NetArea: 0.482241 m2; GrossArea: 0.369861 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000712818 m3; GrossVolume: 0.000728169 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1762
HAUNCH BRACING PLATE | PL/1773

# IfcPlate: PLT3*514.8 (2)
In: Undefined
Description: PLT3*514.8; Material: STEEL/450
Tekla Common - Bottom elevation: +5.023; Top elevation: +5.414; Phase: 1; Class: 11
Tekla Quantity - Weight: 18.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.7 m2; Net surface area: 1.6 m2; Height: 514.8 mm; Width: 3 mm; Length: 1752.2 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 514.804 mm; NetArea: 1.59491 m2; GrossArea: 0.902064 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00236969 m3; GrossVolume: 0.00239517 m3
Name | ASSEMBLY_POS = Reference
APEX BRACING PLATE | PL/1909
APEX BRACING PLATE | PL/1920

# IfcPlate: PLT3*521 (2)
In: Undefined
Description: PLT3*521; Material: STEEL/450
Tekla Common - Bottom elevation: +4.757; Top elevation: +5.453; Phase: 1; Class: 11
Tekla Quantity - Weight: 6.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.1 m2; Net surface area: 0.5 m2; Height: 521 mm; Width: 3 mm; Length: 755.7 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 521.028 mm; NetArea: 0.522841 m2; GrossArea: 0.393767 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000773208 m3; GrossVolume: 0.000788559 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1764
HAUNCH BRACING PLATE | PL/1775

# IfcPlate: PLT3*521.7 (2)
In: Undefined
Description: PLT3*521.7; Material: STEEL/450
Tekla Common - Bottom elevation: +5.199; Top elevation: +5.597; Phase: 1; Class: 11
Tekla Quantity - Weight: 15.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 1.2 m2; Height: 521.7 mm; Width: 3 mm; Length: 1468.8 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 521.729 mm; NetArea: 1.32347 m2; GrossArea: 0.766333 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00196576 m3; GrossVolume: 0.00199124 m3
Name | ASSEMBLY_POS = Reference
APEX BRACING PLATE | PL/1911
APEX BRACING PLATE | PL/1922

# IfcPlate: PLT3*525.3 (2)
In: Undefined
Description: PLT3*525.3; Material: STEEL/450
Tekla Common - Bottom elevation: +3.811; Top elevation: +4.335; Phase: 1; Class: 11
Tekla Quantity - Weight: 5.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.1 m2; Net surface area: 0.5 m2; Height: 525.3 mm; Width: 3 mm; Length: 667.7 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 525.32 mm; NetArea: 0.453762 m2; GrossArea: 0.350777 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000670769 m3; GrossVolume: 0.000686121 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1779
HAUNCH BRACING PLATE | PL/1790

# IfcPlate: PLT3*527.6 (2)
In: Undefined
Description: PLT3*527.6; Material: STEEL/450
Tekla Common - Bottom elevation: +5.379; Top elevation: +5.783; Phase: 1; Class: 11
Tekla Quantity - Weight: 13.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 1.1 m2; Height: 527.6 mm; Width: 3 mm; Length: 1283.8 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 527.567 mm; NetArea: 1.14183 m2; GrossArea: 0.677301 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00169543 m3; GrossVolume: 0.00172091 m3
Name | ASSEMBLY_POS = Reference
APEX BRACING PLATE | PL/1913
APEX BRACING PLATE | PL/1924

# IfcPlate: PLT3*533.4 (2)
In: Undefined
Description: PLT3*533.4; Material: STEEL/450
Tekla Common - Bottom elevation: +4.889; Top elevation: +5.692; Phase: 1; Class: 11
Tekla Quantity - Weight: 7.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.6 m2; Height: 533.4 mm; Width: 3 mm; Length: 893.9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 533.398 mm; NetArea: 0.664676 m2; GrossArea: 0.476788 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000984179 m3
Name | ASSEMBLY_POS = Reference | GrossVolume (m3)
HAUNCH BRACING PLATE | PL/1766 | 0.00099953
HAUNCH BRACING PLATE | PL/1777 | 0.000999529

# IfcPlate: PLT3*536.9 (2)
In: Undefined
Description: PLT3*536.9; Material: STEEL/450
Tekla Common - Bottom elevation: +5.822; Top elevation: +6.235; Phase: 1; Class: 11
Tekla Quantity - Weight: 10.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.8 m2; Height: 536.9 mm; Width: 3 mm; Length: 1034.9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 536.898 mm; GrossArea: 0.555653 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00131407 m3; GrossVolume: 0.00133954 m3
Name | ASSEMBLY_POS = Reference | NetArea (m2)
APEX BRACING PLATE | PL/1915 | 0.885619
APEX BRACING PLATE | PL/1926 | 0.885618

# IfcPlate: PLT3*538.6 (2)
In: Undefined
Description: PLT3*538.6; Material: STEEL/450
Tekla Common - Bottom elevation: +4.937; Top elevation: +5.323; Phase: 1; Class: 11
Tekla Quantity - Weight: 27.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.7 m2; Net surface area: 2.5 m2; Height: 538.6 mm; Width: 3 mm; Length: 2323.3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 538.597 mm; NetArea: 2.38164 m2; GrossArea: 1.25133 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00354291 m3; GrossVolume: 0.00356839 m3
Name | ASSEMBLY_POS = Reference
APEX BRACING PLATE | PL/1929
APEX BRACING PLATE | PL/1940

# IfcPlate: PLT3*543.8 (2)
In: Undefined
Description: PLT3*543.8; Material: STEEL/450
Tekla Common - Bottom elevation: +5.039; Top elevation: +5.430; Phase: 1; Class: 11
Tekla Quantity - Weight: 23.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.7 m2; Net surface area: 2 m2; Height: 543.8 mm; Width: 3 mm; Length: 1987.5 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 543.807 mm; NetArea: 2.0295 m2; GrossArea: 1.08081 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00301849 m3; GrossVolume: 0.00304396 m3
Name | ASSEMBLY_POS = Reference
APEX BRACING PLATE | PL/1931
APEX BRACING PLATE | PL/1942

# IfcPlate: PLT3*544.9 (4)
In: Undefined
Description: PLT3*544.9; Material: STEEL/450
Default - ASSEMBLY_POS: Z/2410
Tekla Common - Bottom elevation: +5.345; Top elevation: +5.732; Phase: 1; Class: 1
Tekla Quantity - Weight: 9.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.8 m2; Height: 544.9 mm; Width: 3 mm; Length: 943.7 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/2410
BaseQuantities - Width: 544.889 mm; NetArea: 0.784315 m2; GrossArea: 0.514235 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.0011642 m3; GrossVolume: 0.0011642 m3

# IfcPlate: PLT3*550.7 (2)
In: Undefined
Description: PLT3*550.7; Material: STEEL/450
Tekla Common - Bottom elevation: +5.232; Top elevation: +5.630; Phase: 1; Class: 11
Tekla Quantity - Weight: 19.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.7 m2; Net surface area: 1.7 m2; Height: 550.7 mm; Width: 3 mm; Length: 1655.4 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 550.723 mm; NetArea: 1.67633 m2; GrossArea: 0.91169 m2; CrossSectionArea: 0.000009 m2; GrossVolume: 0.00251799 m3
Name | ASSEMBLY_POS = Reference | NetVolume (m3)
APEX BRACING PLATE | PL/1933 | 0.00249252
APEX BRACING PLATE | PL/1944 | 0.00249251

# IfcPlate: PLT3*553.8 (2)
In: Undefined
Description: PLT3*553.8; Material: STEEL/450
Tekla Common - Bottom elevation: +4.569; Top elevation: +5.246; Phase: 1; Class: 11
Tekla Quantity - Weight: 6.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.1 m2; Net surface area: 0.5 m2; Height: 553.8 mm; Width: 3 mm; Length: 745.9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 553.779 mm; NetArea: 0.547192 m2; GrossArea: 0.413048 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000809798 m3; GrossVolume: 0.000825149 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1780
HAUNCH BRACING PLATE | PL/1791

# IfcPlate: PLT3*556.6 (2)
In: Undefined
Description: PLT3*556.6; Material: STEEL/450
Tekla Common - Bottom elevation: +5.430; Top elevation: +5.834; Phase: 1; Class: 11
Tekla Quantity - Weight: 16.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.7 m2; Net surface area: 1.4 m2; Height: 556.6 mm; Width: 3 mm; Length: 1437.7 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 556.569 mm; NetArea: 1.43988 m2; GrossArea: 0.800181 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00214035 m3; GrossVolume: 0.00216582 m3
Name | ASSEMBLY_POS = Reference
APEX BRACING PLATE | PL/1935
APEX BRACING PLATE | PL/1946

# IfcPlate: PLT3*557.9 (2)
In: Undefined
Description: PLT3*557.9; Material: STEEL/450
Tekla Common - Bottom elevation: +3.834; Top elevation: +4.358; Phase: 1; Class: 11
Tekla Quantity - Weight: 5.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.1 m2; Net surface area: 0.5 m2; Height: 557.9 mm; Width: 3 mm; Length: 700.3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 557.854 mm; NetArea: 0.487092 m2; GrossArea: 0.390648 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00072035 m3; GrossVolume: 0.000735702 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1801
HAUNCH BRACING PLATE | PL/1872

# IfcPlate: PLT3*558.7 (2)
In: Undefined
Description: PLT3*558.7; Material: STEEL/450
Tekla Common - Bottom elevation: +4.603; Top elevation: +5.299; Phase: 1; Class: 11
Tekla Quantity - Weight: 6.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.1 m2; Net surface area: 0.6 m2; Height: 558.7 mm; Width: 3 mm; Length: 767.8 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 558.733 mm; NetArea: 0.572492 m2; GrossArea: 0.429015 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000847447 m3; GrossVolume: 0.000862799 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1782
HAUNCH BRACING PLATE | PL/1793

# IfcPlate: PLT3*565.6 (8)
In: Undefined
Description: PLT3*565.6; Material: STEEL/450
Tekla Common - Bottom elevation: +4.577; Top elevation: +5.153; Phase: 1; Class: 1
Tekla Quantity - Weight: 8.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.8 m2; Height: 565.6 mm; Width: 3 mm; Length: 853.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - NetArea: 0.754232 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00111964 m3; GrossVolume: 0.00111964 m3
Name | ASSEMBLY_POS = Reference | Width (mm) | GrossArea (m2)
4 x PLATE | Z/1543 | 565.634 | 0.482802
4 x PLATE | Z/1542 | 565.637 | 0.482806

# IfcPlate: PLT3*565.7 (2)
In: Undefined
Description: PLT3*565.7; Material: STEEL/450
Tekla Common - Bottom elevation: +4.654; Top elevation: +5.383; Phase: 1; Class: 11
Tekla Quantity - Weight: 7.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.6 m2; Height: 565.7 mm; Width: 3 mm; Length: 806.9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 565.688 mm; NetArea: 0.616617 m2; GrossArea: 0.456472 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000913112 m3; GrossVolume: 0.000928463 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1784
HAUNCH BRACING PLATE | PL/1795

# IfcPlate: PLT3*565.9 (2)
In: Undefined
Description: PLT3*565.9; Material: STEEL/450
Tekla Common - Bottom elevation: +5.917; Top elevation: +6.330; Phase: 1; Class: 11
Tekla Quantity - Weight: 12.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 1.1 m2; Height: 565.9 mm; Width: 3 mm; Length: 1142.2 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 565.892 mm; NetArea: 1.10595 m2; GrossArea: 0.646335 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00164293 m3; GrossVolume: 0.0016684 m3
Name | ASSEMBLY_POS = Reference
APEX BRACING PLATE | PL/1937
APEX BRACING PLATE | PL/1948

# IfcPlate: PLT3*571.6 (4)
In: Undefined
Description: PLT3*571.6; Material: STEEL/450
Default - ASSEMBLY_POS: Z/957
Tekla Common - Bottom elevation: +5.479; Top elevation: +5.882; Phase: 1; Class: 1
Tekla Quantity - Weight: 9.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.8 m2; Height: 571.6 mm; Width: 3 mm; Length: 955.4 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/957
BaseQuantities - Width: 571.641 mm; NetArea: 0.801356 m2; GrossArea: 0.54616 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00118969 m3; GrossVolume: 0.00118969 m3

# IfcPlate: PLT3*572 (2)
In: Undefined
Description: PLT3*572; Material: STEEL/450
Tekla Common - Bottom elevation: +4.707; Top elevation: +5.474; Phase: 1; Class: 11
Tekla Quantity - Weight: 7.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.6 m2; Height: 572 mm; Width: 3 mm; Length: 855.8 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 572.034 mm; NetArea: 0.670391 m2; GrossArea: 0.489572 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000993136 m3; GrossVolume: 0.00100849 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1786
HAUNCH BRACING PLATE | PL/1797

# IfcPlate: PLT3*576 (4)
In: Undefined
Description: PLT3*576; Material: STEEL/450
Default - ASSEMBLY_POS: Z/1092
Tekla Common - Bottom elevation: +4.577; Top elevation: +5.192; Phase: 1; Class: 1
Tekla Quantity - Weight: 9.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.8 m2; Height: 576 mm; Width: 3 mm; Length: 879 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/1092
BaseQuantities - Width: 576.032 mm; NetArea: 0.778939 m2; GrossArea: 0.506333 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00115652 m3; GrossVolume: 0.00115652 m3

# IfcPlate: PLT3*576.1 (4)
In: Undefined
Description: PLT3*576.1; Material: STEEL/450
Tekla Common - Bottom elevation: +4.577; Top elevation: +5.192; Phase: 1; Class: 1
Default - ASSEMBLY_POS: Z/1093
Tekla Quantity - Weight: 9.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.8 m2; Height: 576.1 mm; Width: 3 mm; Length: 879 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/1093
BaseQuantities - Width: 576.057 mm; NetArea: 0.77894 m2; GrossArea: 0.506359 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00115653 m3; GrossVolume: 0.00115653 m3

# IfcPlate: PLT3*584.4 (2)
In: Undefined
Description: PLT3*584.4; Material: STEEL/450
Tekla Common - Bottom elevation: +4.833; Top elevation: +5.735; Phase: 1; Class: 11
Tekla Quantity - Weight: 10 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.8 m2; Height: 584.4 mm; Width: 3 mm; Length: 1034 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 584.392 mm; NetArea: 0.857649 m2; GrossArea: 0.604248 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00127182 m3; GrossVolume: 0.00128717 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1788
HAUNCH BRACING PLATE | PL/1799

# IfcPlate: PLT3*585.2 (8)
In: Undefined
Description: PLT3*585.2; Material: STEEL/450
Tekla Common - Bottom elevation: +4.577; Top elevation: +5.231; Phase: 1; Class: 1
Tekla Quantity - Weight: 9.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.8 m2; Height: 585.2 mm; Length: 904.9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Tekla Quantity, Width (mm) | BaseQuantities, Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
4 x PLATE | Z/1090 | 3 | 585.177 | 0.803909 | 0.529521 | 0.00119378
4 x PLATE | Z/1091 | 3.1 | 585.228 | 0.803911 | 0.529577 | 0.00119381

# IfcPlate: PLT3*591.5 (2)
In: Undefined
Description: PLT3*591.5; Material: STEEL/450
Tekla Common - Bottom elevation: +4.518; Top elevation: +5.240; Phase: 1; Class: 11
Tekla Quantity - Weight: 6.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.6 m2; Height: 591.5 mm; Width: 3 mm; Length: 772.3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 591.452 mm; NetArea: 0.588204 m2; GrossArea: 0.456753 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000870902 m3; GrossVolume: 0.000886253 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1802
HAUNCH BRACING PLATE | PL/1873

# IfcPlate: PLT3*597.3 (2)
In: Undefined
Description: PLT3*597.3; Material: STEEL/450
Tekla Common - Bottom elevation: +4.550; Top elevation: +5.291; Phase: 1; Class: 11
Tekla Quantity - Weight: 7.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.6 m2; Height: 597.3 mm; Width: 3 mm; Length: 792.9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 597.308 mm; NetArea: 0.615669 m2; GrossArea: 0.473598 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000911798 m3; GrossVolume: 0.00092715 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1804
HAUNCH BRACING PLATE | PL/1875

# IfcPlate: PLT3*601.4 (4)
In: Undefined
Description: PLT3*601.4; Material: STEEL/450
Default - ASSEMBLY_POS: Z/1088
Tekla Common - Bottom elevation: +4.578; Top elevation: +5.322; Phase: 1; Class: 1
Tekla Quantity - Weight: 10.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.8 m2; Height: 601.4 mm; Width: 3.1 mm; Length: 967.3 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/1088
BaseQuantities - Width: 601.441 mm; NetArea: 0.863374 m2; GrossArea: 0.581793 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.0012825 m3; GrossVolume: 0.0012825 m3

# IfcPlate: PLT3*601.6 (4)
In: Undefined
Description: PLT3*601.6; Material: STEEL/450
Tekla Common - Bottom elevation: +4.578; Top elevation: +5.322; Phase: 1; Class: 1
Default - ASSEMBLY_POS: Z/1089
Tekla Quantity - Weight: 10.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.8 m2; Height: 601.6 mm; Width: 3.1 mm; Length: 967.4 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/1089
BaseQuantities - Width: 601.577 mm; NetArea: 0.863379 m2; GrossArea: 0.58195 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00128254 m3; GrossVolume: 0.00128254 m3

# IfcPlate: PLT3*605.5 (2)
In: Undefined
Description: PLT3*605.5; Material: STEEL/450
Tekla Common - Bottom elevation: +4.600; Top elevation: +5.372; Phase: 1; Class: 11
Tekla Quantity - Weight: 7.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.6 m2; Height: 605.5 mm; Width: 3 mm; Length: 829.9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 605.522 mm; NetArea: 0.663627 m2; GrossArea: 0.502545 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000983213 m3; GrossVolume: 0.000998564 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1866
HAUNCH BRACING PLATE | PL/1877

# IfcPlate: PLT3*606.1 (8)
In: Undefined
Description: PLT3*606.1; Material: STEEL/450
Tekla Common - Bottom elevation: +4.577; Top elevation: +5.164; Phase: 1; Class: 1
Tekla Quantity - Weight: 10.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Height: 606.1 mm; Width: 3 mm; Length: 905.1 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - NetArea: 0.865061 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00128499 m3; GrossVolume: 0.00128499 m3
Name | ASSEMBLY_POS = Reference | Net surface area (m2) | Width (mm) | GrossArea (m2)
PLATE | Z/1432 | 1 | 606.062 | 0.548534
PLATE | Z/666 | 1 | 606.065 | 0.548538
3 x PLATE | Z/1432 | 0.8 | 606.062 | 0.548534
3 x PLATE | Z/666 | 0.8 | 606.065 | 0.548538

# IfcPlate: PLT3*609.8 (8)
In: Undefined
Description: PLT3*609.8; Material: STEEL/450
Tekla Common - Bottom elevation: +4.577; Top elevation: +5.128; Phase: 1; Class: 1
Tekla Quantity - Weight: 8.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.6 m2; Height: 609.9 mm; Width: 3 mm; Length: 897 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 609.776 mm; GrossArea: 0.546967 m2; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | NetArea (m2) | NetVolume (m3) = GrossVolume (m3)
2 x PLATE | Z/2409 | 0.739981 | 0.00109836
2 x PLATE | Z/2408 | 0.739984 | 0.00109837
2 x PLATE | Z/2408 | 0.739982 | 0.00109837
2 x PLATE | Z/2409 | 0.739983 | 0.00109837

# IfcPlate: PLT3*609.9 (4)
In: Undefined
Description: PLT3*609.9; Material: STEEL/450
Default - ASSEMBLY_POS: Z/1094
Tekla Common - Bottom elevation: +5.683; Top elevation: +6.112; Phase: 1; Class: 1
Tekla Quantity - Weight: 9.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.8 m2; Height: 609.9 mm; Width: 3 mm; Length: 968.2 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/1094
BaseQuantities - Width: 609.9 mm; NetArea: 0.826034 m2; GrossArea: 0.590519 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00122661 m3; GrossVolume: 0.00122661 m3

# IfcPlate: PLT3*613 (2)
In: Undefined
Description: PLT3*613; Material: STEEL/450
Tekla Common - Bottom elevation: +4.649; Top elevation: +5.460; Phase: 1; Class: 11
Tekla Quantity - Weight: 8.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.6 m2; Height: 613 mm; Width: 3 mm; Length: 876.7 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 613.013 mm; NetArea: 0.722137 m2; GrossArea: 0.537449 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00107034 m3; GrossVolume: 0.00108569 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1868
HAUNCH BRACING PLATE | PL/1879

# IfcPlate: PLT3*618.8 (8)
In: Undefined
Description: PLT3*618.8; Material: STEEL/450
Tekla Common - Bottom elevation: +4.577; Top elevation: +5.205; Phase: 1; Class: 1
Tekla Quantity - Weight: 10.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.7 m2; Height: 618.8 mm; Width: 3 mm; Length: 932.1 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Net surface area (m2) | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
PLATE | Z/1119 | 1 | 618.779 | 0.896833 | 0.576777 | 0.00133246
PLATE | Z/1120 | 1 | 618.804 | 0.896834 | 0.576804 | 0.00133245
3 x PLATE | Z/1119 | 0.8 | 618.779 | 0.896833 | 0.576777 | 0.00133246
3 x PLATE | Z/1120 | 0.8 | 618.804 | 0.896834 | 0.576804 | 0.00133245

# IfcPlate: PLT3*623.4 (4)
In: Undefined
Description: PLT3*623.4; Material: STEEL/450
Default - ASSEMBLY_POS: Z/2417
Tekla Common - Bottom elevation: +5.299; Top elevation: +5.736; Phase: 1; Class: 1
Tekla Quantity - Weight: 10.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.7 m2; Net surface area: 0.8 m2; Height: 623.4 mm; Width: 3 mm; Length: 965.9 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/2417
BaseQuantities - Width: 623.448 mm; NetArea: 0.929783 m2; GrossArea: 0.602188 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00138161 m3; GrossVolume: 0.00138161 m3

# IfcPlate: PLT3*627.6 (2)
In: Undefined
Description: PLT3*627.6; Material: STEEL/450
Tekla Common - Bottom elevation: +4.769; Top elevation: +5.713; Phase: 1; Class: 11
Tekla Quantity - Weight: 10.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.8 m2; Height: 627.6 mm; Width: 3 mm; Length: 1049.7 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 627.623 mm; NetArea: 0.926253 m2; GrossArea: 0.658822 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00137431 m3; GrossVolume: 0.00138966 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1870
HAUNCH BRACING PLATE | PL/1881

# IfcPlate: PLT3*630.2 (4)
In: Undefined
Description: PLT3*630.2; Material: STEEL/450
Default - ASSEMBLY_POS: Z/1117
Tekla Common - Bottom elevation: +4.577; Top elevation: +5.247; Phase: 1; Class: 1
Tekla Quantity - Weight: 10.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.7 m2; Height: 630.2 mm; Width: 3.1 mm; Length: 959.6 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/1117
BaseQuantities - Width: 630.227 mm; NetArea: 0.929235 m2; GrossArea: 0.604746 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00138086 m3; GrossVolume: 0.00138086 m3
Name | Net surface area (m2)
PLATE | 1
3 x PLATE | 0.8

# IfcPlate: PLT3*630.3 (4)
In: Undefined
Description: PLT3*630.3; Material: STEEL/450
Tekla Common - Bottom elevation: +4.577; Top elevation: +5.247; Phase: 1; Class: 1
Default - ASSEMBLY_POS: Z/1118
Tekla Quantity - Weight: 10.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.7 m2; Height: 630.3 mm; Width: 3 mm; Length: 959.6 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/1118
BaseQuantities - Width: 630.281 mm; NetArea: 0.929236 m2; GrossArea: 0.604807 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00138084 m3; GrossVolume: 0.00138084 m3
Name | Net surface area (m2)
PLATE | 1
3 x PLATE | 0.8

# IfcPlate: PLT3*638.9 (2)
In: Undefined
Description: PLT3*638.9; Material: STEEL/450
Tekla Common - Bottom elevation: +3.801; Top elevation: +4.391; Phase: 1; Class: 11
Tekla Quantity - Weight: 7.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.6 m2; Height: 638.9 mm; Width: 3 mm; Length: 746.3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 638.859 mm; GrossArea: 0.476757 m2; CrossSectionArea: 0.000009 m2; GrossVolume: 0.000932062 m3
Name | ASSEMBLY_POS = Reference | NetArea (m2) | NetVolume (m3)
HAUNCH BRACING PLATE | PL/1883 | 0.611964 | 0.00090658
HAUNCH BRACING PLATE | PL/1894 | 0.611963 | 0.000906579

# IfcPlate: PLT3*645.5 (4)
In: Undefined
Description: PLT3*645.5; Material: STEEL/450
