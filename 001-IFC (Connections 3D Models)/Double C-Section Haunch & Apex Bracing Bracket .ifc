Properties of the parts of a building model (IFC2X3), part 3 of 4

# IfcPlate: PLT3*355.8 (2)
Tekla Quantity - Weight: 2.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.9 m2; Net surface area: 0.3 m2; Height: 355.8 mm; Width: 3 mm; Length: 555.2 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 355.755 mm; NetArea: 0.260153 m2; GrossArea: 0.197529 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000381368 m3; GrossVolume: 0.000397838 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1716
HAUNCH BRACING PLATE | PL/1727

# IfcPlate: PLT3*359.8 (2)
In: Undefined
Description: PLT3*359.8; Material: STEEL/450
Default - ASSEMBLY_POS: Z/2406
Tekla Common - Bottom elevation: +5.469; Top elevation: +5.723; Phase: 1; Class: 1
Tekla Quantity - Weight: 3.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.3 m2; Height: 359.8 mm; Width: 3 mm; Length: 519.2 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/2406
BaseQuantities - Width: 359.788 mm; NetArea: 0.292934 m2; GrossArea: 0.186786 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000432182 m3; GrossVolume: 0.000432182 m3

# IfcPlate: PLT3*359.9 (2)
In: Undefined
Description: PLT3*359.9; Material: STEEL/450
Tekla Common - Bottom elevation: +4.873; Top elevation: +5.378; Phase: 1; Class: 11
Tekla Quantity - Weight: 3.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.9 m2; Net surface area: 0.3 m2; Height: 359.9 mm; Width: 3 mm; Length: 579.3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 359.911 mm; NetArea: 0.277584 m2; GrossArea: 0.208487 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000407114 m3; GrossVolume: 0.000423583 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1718
HAUNCH BRACING PLATE | PL/1729

# IfcPlate: PLT3*363.7 (2)
In: Undefined
Description: PLT3*363.7; Material: STEEL/450
Tekla Common - Bottom elevation: +4.935; Top elevation: +5.464; Phase: 1; Class: 11
Tekla Quantity - Weight: 3.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.9 m2; Net surface area: 0.3 m2; Height: 363.8 mm; Width: 3 mm; Length: 609.4 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 363.711 mm; NetArea: 0.298804 m2; GrossArea: 0.221631 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000438457 m3; GrossVolume: 0.000454927 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1720
HAUNCH BRACING PLATE | PL/1731

# IfcPlate: PLT3*363.8 (4)
In: Undefined
Description: PLT3*363.8; Material: STEEL/450
Tekla Common - Bottom elevation: +4.775; Top elevation: +5.192; Phase: 1; Class: 1
Tekla Quantity - Weight: 3.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.3 m2; Height: 363.8 mm; Width: 3 mm; Length: 564.9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 363.821 mm; NetArea: 0.315463 m2; GrossArea: 0.205516 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00046552 m3; GrossVolume: 0.00046552 m3
Name | ASSEMBLY_POS = Reference
2 x PLATE | Z/1030
2 x PLATE | Z/1031

# IfcPlate: PLT3*365.2 (2)
In: Undefined
Description: PLT3*365.2; Material: STEEL/450
Tekla Common - Bottom elevation: +6.047; Top elevation: +6.327; Phase: 1; Class: 11
Tekla Quantity - Weight: 5.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.5 m2; Net surface area: 0.3 m2; Height: 365.2 mm; Width: 3 mm; Length: 764.8 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 365.234 mm; NetArea: 0.448403 m2; GrossArea: 0.279326 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000660704 m3; GrossVolume: 0.000677173 m3
Name | ASSEMBLY_POS = Reference
APEX BRACING PLATE | PL/1745
APEX BRACING PLATE | PL/1756

# IfcPlate: PLT3*371.1 (2)
In: Undefined
Description: PLT3*371.1; Material: STEEL/450
Tekla Common - Bottom elevation: +5.088; Top elevation: +5.700; Phase: 1; Class: 11
Tekla Quantity - Weight: 4.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.7 m2; Net surface area: 0.3 m2; Height: 371.1 mm; Width: 3 mm; Length: 718.9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 371.112 mm; NetArea: 0.372606 m2; GrossArea: 0.266777 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000547474 m3; GrossVolume: 0.000563944 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1722
HAUNCH BRACING PLATE | PL/1733

# IfcPlate: PLT3*373.7 (2)
In: Undefined
Description: PLT3*373.7; Material: STEEL/450
Default - ASSEMBLY_POS: Z/187
Tekla Common - Bottom elevation: +5.609; Top elevation: +5.872; Phase: 1; Class: 1
Tekla Quantity - Weight: 3.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.3 m2; Height: 373.7 mm; Width: 3 mm; Length: 529.1 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/187
BaseQuantities - Width: 373.729 mm; NetArea: 0.298692 m2; GrossArea: 0.197735 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000440768 m3; GrossVolume: 0.000440768 m3

# IfcPlate: PLT3*376.6 (4)
In: Undefined
Description: PLT3*376.6; Material: STEEL/450
Tekla Common - Phase: 1; Class: 11
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 376.6 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 376.621 mm; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) | GrossVolume (m3)
APEX BRACING PLATE | PL/1781 | +5.042 | +5.333 | 14.5 | 86.1 | 1.2 | 1762.2 | 1.24722 | 0.663679 | 0.00184443 | 0.0018609
APEX BRACING PLATE | PL/1759 | +5.093 | +5.384 | 11.1 | 86.3 | 1 | 1473 | 0.959713 | 0.554746 | 0.0014174 | 0.00143387
APEX BRACING PLATE | PL/1792 | +5.042 | +5.333 | 14.5 | 86.1 | 1.2 | 1762.2 | 1.24722 | 0.663679 | 0.00184443 | 0.0018609
APEX BRACING PLATE | PL/1770 | +5.093 | +5.384 | 11.1 | 86.3 | 1 | 1473 | 0.959712 | 0.554746 | 0.0014174 | 0.00143387

# IfcPlate: PLT3*382.5 (4)
In: Undefined
Description: PLT3*382.5; Material: STEEL/450
Tekla Common - Phase: 1; Class: 11
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 382.5 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Length (mm) | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) | GrossVolume (m3)
APEX BRACING PLATE | PL/1783 | +5.156 | +5.454 | 12.4 | 86.1 | 1.1 | 1515.9 | 382.467 | 1.07142 | 0.579774 | 0.0015842 | 0.00160067
APEX BRACING PLATE | PL/1794 | +5.156 | +5.454 | 12.4 | 86.1 | 1.1 | 1515.9 | 382.467 | 1.07142 | 0.579774 | 0.0015842 | 0.00160067
APEX BRACING PLATE | PL/1761 | +5.207 | +5.505 | 9.7 | 86.3 | 0.8 | 1275.9 | 382.466 | 0.828633 | 0.488003 | 0.00122357 | 0.00124004
APEX BRACING PLATE | PL/1772 | +5.207 | +5.505 | 9.7 | 86.3 | 0.8 | 1275.9 | 382.466 | 0.828633 | 0.488003 | 0.00122357 | 0.00124004

# IfcPlate: PLT3*390.6 (4)
In: Undefined
Description: PLT3*390.6; Material: STEEL/450
Tekla Common - Phase: 1; Class: 11
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 390.6 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Length (mm) | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) | GrossVolume (m3)
APEX BRACING PLATE | PL/1785 | +5.331 | +5.637 | 10.5 | 86.1 | 0.8 | 1272.3 | 390.56 | 0.895154 | 0.496914 | 0.00132327 | 0.00133974
APEX BRACING PLATE | PL/1796 | +5.331 | +5.637 | 10.5 | 86.1 | 0.8 | 1272.3 | 390.56 | 0.895154 | 0.496914 | 0.00132327 | 0.00133974
APEX BRACING PLATE | PL/1763 | +5.382 | +5.688 | 8.1 | 86.3 | 0.6 | 1082 | 390.561 | 0.697255 | 0.422581 | 0.00102927 | 0.00104574
APEX BRACING PLATE | PL/1774 | +5.382 | +5.688 | 8.1 | 86.3 | 0.6 | 1082 | 390.561 | 0.697255 | 0.422581 | 0.00102927 | 0.00104574

# IfcPlate: PLT3*393.6 (2)
In: Undefined
Description: PLT3*393.6; Material: STEEL/450
Default - ASSEMBLY_POS: Z/1036
Tekla Common - Bottom elevation: +5.822; Top elevation: +6.099; Phase: 1; Class: 1
Tekla Quantity - Weight: 3.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.3 m2; Height: 393.6 mm; Width: 3 mm; Length: 541.3 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/1036
BaseQuantities - Width: 393.583 mm; NetArea: 0.307078 m2; GrossArea: 0.213063 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000453276 m3; GrossVolume: 0.000453276 m3

# IfcPlate: PLT3*397.8 (4)
In: Undefined
Description: PLT3*397.8; Material: STEEL/450
Tekla Common - Phase: 1; Class: 11
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 397.8 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 397.831 mm; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) | GrossVolume (m3)
APEX BRACING PLATE | PL/1787 | +5.510 | +5.822 | 9 | 86.1 | 0.8 | 1112.6 | 0.777193 | 0.44262 | 0.00114863 | 0.0011651
APEX BRACING PLATE | PL/1798 | +5.510 | +5.822 | 9 | 86.1 | 0.8 | 1112.6 | 0.777192 | 0.44262 | 0.00114863 | 0.0011651
APEX BRACING PLATE | PL/1765 | +5.561 | +5.874 | 7.1 | 86.3 | 0.6 | 955.6 | 0.609366 | 0.380174 | 0.000899262 | 0.000915731
APEX BRACING PLATE | PL/1776 | +5.561 | +5.874 | 7.1 | 86.3 | 0.6 | 955.6 | 0.609366 | 0.380174 | 0.000899262 | 0.000915731

# IfcPlate: PLT3*410.8 (4)
In: Undefined
Description: PLT3*410.8; Material: STEEL/450
Default - ASSEMBLY_POS: Z/2424
Tekla Common - Bottom elevation: +5.422; Top elevation: +5.727; Phase: 1; Class: 1
Tekla Quantity - Weight: 3.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.1 m2; Net surface area: 0.3 m2; Height: 410.8 mm; Width: 3 mm; Length: 536.6 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/2424
BaseQuantities - Width: 410.79 mm; NetArea: 0.347447 m2; GrossArea: 0.220441 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00051341 m3; GrossVolume: 0.00051341 m3

# IfcPlate: PLT3*411.5 (4)
In: Undefined
Description: PLT3*411.5; Material: STEEL/450
Tekla Common - Phase: 1; Class: 11
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 411.5 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Length (mm) | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) | GrossVolume (m3)
APEX BRACING PLATE | PL/1789 | +5.951 | +6.278 | 7.1 | 86.1 | 0.6 | 895.7 | 411.461 | 0.610736 | 0.368552 | 0.00090214 | 0.000918609
APEX BRACING PLATE | PL/1800 | +5.951 | +6.278 | 7.1 | 86.1 | 0.6 | 895.7 | 411.461 | 0.610735 | 0.368551 | 0.00090214 | 0.000918609
APEX BRACING PLATE | PL/1767 | +6.002 | +6.329 | 5.6 | 86.3 | 0.5 | 786.3 | 411.451 | 0.48546 | 0.323539 | 0.000715912 | 0.000732381
APEX BRACING PLATE | PL/1778 | +6.002 | +6.329 | 5.6 | 86.3 | 0.5 | 786.3 | 411.451 | 0.48546 | 0.323539 | 0.000715912 | 0.000732381

# IfcPlate: PLT3*412 (2)
In: Undefined
Description: PLT3*412; Material: STEEL/450
Default - ASSEMBLY_POS: Z/1037
Tekla Common - Bottom elevation: +6.041; Top elevation: +6.332; Phase: 1; Class: 1
Tekla Quantity - Weight: 3.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.3 m2; Height: 412 mm; Width: 3 mm; Length: 550.3 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/1037
BaseQuantities - Width: 411.971 mm; NetArea: 0.315115 m2; GrossArea: 0.226702 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000465263 m3; GrossVolume: 0.000465263 m3

# IfcPlate: PLT3*421.9 (2)
In: Undefined
Description: PLT3*421.9; Material: STEEL/450
Tekla Common - Bottom elevation: +4.999; Top elevation: +5.336; Phase: 1; Class: 11
Tekla Quantity - Weight: 15.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.1 m2; Net surface area: 1.2 m2; Height: 421.9 mm; Width: 3 mm; Length: 1770.2 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 421.923 mm; NetArea: 1.3274 m2; GrossArea: 0.746873 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00196444 m3; GrossVolume: 0.00198091 m3
Name | ASSEMBLY_POS = Reference
APEX BRACING PLATE | PL/1803
APEX BRACING PLATE | PL/1874

# IfcPlate: PLT3*424.7 (4)
In: Undefined
Description: PLT3*424.7; Material: STEEL/450
Default - ASSEMBLY_POS: Z/1288
Tekla Common - Bottom elevation: +5.562; Top elevation: +5.877; Phase: 1; Class: 1
Tekla Quantity - Weight: 4.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.1 m2; Net surface area: 0.3 m2; Height: 424.7 mm; Width: 3 mm; Length: 549.8 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/1288
BaseQuantities - Width: 424.728 mm; NetArea: 0.354893 m2; GrossArea: 0.23353 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000524514 m3; GrossVolume: 0.000524514 m3

# IfcPlate: PLT3*426.1 (8)
In: Undefined
Description: PLT3*426.1; Material: STEEL/450
Tekla Common - Bottom elevation: +4.692; Top elevation: +5.119; Phase: 1; Class: 1
Tekla Quantity - Weight: 5.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.1 m2; Net surface area: 0.3 m2; Height: 426.1 mm; Width: 3 mm; Length: 656.1 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - NetArea: 0.449082 m2; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Width (mm) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
4 x PLATE | Z/1289 | 426.082 | 0.27956 | 0.000664572
4 x PLATE | Z/1287 | 426.096 | 0.279571 | 0.000664571

# IfcPlate: PLT3*427.5 (2)
In: Undefined
Description: PLT3*427.5; Material: STEEL/450
Tekla Common - Bottom elevation: +5.115; Top elevation: +5.457; Phase: 1; Class: 11
Tekla Quantity - Weight: 13.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.1 m2; Net surface area: 1.1 m2; Height: 427.5 mm; Width: 3 mm; Length: 1525.4 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 427.46 mm; NetArea: 1.14007 m2; GrossArea: 0.652064 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00168692 m3; GrossVolume: 0.00170339 m3
Name | ASSEMBLY_POS = Reference
APEX BRACING PLATE | PL/1865
APEX BRACING PLATE | PL/1876

# IfcPlate: PLT3*434.8 (2)
In: Undefined
Description: PLT3*434.8; Material: STEEL/450
Tekla Common - Bottom elevation: +3.821; Top elevation: +4.274; Phase: 1; Class: 11
Tekla Quantity - Weight: 3.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.7 m2; Net surface area: 0.3 m2; Height: 434.8 mm; Width: 3 mm; Length: 580.7 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 434.818 mm; NetArea: 0.325326 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000478616 m3; GrossVolume: 0.000495761 m3
Name | ASSEMBLY_POS = Reference | GrossArea (m2)
HAUNCH BRACING PLATE | PL/1735 | 0.252491
HAUNCH BRACING PLATE | PL/1746 | 0.25249

# IfcPlate: PLT3*435 (2)
In: Undefined
Description: PLT3*435; Material: STEEL/450
Tekla Common - Bottom elevation: +5.290; Top elevation: +5.640; Phase: 1; Class: 11
Tekla Quantity - Weight: 11.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.1 m2; Net surface area: 1 m2; Height: 435 mm; Width: 3 mm; Length: 1284.2 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 434.993 mm; GrossArea: 0.558627 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00140874 m3; GrossVolume: 0.00142521 m3
Name | ASSEMBLY_POS = Reference | NetArea (m2)
APEX BRACING PLATE | PL/1867 | 0.952321
APEX BRACING PLATE | PL/1878 | 0.95232

# IfcPlate: PLT3*435.4 (4)
In: Undefined
Description: PLT3*435.4; Material: STEEL/450
Default - ASSEMBLY_POS: Z/1062
Tekla Common - Bottom elevation: +4.692; Top elevation: +5.149; Phase: 1; Class: 1
Tekla Quantity - Weight: 5.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.1 m2; Net surface area: 0.5 m2; Height: 435.4 mm; Width: 3 mm; Length: 675.7 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/1062
BaseQuantities - Width: 435.438 mm; NetArea: 0.465321 m2; GrossArea: 0.294207 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000688788 m3; GrossVolume: 0.000688788 m3

# IfcPlate: PLT3*435.5 (4)
In: Undefined
Description: PLT3*435.5; Material: STEEL/450
Tekla Common - Bottom elevation: +4.692; Top elevation: +5.149; Phase: 1; Class: 1
Tekla Quantity - Weight: 5.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.1 m2; Net surface area: 0.5 m2; Height: 435.4 mm; Width: 3 mm; Length: 675.7 mm
Default - ASSEMBLY_POS: Z/1063
Pset_PlateCommon - LoadBearing: no; Reference: Z/1063
BaseQuantities - Width: 435.459 mm; NetArea: 0.465321 m2; GrossArea: 0.294224 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000688799 m3; GrossVolume: 0.000688799 m3

# IfcPlate: PLT3*441.6 (2)
In: Undefined
Description: PLT3*441.6; Material: STEEL/450
Tekla Common - Bottom elevation: +5.470; Top elevation: +5.826; Phase: 1; Class: 11
Tekla Quantity - Weight: 9.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.1 m2; Net surface area: 0.8 m2; Height: 441.6 mm; Width: 3 mm; Length: 1126.8 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 441.582 mm; NetArea: 0.826737 m2; GrossArea: 0.497572 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00122265 m3; GrossVolume: 0.00123912 m3
Name | ASSEMBLY_POS = Reference
APEX BRACING PLATE | PL/1869
APEX BRACING PLATE | PL/1880

# IfcPlate: PLT3*443.8 (4)
In: Undefined
Description: PLT3*443.8; Material: STEEL/450
Default - ASSEMBLY_POS: Z/1060
Tekla Common - Bottom elevation: +4.692; Top elevation: +5.180; Phase: 1; Class: 1
Tekla Quantity - Weight: 5.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.5 m2; Height: 443.8 mm; Width: 3 mm; Length: 695.5 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/1060
BaseQuantities - Width: 443.844 mm; NetArea: 0.48188 m2; GrossArea: 0.308713 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000713477 m3; GrossVolume: 0.000713477 m3

# IfcPlate: PLT3*443.9 (4)
In: Undefined
Description: PLT3*443.9; Material: STEEL/450
Tekla Common - Bottom elevation: +4.692; Top elevation: +5.180; Phase: 1; Class: 1
Default - ASSEMBLY_POS: Z/1061
Tekla Quantity - Weight: 5.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.5 m2; Height: 443.9 mm; Width: 3 mm; Length: 695.6 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/1061
BaseQuantities - Width: 443.894 mm; NetArea: 0.481881 m2; GrossArea: 0.308754 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000713497 m3; GrossVolume: 0.000713497 m3

# IfcPlate: PLT3*444.6 (4)
In: Undefined
Description: PLT3*444.6; Material: STEEL/450
Default - ASSEMBLY_POS: Z/1064
Tekla Common - Bottom elevation: +5.776; Top elevation: +6.105; Phase: 1; Class: 1
Tekla Quantity - Weight: 4.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.1 m2; Net surface area: 0.3 m2; Height: 444.6 mm; Width: 3 mm; Length: 566.8 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/1064
BaseQuantities - Width: 444.577 mm; NetArea: 0.365885 m2; GrossArea: 0.252 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000540905 m3; GrossVolume: 0.000540905 m3

# IfcPlate: PLT3*448.1 (2)
In: Undefined
Description: PLT3*448.1; Material: STEEL/450
Default - ASSEMBLY_POS: Z/1038
Tekla Common - Bottom elevation: +6.585; Top elevation: +6.912; Phase: 1; Class: 1
Tekla Quantity - Weight: 3.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.1 m2; Net surface area: 0.3 m2; Height: 448.1 mm; Width: 3 mm; Length: 558.1 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/1038
BaseQuantities - Width: 448.062 mm; NetArea: 0.332573 m2; GrossArea: 0.250076 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000491299 m3; GrossVolume: 0.000491299 m3

# IfcPlate: PLT3*453.1 (2)
In: Undefined
Description: PLT3*453.1; Material: STEEL/450
Tekla Common - Bottom elevation: +5.912; Top elevation: +6.280; Phase: 1; Class: 11
Tekla Quantity - Weight: 7.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.1 m2; Net surface area: 0.6 m2; Height: 453.1 mm; Width: 3 mm; Length: 915.2 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 453.143 mm; NetArea: 0.6497 m2; GrossArea: 0.414695 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00096026 m3; GrossVolume: 0.000976729 m3
Name | ASSEMBLY_POS = Reference
APEX BRACING PLATE | PL/1871
APEX BRACING PLATE | PL/1882

# IfcPlate: PLT3*456.9 (2)
In: Undefined
Description: PLT3*456.9; Material: STEEL/450
Tekla Common - Bottom elevation: +4.953; Top elevation: +5.290; Phase: 1; Class: 11
Tekla Quantity - Weight: 20.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 1.7 m2; Height: 456.9 mm; Width: 3 mm; Length: 2031 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 456.924 mm; NetArea: 1.74945 m2; GrossArea: 0.92803 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00259344 m3; GrossVolume: 0.00262004 m3
Name | ASSEMBLY_POS = Reference
APEX BRACING PLATE | PL/1885
APEX BRACING PLATE | PL/1896

# IfcPlate: PLT3*457.6 (2)
In: Undefined
Description: PLT3*457.6; Material: STEEL/450
Tekla Common - Bottom elevation: +4.670; Top elevation: +5.245; Phase: 1; Class: 11
Tekla Quantity - Weight: 4.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.5 m2; Net surface area: 0.3 m2; Height: 457.6 mm; Width: 3 mm; Length: 643.8 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 457.564 mm; NetArea: 0.388541 m2; GrossArea: 0.29457 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.0005723 m3; GrossVolume: 0.000588769 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1736
HAUNCH BRACING PLATE | PL/1747

# IfcPlate: PLT3*458.3 (4)
In: Undefined
Description: PLT3*458.3; Material: STEEL/450
Tekla Common - Bottom elevation: +4.692; Top elevation: +5.099; Phase: 1; Class: 1
Tekla Quantity - Weight: 5.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.1 m2; Net surface area: 0.3 m2; Height: 458.3 mm; Width: 3 mm; Length: 679.4 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 458.296 mm; GrossArea: 0.311382 m2; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | NetArea (m2) | NetVolume (m3) = GrossVolume (m3)
2 x PLATE | Z/2426 | 0.439846 | 0.000650793
PLATE | Z/2429 | 0.439847 | 0.000650793
PLATE | Z/2429 | 0.439847 | 0.000650794

# IfcPlate: PLT3*459.7 (4)
In: Undefined
Description: PLT3*459.7; Material: STEEL/450
Default - ASSEMBLY_POS: Z/1058
Tekla Common - Bottom elevation: +4.692; Top elevation: +5.252; Phase: 1; Class: 1
Tekla Quantity - Weight: 6.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.5 m2; Height: 459.7 mm; Width: 3.1 mm; Length: 743.7 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/1058
BaseQuantities - Width: 459.656 mm; NetArea: 0.521886 m2; GrossArea: 0.341847 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.0007731 m3; GrossVolume: 0.0007731 m3

# IfcPlate: PLT3*459.8 (8)
In: Undefined
Description: PLT3*459.8; Material: STEEL/450
Tekla Common - Bottom elevation: +4.692; Phase: 1; Class: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 459.7 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000009 m2
Name | Top elevation | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Tekla Quantity, Width (mm) | Length (mm) | ASSEMBLY_POS = Reference | BaseQuantities, Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
4 x PLATE | +5.252 | 6.1 | 86 | 0.5 | 3.1 | 743.7 | Z/1059 | 459.8 | 0.521888 | 0.341971 | 0.000773137
2 x PLATE | +5.099 | 5.2 | 86.1 | 0.3 | 3 | 681.3 | Z/2425 | 459.788 | 0.438155 | 0.313255 | 0.000648274
2 x PLATE | +5.099 | 5.2 | 86.1 | 0.3 | 3 | 681.3 | Z/2430 | 459.788 | 0.438154 | 0.313255 | 0.000648271

# IfcPlate: PLT3*461.5 (2)
In: Undefined
Description: PLT3*461.5; Material: STEEL/450
Tekla Common - Bottom elevation: +4.707; Top elevation: +5.298; Phase: 1; Class: 11
Tekla Quantity - Weight: 4.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.5 m2; Net surface area: 0.3 m2; Height: 461.5 mm; Width: 3 mm; Length: 661.5 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 461.529 mm; NetArea: 0.405511 m2; GrossArea: 0.305305 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000597449 m3; GrossVolume: 0.000613919 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1738
HAUNCH BRACING PLATE | PL/1749

# IfcPlate: PLT3*462.5 (2)
In: Undefined
Description: PLT3*462.5; Material: STEEL/450
Tekla Common - Bottom elevation: +5.069; Top elevation: +5.411; Phase: 1; Class: 11
Tekla Quantity - Weight: 17.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 1.4 m2; Height: 462.5 mm; Width: 3 mm; Length: 1741.9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 462.464 mm; NetArea: 1.49565 m2; GrossArea: 0.805546 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00221683 m3; GrossVolume: 0.00224342 m3
Name | ASSEMBLY_POS = Reference
APEX BRACING PLATE | PL/1887
APEX BRACING PLATE | PL/1898

# IfcPlate: PLT3*463 (4)
In: Undefined
Description: PLT3*463; Material: STEEL/450
Default - ASSEMBLY_POS: Z/1065
Tekla Common - Bottom elevation: +5.996; Top elevation: +6.341; Phase: 1; Class: 1
Tekla Quantity - Weight: 4.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.1 m2; Net surface area: 0.3 m2; Height: 463 mm; Width: 3 mm; Length: 580.3 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/1065
BaseQuantities - NetArea: 0.376626 m2; GrossArea: 0.268651 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000556923 m3; GrossVolume: 0.000556923 m3
Name | Width (mm)
2 x PLATE | 462.974
2 x PLATE | 462.973

# IfcPlate: PLT3*467.1 (2)
In: Undefined
Description: PLT3*467.1; Material: STEEL/450
Tekla Common - Bottom elevation: +4.764; Top elevation: +5.380; Phase: 1; Class: 11
Tekla Quantity - Weight: 5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.3 m2; Height: 467.1 mm; Width: 3 mm; Length: 693.1 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 467.083 mm; NetArea: 0.435114 m2; GrossArea: 0.323739 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000641323 m3; GrossVolume: 0.000657793 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1740
HAUNCH BRACING PLATE | PL/1751

# IfcPlate: PLT3*470 (2)
In: Undefined
Description: PLT3*470; Material: STEEL/450
Tekla Common - Bottom elevation: +5.244; Top elevation: +5.594; Phase: 1; Class: 11
Tekla Quantity - Weight: 14.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 1.2 m2; Height: 470 mm; Width: 3 mm; Length: 1455.9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 469.994 mm; NetArea: 1.24112 m2; GrossArea: 0.684263 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00183912 m3; GrossVolume: 0.00186571 m3
Name | ASSEMBLY_POS = Reference
APEX BRACING PLATE | PL/1889
APEX BRACING PLATE | PL/1900

# IfcPlate: PLT3*470.9 (2)
In: Undefined
Description: PLT3*470.9; Material: STEEL/450
Tekla Common - Bottom elevation: +3.847; Top elevation: +4.299; Phase: 1; Class: 11
Tekla Quantity - Weight: 4.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.5 m2; Net surface area: 0.3 m2; Height: 470.9 mm; Width: 3 mm; Length: 616.7 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 470.878 mm; NetArea: 0.354912 m2; GrossArea: 0.29041 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000522536 m3; GrossVolume: 0.000539681 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1757
HAUNCH BRACING PLATE | PL/1768

# IfcPlate: PLT3*472.2 (2)
In: Undefined
Description: PLT3*472.2; Material: STEEL/450
Tekla Common - Bottom elevation: +4.821; Top elevation: +5.469; Phase: 1; Class: 11
Tekla Quantity - Weight: 5.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.5 m2; Height: 472.2 mm; Width: 3 mm; Length: 732.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 472.15 mm; NetArea: 0.471148 m2; GrossArea: 0.345893 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000694732 m3
Name | ASSEMBLY_POS = Reference | GrossVolume (m3)
HAUNCH BRACING PLATE | PL/1742 | 0.000711202
HAUNCH BRACING PLATE | PL/1753 | 0.000711201

# IfcPlate: PLT3*476.6 (2)
In: Undefined
Description: PLT3*476.6; Material: STEEL/450
Tekla Common - Bottom elevation: +5.424; Top elevation: +5.780; Phase: 1; Class: 11
Tekla Quantity - Weight: 12.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 1.1 m2; Height: 476.6 mm; Width: 3 mm; Length: 1268.4 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 476.584 mm; NetArea: 1.07074 m2; GrossArea: 0.604483 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00158626 m3; GrossVolume: 0.00161285 m3
Name | ASSEMBLY_POS = Reference
APEX BRACING PLATE | PL/1891
APEX BRACING PLATE | PL/1902

# IfcPlate: PLT3*482 (2)
In: Undefined
Description: PLT3*482; Material: STEEL/450
Tekla Common - Bottom elevation: +4.961; Top elevation: +5.717; Phase: 1; Class: 11
Tekla Quantity - Weight: 6.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.6 m2; Height: 482 mm; Width: 3 mm; Length: 876.4 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 482.04 mm; NetArea: 0.596588 m2; GrossArea: 0.422459 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000880664 m3; GrossVolume: 0.000897134 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1744
HAUNCH BRACING PLATE | PL/1755

# IfcPlate: PLT3*488.1 (2)
In: Undefined
Description: PLT3*488.1; Material: STEEL/450
Tekla Common - Bottom elevation: +5.866; Top elevation: +6.234; Phase: 1; Class: 11
Tekla Quantity - Weight: 9.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.8 m2; Height: 488.1 mm; Width: 3 mm; Length: 1013.8 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 488.143 mm; NetArea: 0.830191 m2; GrossArea: 0.494879 m2; CrossSectionArea: 0.000009 m2; GrossVolume: 0.00125579 m3
Name | ASSEMBLY_POS = Reference | NetVolume (m3)
APEX BRACING PLATE | PL/1893 | 0.0012292
APEX BRACING PLATE | PL/1904 | 0.00122919

# IfcPlate: PLT3*499.1 (4)
In: Undefined
Description: PLT3*499.1; Material: STEEL/450
Default - ASSEMBLY_POS: Z/1066
Tekla Common - Bottom elevation: +6.540; Top elevation: +6.924; Phase: 1; Class: 1
Tekla Quantity - Weight: 4.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.1 m2; Net surface area: 0.3 m2; Height: 499.1 mm; Width: 3 mm; Length: 597.2 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/1066
BaseQuantities - Width: 499.069 mm; NetArea: 0.400777 m2; GrossArea: 0.298047 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000592931 m3; GrossVolume: 0.000592931 m3

# IfcPlate: PLT3*499.3 (2)
In: Undefined
Description: PLT3*499.3; Material: STEEL/450
Tekla Common - Bottom elevation: +4.613; Top elevation: +5.238; Phase: 1; Class: 11
Tekla Quantity - Weight: 4.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.3 m2; Height: 499.3 mm; Width: 3 mm; Length: 673 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 499.344 mm; NetArea: 0.424956 m2; GrossArea: 0.336083 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000626463 m3; GrossVolume: 0.000642933 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1758
HAUNCH BRACING PLATE | PL/1769

# IfcPlate: PLT3*504.3 (2)
In: Undefined
Description: PLT3*504.3; Material: STEEL/450
Tekla Common - Bottom elevation: +4.648; Top elevation: +5.288; Phase: 1; Class: 11
Tekla Quantity - Weight: 5.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.3 m2; Height: 504.3 mm; Width: 3 mm; Length: 689.3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 504.304 mm; NetArea: 0.443846 m2; GrossArea: 0.347616 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000654493 m3; GrossVolume: 0.000670963 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1760
HAUNCH BRACING PLATE | PL/1771

# IfcPlate: PLT3*506.2 (2)
In: Undefined
Description: PLT3*506.2; Material: STEEL/450
Tekla Common - Bottom elevation: +4.907; Top elevation: +5.293; Phase: 1; Class: 11
Tekla Quantity - Weight: 21.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 1.7 m2; Height: 506.2 mm; Width: 3 mm; Length: 2039.7 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 506.174 mm; NetArea: 1.84986 m2; GrossArea: 1.03245 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00274379 m3; GrossVolume: 0.00277039 m3
Name | ASSEMBLY_POS = Reference
APEX BRACING PLATE | PL/1907
APEX BRACING PLATE | PL/1918

# IfcPlate: PLT3*511.3 (2)
In: Undefined
Description: PLT3*511.3; Material: STEEL/450
Tekla Common - Bottom elevation: +4.702; Top elevation: +5.368; Phase: 1; Class: 11
Tekla Quantity - Weight: 5.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.5 m2; Height: 511.3 mm; Width: 3 mm; Length: 718.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 511.253 mm; NetArea: 0.476836 m2; GrossArea: 0.367393 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000703448 m3; GrossVolume: 0.000719918 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1762
HAUNCH BRACING PLATE | PL/1773

# IfcPlate: PLT3*511.4 (2)
In: Undefined
Description: PLT3*511.4; Material: STEEL/450
Tekla Common - Bottom elevation: +5.023; Top elevation: +5.414; Phase: 1; Class: 11
Tekla Quantity - Weight: 18.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 1.6 m2; Height: 511.4 mm; Width: 3 mm; Length: 1752.2 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 511.37 mm; NetArea: 1.58133 m2; GrossArea: 0.896048 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00234507 m3; GrossVolume: 0.00237166 m3
Name | ASSEMBLY_POS = Reference
APEX BRACING PLATE | PL/1909
APEX BRACING PLATE | PL/1920

# IfcPlate: PLT3*517.6 (2)
In: Undefined
Description: PLT3*517.6; Material: STEEL/450
Tekla Common - Bottom elevation: +4.757; Top elevation: +5.453; Phase: 1; Class: 11
Tekla Quantity - Weight: 6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.5 m2; Height: 517.6 mm; Width: 3 mm; Length: 755.7 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 517.595 mm; NetArea: 0.517068 m2; GrossArea: 0.391172 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000763153 m3; GrossVolume: 0.000779622 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1764
HAUNCH BRACING PLATE | PL/1775

# IfcPlate: PLT3*518.3 (2)
In: Undefined
Description: PLT3*518.3; Material: STEEL/450
Tekla Common - Bottom elevation: +5.199; Top elevation: +5.597; Phase: 1; Class: 11
Tekla Quantity - Weight: 15.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 1.2 m2; Height: 518.3 mm; Width: 3 mm; Length: 1468.8 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 518.296 mm; NetArea: 1.31215 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00194536 m3; GrossVolume: 0.00197195 m3
Name | ASSEMBLY_POS = Reference | GrossArea (m2)
APEX BRACING PLATE | PL/1911 | 0.76129
APEX BRACING PLATE | PL/1922 | 0.761289

# IfcPlate: PLT3*521.9 (2)
In: Undefined
Description: PLT3*521.9; Material: STEEL/450
Tekla Common - Bottom elevation: +3.811; Top elevation: +4.335; Phase: 1; Class: 11
Tekla Quantity - Weight: 5.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.3 m2; Height: 521.9 mm; Width: 3 mm; Length: 667.7 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 521.886 mm; NetArea: 0.449148 m2; GrossArea: 0.348484 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000662858 m3; GrossVolume: 0.000679328 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1779
HAUNCH BRACING PLATE | PL/1790

# IfcPlate: PLT3*524.1 (2)
In: Undefined
Description: PLT3*524.1; Material: STEEL/450
Tekla Common - Bottom elevation: +5.379; Top elevation: +5.783; Phase: 1; Class: 11
Tekla Quantity - Weight: 13.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 1.1 m2; Height: 524.1 mm; Width: 3 mm; Length: 1283.8 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 524.134 mm; NetArea: 1.13203 m2; GrossArea: 0.672892 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00167787 m3; GrossVolume: 0.00170446 m3
Name | ASSEMBLY_POS = Reference
APEX BRACING PLATE | PL/1913
APEX BRACING PLATE | PL/1924

# IfcPlate: PLT3*530 (2)
In: Undefined
Description: PLT3*530; Material: STEEL/450
Tekla Common - Bottom elevation: +4.889; Top elevation: +5.692; Phase: 1; Class: 11
Tekla Quantity - Weight: 7.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.1 m2; Net surface area: 0.6 m2; Height: 530 mm; Width: 3 mm; Length: 893.9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 529.964 mm; NetArea: 0.657645 m2; GrossArea: 0.473718 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000971788 m3; GrossVolume: 0.000988257 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1766
HAUNCH BRACING PLATE | PL/1777

# IfcPlate: PLT3*533.5 (2)
In: Undefined
Description: PLT3*533.5; Material: STEEL/450
Tekla Common - Bottom elevation: +5.822; Top elevation: +6.235; Phase: 1; Class: 11
Tekla Quantity - Weight: 10.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.8 m2; Height: 533.5 mm; Width: 3 mm; Length: 1034.9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 533.464 mm; GrossArea: 0.5521 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00130055 m3; GrossVolume: 0.00132714 m3
Name | ASSEMBLY_POS = Reference | NetArea (m2)
APEX BRACING PLATE | PL/1915 | 0.877993
APEX BRACING PLATE | PL/1926 | 0.877992

# IfcPlate: PLT3*535.2 (2)
In: Undefined
Description: PLT3*535.2; Material: STEEL/450
Tekla Common - Bottom elevation: +4.937; Top elevation: +5.323; Phase: 1; Class: 11
Tekla Quantity - Weight: 27.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 2.5 m2; Height: 535.2 mm; Width: 3 mm; Length: 2323.3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 535.164 mm; NetArea: 2.36368 m2; GrossArea: 1.24335 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00351011 m3; GrossVolume: 0.0035367 m3
Name | ASSEMBLY_POS = Reference
APEX BRACING PLATE | PL/1929
APEX BRACING PLATE | PL/1940

# IfcPlate: PLT3*540.4 (2)
In: Undefined
Description: PLT3*540.4; Material: STEEL/450
Tekla Common - Bottom elevation: +5.039; Top elevation: +5.430; Phase: 1; Class: 11
Tekla Quantity - Weight: 23.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 2 m2; Height: 540.4 mm; Width: 3 mm; Length: 1987.5 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 540.374 mm; NetArea: 2.01415 m2; GrossArea: 1.07398 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00299056 m3; GrossVolume: 0.00301715 m3
Name | ASSEMBLY_POS = Reference
APEX BRACING PLATE | PL/1931
APEX BRACING PLATE | PL/1942

# IfcPlate: PLT3*544.9 (4)
In: Undefined
Description: PLT3*544.9; Material: STEEL/450
Default - ASSEMBLY_POS: Z/2454
Tekla Common - Bottom elevation: +5.345; Top elevation: +5.732; Phase: 1; Class: 1
Tekla Quantity - Weight: 9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.8 m2; Height: 544.9 mm; Width: 3 mm; Length: 943.7 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/2454
BaseQuantities - Width: 544.889 mm; NetArea: 0.784315 m2; GrossArea: 0.514235 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.0011642 m3; GrossVolume: 0.0011642 m3

# IfcPlate: PLT3*547.3 (2)
In: Undefined
Description: PLT3*547.3; Material: STEEL/450
Tekla Common - Bottom elevation: +5.232; Top elevation: +5.630; Phase: 1; Class: 11
Tekla Quantity - Weight: 19.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 1.7 m2; Height: 547.3 mm; Width: 3 mm; Length: 1655.4 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 547.29 mm; NetArea: 1.66361 m2; GrossArea: 0.906006 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00246949 m3; GrossVolume: 0.00249608 m3
Name | ASSEMBLY_POS = Reference
APEX BRACING PLATE | PL/1933
APEX BRACING PLATE | PL/1944

# IfcPlate: PLT3*550.3 (2)
In: Undefined
Description: PLT3*550.3; Material: STEEL/450
Tekla Common - Bottom elevation: +4.569; Top elevation: +5.246; Phase: 1; Class: 11
Tekla Quantity - Weight: 6.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.1 m2; Net surface area: 0.5 m2; Height: 550.3 mm; Width: 3 mm; Length: 745.9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 550.346 mm; NetArea: 0.541728 m2; GrossArea: 0.410487 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000800307 m3; GrossVolume: 0.000816777 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1780
HAUNCH BRACING PLATE | PL/1791

# IfcPlate: PLT3*553.1 (2)
In: Undefined
Description: PLT3*553.1; Material: STEEL/450
Tekla Common - Bottom elevation: +5.430; Top elevation: +5.834; Phase: 1; Class: 11
Tekla Quantity - Weight: 16.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 1.4 m2; Height: 553.1 mm; Width: 3 mm; Length: 1437.7 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 553.135 mm; NetArea: 1.42893 m2; GrossArea: 0.795245 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00212062 m3; GrossVolume: 0.00214721 m3
Name | ASSEMBLY_POS = Reference
APEX BRACING PLATE | PL/1935
APEX BRACING PLATE | PL/1946

# IfcPlate: PLT3*554.4 (2)
In: Undefined
Description: PLT3*554.4; Material: STEEL/450
Tekla Common - Bottom elevation: +3.834; Top elevation: +4.358; Phase: 1; Class: 11
Tekla Quantity - Weight: 5.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.5 m2; Height: 554.4 mm; Width: 3 mm; Length: 700.3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 554.42 mm; GrossArea: 0.388243 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000712439 m3; GrossVolume: 0.000728909 m3
Name | ASSEMBLY_POS = Reference | NetArea (m2)
HAUNCH BRACING PLATE | PL/1801 | 0.482479
HAUNCH BRACING PLATE | PL/1872 | 0.482478

# IfcPlate: PLT3*555.3 (2)
In: Undefined
Description: PLT3*555.3; Material: STEEL/450
Tekla Common - Bottom elevation: +4.603; Top elevation: +5.299; Phase: 1; Class: 11
Tekla Quantity - Weight: 6.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.1 m2; Net surface area: 0.6 m2; Height: 555.3 mm; Width: 3 mm; Length: 767.8 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 555.3 mm; NetArea: 0.566806 m2; GrossArea: 0.426378 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000837544 m3; GrossVolume: 0.000854014 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1782
HAUNCH BRACING PLATE | PL/1793

# IfcPlate: PLT3*562.3 (2)
In: Undefined
Description: PLT3*562.3; Material: STEEL/450
Tekla Common - Bottom elevation: +4.654; Top elevation: +5.383; Phase: 1; Class: 11
Tekla Quantity - Weight: 7.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.1 m2; Net surface area: 0.6 m2; Height: 562.3 mm; Width: 3 mm; Length: 806.9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 562.254 mm; NetArea: 0.61055 m2; GrossArea: 0.453702 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.0009025 m3; GrossVolume: 0.00091897 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1784
HAUNCH BRACING PLATE | PL/1795

# IfcPlate: PLT3*562.5 (2)
In: Undefined
Description: PLT3*562.5; Material: STEEL/450
Tekla Common - Bottom elevation: +5.917; Top elevation: +6.330; Phase: 1; Class: 11
Tekla Quantity - Weight: 12.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 1.1 m2; Height: 562.5 mm; Width: 3 mm; Length: 1142.2 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 562.459 mm; NetArea: 1.09752 m2; GrossArea: 0.642413 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.0016279 m3; GrossVolume: 0.0016545 m3
Name | ASSEMBLY_POS = Reference
APEX BRACING PLATE | PL/1937
APEX BRACING PLATE | PL/1948

# IfcPlate: PLT3*565.6 (8)
In: Undefined
Description: PLT3*565.6; Material: STEEL/450
Tekla Common - Bottom elevation: +4.577; Top elevation: +5.153; Phase: 1; Class: 1
Tekla Quantity - Weight: 8.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.8 m2; Height: 565.6 mm; Width: 3 mm; Length: 853.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - NetArea: 0.754232 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00111964 m3; GrossVolume: 0.00111964 m3
Name | ASSEMBLY_POS = Reference | Width (mm) | GrossArea (m2)
4 x PLATE | Z/1543 | 565.634 | 0.482802
4 x PLATE | Z/1542 | 565.637 | 0.482806

# IfcPlate: PLT3*568.6 (2)
In: Undefined
Description: PLT3*568.6; Material: STEEL/450
Tekla Common - Bottom elevation: +4.707; Top elevation: +5.474; Phase: 1; Class: 11
Tekla Quantity - Weight: 7.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.1 m2; Net surface area: 0.6 m2; Height: 568.6 mm; Width: 3 mm; Length: 855.8 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 568.6 mm; NetArea: 0.663866 m2; GrossArea: 0.486633 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000981674 m3; GrossVolume: 0.000998143 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1786
HAUNCH BRACING PLATE | PL/1797

# IfcPlate: PLT3*571.6 (4)
In: Undefined
Description: PLT3*571.6; Material: STEEL/450
Default - ASSEMBLY_POS: Z/957
Tekla Common - Bottom elevation: +5.479; Top elevation: +5.882; Phase: 1; Class: 1
Tekla Quantity - Weight: 9.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.8 m2; Height: 571.6 mm; Width: 3 mm; Length: 955.4 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/957
BaseQuantities - Width: 571.641 mm; NetArea: 0.801356 m2; GrossArea: 0.54616 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00118969 m3; GrossVolume: 0.00118969 m3

# IfcPlate: PLT3*576 (4)
In: Undefined
Description: PLT3*576; Material: STEEL/450
Default - ASSEMBLY_POS: Z/1092
Tekla Common - Bottom elevation: +4.577; Top elevation: +5.192; Phase: 1; Class: 1
Tekla Quantity - Weight: 9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.8 m2; Height: 576 mm; Width: 3 mm; Length: 879 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/1092
BaseQuantities - Width: 576.032 mm; NetArea: 0.778939 m2; GrossArea: 0.506333 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00115652 m3; GrossVolume: 0.00115652 m3

# IfcPlate: PLT3*576.1 (4)
In: Undefined
Description: PLT3*576.1; Material: STEEL/450
Tekla Common - Bottom elevation: +4.577; Top elevation: +5.192; Phase: 1; Class: 1
Default - ASSEMBLY_POS: Z/1093
Tekla Quantity - Weight: 9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.8 m2; Height: 576.1 mm; Width: 3 mm; Length: 879 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/1093
BaseQuantities - Width: 576.057 mm; NetArea: 0.77894 m2; GrossArea: 0.506359 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00115653 m3; GrossVolume: 0.00115653 m3

# IfcPlate: PLT3*581 (2)
In: Undefined
Description: PLT3*581; Material: STEEL/450
Tekla Common - Bottom elevation: +4.833; Top elevation: +5.735; Phase: 1; Class: 11
Tekla Quantity - Weight: 9.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.1 m2; Net surface area: 0.8 m2; Height: 581 mm; Width: 3 mm; Length: 1034 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 580.958 mm; NetArea: 0.849569 m2; GrossArea: 0.600698 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00125746 m3; GrossVolume: 0.00127393 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1788
HAUNCH BRACING PLATE | PL/1799

# IfcPlate: PLT3*585.2 (8)
In: Undefined
Description: PLT3*585.2; Material: STEEL/450
Tekla Common - Bottom elevation: +4.577; Top elevation: +5.231; Phase: 1; Class: 1
Tekla Quantity - Weight: 9.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.8 m2; Height: 585.2 mm; Length: 904.9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Tekla Quantity, Width (mm) | BaseQuantities, Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
4 x PLATE | Z/1090 | 3 | 585.177 | 0.803909 | 0.529521 | 0.00119378
4 x PLATE | Z/1091 | 3.1 | 585.228 | 0.803911 | 0.529577 | 0.00119381

# IfcPlate: PLT3*588 (2)
In: Undefined
Description: PLT3*588; Material: STEEL/450
Tekla Common - Bottom elevation: +4.518; Top elevation: +5.240; Phase: 1; Class: 11
Tekla Quantity - Weight: 6.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.1 m2; Net surface area: 0.6 m2; Height: 588 mm; Width: 3 mm; Length: 772.3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 588.019 mm; NetArea: 0.58274 m2; GrossArea: 0.454102 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000861411 m3; GrossVolume: 0.000877881 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1802
HAUNCH BRACING PLATE | PL/1873

# IfcPlate: PLT3*593.9 (2)
In: Undefined
Description: PLT3*593.9; Material: STEEL/450
Tekla Common - Bottom elevation: +4.550; Top elevation: +5.291; Phase: 1; Class: 11
Tekla Quantity - Weight: 7.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.1 m2; Net surface area: 0.6 m2; Height: 593.9 mm; Width: 3 mm; Length: 792.9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 593.875 mm; NetArea: 0.609983 m2; GrossArea: 0.470875 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000901895 m3; GrossVolume: 0.000918365 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1804
HAUNCH BRACING PLATE | PL/1875

# IfcPlate: PLT3*601.4 (4)
In: Undefined
Description: PLT3*601.4; Material: STEEL/450
Default - ASSEMBLY_POS: Z/1088
Tekla Common - Bottom elevation: +4.578; Top elevation: +5.322; Phase: 1; Class: 1
Tekla Quantity - Weight: 10.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.8 m2; Height: 601.4 mm; Width: 3.1 mm; Length: 967.3 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/1088
BaseQuantities - Width: 601.441 mm; NetArea: 0.863374 m2; GrossArea: 0.581793 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.0012825 m3; GrossVolume: 0.0012825 m3

# IfcPlate: PLT3*601.6 (4)
In: Undefined
Description: PLT3*601.6; Material: STEEL/450
Tekla Common - Bottom elevation: +4.578; Top elevation: +5.322; Phase: 1; Class: 1
Default - ASSEMBLY_POS: Z/1089
Tekla Quantity - Weight: 10.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.8 m2; Height: 601.6 mm; Width: 3.1 mm; Length: 967.4 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/1089
BaseQuantities - Width: 601.577 mm; NetArea: 0.863379 m2; GrossArea: 0.58195 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00128254 m3; GrossVolume: 0.00128254 m3

# IfcPlate: PLT3*602.1 (2)
In: Undefined
Description: PLT3*602.1; Material: STEEL/450
Tekla Common - Bottom elevation: +4.600; Top elevation: +5.372; Phase: 1; Class: 11
Tekla Quantity - Weight: 7.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.1 m2; Net surface area: 0.6 m2; Height: 602.1 mm; Width: 3 mm; Length: 829.9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 602.088 mm; NetArea: 0.65756 m2; GrossArea: 0.499695 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000972601 m3; GrossVolume: 0.000989071 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1866
HAUNCH BRACING PLATE | PL/1877

# IfcPlate: PLT3*606.1 (8)
In: Undefined
Description: PLT3*606.1; Material: STEEL/450
Tekla Common - Bottom elevation: +4.577; Top elevation: +5.164; Phase: 1; Class: 1
Tekla Quantity - Weight: 10.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Height: 606.1 mm; Width: 3 mm; Length: 905.1 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - NetArea: 0.865061 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00128499 m3; GrossVolume: 0.00128499 m3
Name | ASSEMBLY_POS = Reference | Net surface area (m2) | Width (mm) | GrossArea (m2)
PLATE | Z/1432 | 1 | 606.062 | 0.548534
PLATE | Z/666 | 1 | 606.065 | 0.548538
3 x PLATE | Z/1432 | 0.8 | 606.062 | 0.548534
3 x PLATE | Z/666 | 0.8 | 606.065 | 0.548538

# IfcPlate: PLT3*609.6 (2)
In: Undefined
Description: PLT3*609.6; Material: STEEL/450
Tekla Common - Bottom elevation: +4.649; Top elevation: +5.460; Phase: 1; Class: 11
Tekla Quantity - Weight: 8.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.1 m2; Net surface area: 0.6 m2; Height: 609.6 mm; Width: 3 mm; Length: 876.7 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 609.58 mm; NetArea: 0.715612 m2; GrossArea: 0.534438 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00105888 m3; GrossVolume: 0.00107535 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1868
HAUNCH BRACING PLATE | PL/1879

# IfcPlate: PLT3*609.8 (8)
In: Undefined
Description: PLT3*609.8; Material: STEEL/450
Tekla Common - Bottom elevation: +4.577; Top elevation: +5.128; Phase: 1; Class: 1
Tekla Quantity - Weight: 8.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.6 m2; Height: 609.9 mm; Width: 3 mm; Length: 897 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 609.776 mm; GrossArea: 0.546967 m2; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | NetArea (m2) | NetVolume (m3) = GrossVolume (m3)
2 x PLATE | Z/2455 | 0.739981 | 0.00109836
2 x PLATE | Z/2456 | 0.739984 | 0.00109837
PLATE | Z/2456 | 0.739982 | 0.00109836
2 x PLATE | Z/2455 | 0.739983 | 0.00109837
PLATE | Z/2456 | 0.739982 | 0.00109837

# IfcPlate: PLT3*609.9 (4)
In: Undefined
Description: PLT3*609.9; Material: STEEL/450
Default - ASSEMBLY_POS: Z/1094
Tekla Common - Bottom elevation: +5.683; Top elevation: +6.112; Phase: 1; Class: 1
Tekla Quantity - Weight: 9.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.8 m2; Height: 609.9 mm; Width: 3 mm; Length: 968.2 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/1094
BaseQuantities - Width: 609.9 mm; NetArea: 0.826034 m2; GrossArea: 0.590519 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00122661 m3; GrossVolume: 0.00122661 m3

# IfcPlate: PLT3*618.8 (8)
In: Undefined
Description: PLT3*618.8; Material: STEEL/450
Tekla Common - Bottom elevation: +4.577; Top elevation: +5.205; Phase: 1; Class: 1
Tekla Quantity - Weight: 10.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.7 m2; Height: 618.8 mm; Width: 3 mm; Length: 932.1 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Net surface area (m2) | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
PLATE | Z/1119 | 1 | 618.779 | 0.896833 | 0.576777 | 0.00133246
PLATE | Z/1120 | 1 | 618.804 | 0.896834 | 0.576804 | 0.00133245
3 x PLATE | Z/1119 | 0.8 | 618.779 | 0.896833 | 0.576777 | 0.00133246
3 x PLATE | Z/1120 | 0.8 | 618.804 | 0.896834 | 0.576804 | 0.00133245

# IfcPlate: PLT3*623.4 (4)
In: Undefined
Description: PLT3*623.4; Material: STEEL/450
Default - ASSEMBLY_POS: Z/2494
Tekla Common - Bottom elevation: +5.299; Top elevation: +5.736; Phase: 1; Class: 1
Tekla Quantity - Weight: 10.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.7 m2; Net surface area: 0.8 m2; Height: 623.4 mm; Width: 3 mm; Length: 965.9 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/2494
BaseQuantities - Width: 623.448 mm; NetArea: 0.929783 m2; GrossArea: 0.602188 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00138161 m3; GrossVolume: 0.00138161 m3

# IfcPlate: PLT3*624.2 (2)
In: Undefined
Description: PLT3*624.2; Material: STEEL/450
Tekla Common - Bottom elevation: +4.769; Top elevation: +5.713; Phase: 1; Class: 11
Tekla Quantity - Weight: 10.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.8 m2; Height: 624.2 mm; Width: 3 mm; Length: 1049.7 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 624.189 mm; NetArea: 0.918173 m2; GrossArea: 0.655218 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00135995 m3; GrossVolume: 0.00137642 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1870
HAUNCH BRACING PLATE | PL/1881

# IfcPlate: PLT3*630.2 (4)
In: Undefined
Description: PLT3*630.2; Material: STEEL/450
Default - ASSEMBLY_POS: Z/1117
Tekla Common - Bottom elevation: +4.577; Top elevation: +5.247; Phase: 1; Class: 1
Tekla Quantity - Weight: 10.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.7 m2; Height: 630.2 mm; Width: 3.1 mm; Length: 959.6 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/1117
BaseQuantities - Width: 630.227 mm; NetArea: 0.929235 m2; GrossArea: 0.604746 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00138086 m3; GrossVolume: 0.00138086 m3
Name | Net surface area (m2)
PLATE | 1
3 x PLATE | 0.8

# IfcPlate: PLT3*630.3 (4)
In: Undefined
Description: PLT3*630.3; Material: STEEL/450
Tekla Common - Bottom elevation: +4.577; Top elevation: +5.247; Phase: 1; Class: 1
Default - ASSEMBLY_POS: Z/1118
Tekla Quantity - Weight: 10.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.7 m2; Height: 630.3 mm; Width: 3 mm; Length: 959.6 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/1118
BaseQuantities - Width: 630.281 mm; NetArea: 0.929236 m2; GrossArea: 0.604807 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00138084 m3; GrossVolume: 0.00138084 m3
Name | Net surface area (m2)
PLATE | 1
3 x PLATE | 0.8

# IfcPlate: PLT3*635.4 (2)
In: Undefined
Description: PLT3*635.4; Material: STEEL/450
Tekla Common - Bottom elevation: +3.801; Top elevation: +4.391; Phase: 1; Class: 11
Tekla Quantity - Weight: 6.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.1 m2; Net surface area: 0.6 m2; Height: 635.4 mm; Width: 3 mm; Length: 746.3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 635.425 mm; NetArea: 0.607005 m2; GrossArea: 0.474195 m2; CrossSectionArea: 0.000009 m2; GrossVolume: 0.000924623 m3
Name | ASSEMBLY_POS = Reference | NetVolume (m3)
HAUNCH BRACING PLATE | PL/1883 | 0.000898023
HAUNCH BRACING PLATE | PL/1894 | 0.000898022

# IfcPlate: PLT3*645.5 (4)
In: Undefined
Description: PLT3*645.5; Material: STEEL/450
Default - ASSEMBLY_POS: Z/1095
Tekla Common - Bottom elevation: +5.893; Top elevation: +6.348; Phase: 1; Class: 1
Tekla Quantity - Weight: 9.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.8 m2; Height: 645.5 mm; Width: 3 mm; Length: 975.3 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/1095
BaseQuantities - Width: 645.542 mm; NetArea: 0.849539 m2; GrossArea: 0.629592 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00126179 m3; GrossVolume: 0.00126179 m3

# IfcPlate: PLT3*650 (4)
In: Undefined
Description: PLT3*650; Material: STEEL/450
Default - ASSEMBLY_POS: Z/667
Tekla Common - Bottom elevation: +5.433; Top elevation: +5.887; Phase: 1; Class: 1
Tekla Quantity - Weight: 11.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.7 m2; Height: 650 mm; Width: 3 mm; Length: 981.8 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/667
BaseQuantities - Width: 650 mm; NetArea: 0.948818 m2; GrossArea: 0.638154 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00141008 m3; GrossVolume: 0.00141008 m3
Name | Net surface area (m2)
PLATE | 1
3 x PLATE | 0.8

# IfcPlate: PLT3*651.2 (8)
In: Undefined
Description: PLT3*651.2; Material: STEEL/450
Tekla Common - Bottom elevation: +4.577; Top elevation: +5.137; Phase: 1; Class: 1
Tekla Quantity - Weight: 9.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.8 m2; Height: 651.2 mm; Width: 3 mm; Length: 932.8 mm
Pset_PlateCommon - LoadBearing: no
