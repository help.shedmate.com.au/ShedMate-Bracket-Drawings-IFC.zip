Properties of the parts of a building model (IFC2X3), part 4 of 4

# IfcPlate: PLT3*651.2 (8)
BaseQuantities - Width: 651.229 mm; GrossArea: 0.607454 m2; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | NetArea (m2) | NetVolume (m3) = GrossVolume (m3)
2 x PLATE | Z/2496 | 0.846959 | 0.00125795
2 x PLATE | Z/2495 | 0.846955 | 0.00125793
2 x PLATE | Z/2495 | 0.846958 | 0.00125794
2 x PLATE | Z/2496 | 0.846956 | 0.00125794

# IfcPlate: PLT3*651.8 (4)
In: Undefined
Description: PLT3*651.8; Material: STEEL/450
Default - ASSEMBLY_POS: Z/1115
Tekla Common - Bottom elevation: +4.577; Top elevation: +5.345; Phase: 1; Class: 1
Tekla Quantity - Weight: 11.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.7 m2; Net surface area: 1 m2; Height: 651.8 mm; Width: 3.1 mm; Length: 1025.7 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/1115
BaseQuantities - Width: 651.804 mm; NetArea: 1.00762 m2; GrossArea: 0.668586 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00149792 m3; GrossVolume: 0.00149792 m3

# IfcPlate: PLT3*652 (4)
In: Undefined
Description: PLT3*652; Material: STEEL/450
Tekla Common - Bottom elevation: +4.577; Top elevation: +5.345; Phase: 1; Class: 1
Default - ASSEMBLY_POS: Z/1116
Tekla Quantity - Weight: 11.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.7 m2; Net surface area: 1 m2; Height: 652 mm; Width: 3.1 mm; Length: 1025.7 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/1116
BaseQuantities - Width: 651.954 mm; NetArea: 1.00763 m2; GrossArea: 0.668766 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.0014979 m3; GrossVolume: 0.0014979 m3

# IfcPlate: PLT3*669 (2)
In: Undefined
Description: PLT3*669; Material: STEEL/450
Tekla Common - Bottom elevation: +4.478; Top elevation: +5.246; Phase: 1; Class: 11
Tekla Quantity - Weight: 8.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.6 m2; Height: 669 mm; Width: 3 mm; Length: 838 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 669.019 mm; NetArea: 0.740075 m2; GrossArea: 0.560608 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00109596 m3; GrossVolume: 0.00112255 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1884
HAUNCH BRACING PLATE | PL/1895

# IfcPlate: PLT3*670.8 (2)
In: Undefined
Description: PLT3*670.8; Material: STEEL/450
Tekla Common - Bottom elevation: +3.826; Top elevation: +4.416; Phase: 1; Class: 11
Tekla Quantity - Weight: 7.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.1 m2; Net surface area: 0.6 m2; Height: 670.8 mm; Width: 3 mm; Length: 781.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 670.781 mm; NetArea: 0.649719 m2; GrossArea: 0.524287 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000961643 m3; GrossVolume: 0.000988245 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1905
HAUNCH BRACING PLATE | PL/1916

# IfcPlate: PLT3*674.9 (2)
In: Undefined
Description: PLT3*674.9; Material: STEEL/450
Tekla Common - Bottom elevation: +4.509; Top elevation: +5.300; Phase: 1; Class: 11
Tekla Quantity - Weight: 9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.8 m2; Height: 674.9 mm; Width: 3 mm; Length: 863.7 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 674.879 mm; NetArea: 0.776067 m2; GrossArea: 0.582903 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00114952 m3; GrossVolume: 0.00117611 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1886
HAUNCH BRACING PLATE | PL/1897

# IfcPlate: PLT3*683.1 (2)
In: Undefined
Description: PLT3*683.1; Material: STEEL/450
Tekla Common - Bottom elevation: +4.556; Top elevation: +5.385; Phase: 1; Class: 11
Tekla Quantity - Weight: 9.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.8 m2; Height: 683.1 mm; Width: 3 mm; Length: 909.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 683.088 mm; NetArea: 0.838837 m2; GrossArea: 0.621349 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.0012429 m3; GrossVolume: 0.00126949 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1888
HAUNCH BRACING PLATE | PL/1899

# IfcPlate: PLT3*687.9 (4)
In: Undefined
Description: PLT3*687.9; Material: STEEL/450
Default - ASSEMBLY_POS: Z/1121
Tekla Common - Bottom elevation: +5.638; Top elevation: +6.119; Phase: 1; Class: 1
Tekla Quantity - Weight: 11.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.7 m2; Net surface area: 1 m2; Height: 687.9 mm; Width: 3 mm; Length: 1000.7 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/1121
BaseQuantities - Width: 687.908 mm; NetArea: 0.97651 m2; GrossArea: 0.688403 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.0014515 m3; GrossVolume: 0.0014515 m3

# IfcPlate: PLT3*690.6 (2)
In: Undefined
Description: PLT3*690.6; Material: STEEL/450
Tekla Common - Bottom elevation: +4.604; Top elevation: +5.479; Phase: 1; Class: 11
Tekla Quantity - Weight: 10.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.8 m2; Height: 690.6 mm; Width: 3 mm; Length: 967 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 690.58 mm; NetArea: 0.915263 m2; GrossArea: 0.667789 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.0013566 m3; GrossVolume: 0.00138319 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1890
HAUNCH BRACING PLATE | PL/1901

# IfcPlate: PLT3*705.2 (2)
In: Undefined
Description: PLT3*705.2; Material: STEEL/450
Tekla Common - Bottom elevation: +4.718; Top elevation: +5.753; Phase: 1; Class: 11
Tekla Quantity - Weight: 13.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 1.2 m2; Height: 705.2 mm; Width: 3 mm; Length: 1180.2 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 705.19 mm; NetArea: 1.18402 m2; GrossArea: 0.832275 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00175643 m3; GrossVolume: 0.00178302 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1892
HAUNCH BRACING PLATE | PL/1903

# IfcPlate: PLT3*710 (2)
In: Undefined
Description: PLT3*710; Material: STEEL/450
Tekla Common - Bottom elevation: +4.422; Top elevation: +5.239; Phase: 1; Class: 11
Tekla Quantity - Weight: 9.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.8 m2; Height: 710 mm; Width: 3 mm; Length: 866.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 709.985 mm; NetArea: 0.792692 m2; GrossArea: 0.615304 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00117444 m3; GrossVolume: 0.00120103 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1906
HAUNCH BRACING PLATE | PL/1917

# IfcPlate: PLT3*716.4 (4)
In: Undefined
Description: PLT3*716.4; Material: STEEL/450
Default - ASSEMBLY_POS: Z/1096
Tekla Common - Bottom elevation: +6.416; Top elevation: +6.935; Phase: 1; Class: 1
Tekla Quantity - Weight: 10.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.7 m2; Net surface area: 0.8 m2; Height: 716.4 mm; Width: 3 mm; Length: 969.5 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/1096
BaseQuantities - Width: 716.41 mm; NetArea: 0.899521 m2; GrossArea: 0.694526 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00133658 m3; GrossVolume: 0.00133658 m3

# IfcPlate: PLT3*716.8 (2)
In: Undefined
Description: PLT3*716.8; Material: STEEL/450
Tekla Common - Bottom elevation: +4.494; Top elevation: +5.334; Phase: 1; Class: 11
Tekla Quantity - Weight: 9.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.8 m2; Height: 716.8 mm; Width: 3 mm; Length: 890.9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 716.811 mm; NetArea: 0.831438 m2; GrossArea: 0.638637 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00123211 m3; GrossVolume: 0.0012587 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1908
HAUNCH BRACING PLATE | PL/1919

# IfcPlate: PLT3*723.1 (4)
In: Undefined
Description: PLT3*723.1; Material: STEEL/450
Default - ASSEMBLY_POS: Z/1122
Tekla Common - Bottom elevation: +5.849; Top elevation: +6.357; Phase: 1; Class: 1
Tekla Quantity - Weight: 11.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.7 m2; Net surface area: 1 m2; Height: 723.1 mm; Width: 3 mm; Length: 1013.6 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/1122
BaseQuantities - Width: 723.131 mm; NetArea: 1.00302 m2; GrossArea: 0.732998 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00149115 m3; GrossVolume: 0.00149115 m3

# IfcPlate: PLT3*726.4 (2)
In: Undefined
Description: PLT3*726.4; Material: STEEL/450
Tekla Common - Bottom elevation: +4.523; Top elevation: +5.400; Phase: 1; Class: 11
Tekla Quantity - Weight: 10.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.8 m2; Height: 726.4 mm; Width: 3 mm; Length: 934.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 726.391 mm; NetArea: 0.899139 m2; GrossArea: 0.678899 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00133289 m3; GrossVolume: 0.00135948 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1910
HAUNCH BRACING PLATE | PL/1921

# IfcPlate: PLT3*735.1 (2)
In: Undefined
Description: PLT3*735.1; Material: STEEL/450
Tekla Common - Bottom elevation: +4.606; Top elevation: +5.529; Phase: 1; Class: 11
Tekla Quantity - Weight: 11.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 1 m2; Height: 735.1 mm; Width: 3 mm; Length: 989.7 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 735.134 mm; NetArea: 0.981667 m2; GrossArea: 0.727572 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00145574 m3; GrossVolume: 0.00148233 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1912
HAUNCH BRACING PLATE | PL/1923

# IfcPlate: PLT3*749.8 (2)
In: Undefined
Description: PLT3*749.8; Material: STEEL/450
Tekla Common - Bottom elevation: +3.684; Top elevation: +4.344; Phase: 1; Class: 11
Tekla Quantity - Weight: 9.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.8 m2; Height: 749.8 mm; Width: 3 mm; Length: 831.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 749.782 mm; NetArea: 0.802052 m2; GrossArea: 0.623541 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00118887 m3; GrossVolume: 0.00121547 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1927
HAUNCH BRACING PLATE | PL/1938

# IfcPlate: PLT3*752.2 (2)
In: Undefined
Description: PLT3*752.2; Material: STEEL/450
Tekla Common - Bottom elevation: +4.742; Top elevation: +5.820; Phase: 1; Class: 11
Tekla Quantity - Weight: 14.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 1.2 m2; Height: 752.2 mm; Width: 3 mm; Length: 1193.2 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 752.17 mm; NetArea: 1.26939 m2; GrossArea: 0.897493 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00188407 m3; GrossVolume: 0.00191067 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1914
HAUNCH BRACING PLATE | PL/1925

# IfcPlate: PLT3*789 (2)
In: Undefined
Description: PLT3*789; Material: STEEL/450
Tekla Common - Bottom elevation: +4.402; Top elevation: +5.270; Phase: 1; Class: 11
Tekla Quantity - Weight: 11.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 1 m2; Height: 789 mm; Width: 3 mm; Length: 938.1 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 788.984 mm; NetArea: 0.985125 m2; GrossArea: 0.740107 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00146154 m3; GrossVolume: 0.00148813 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1928
HAUNCH BRACING PLATE | PL/1939

# IfcPlate: PLT3*792.7 (4)
In: Undefined
Description: PLT3*792.7; Material: STEEL/450
Default - ASSEMBLY_POS: Z/1123
Tekla Common - Bottom elevation: +6.373; Top elevation: +6.947; Phase: 1; Class: 1
Tekla Quantity - Weight: 12.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.7 m2; Net surface area: 1.1 m2; Height: 792.7 mm; Width: 3 mm; Length: 1020 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/1123
BaseQuantities - Width: 792.682 mm; NetArea: 1.06002 m2; GrossArea: 0.808545 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.0015764 m3; GrossVolume: 0.0015764 m3

# IfcPlate: PLT3*795.8 (2)
In: Undefined
Description: PLT3*795.8; Material: STEEL/450
Tekla Common - Bottom elevation: +4.435; Top elevation: +5.329; Phase: 1; Class: 11
Tekla Quantity - Weight: 12.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 1 m2; Height: 795.8 mm; Width: 3 mm; Length: 967.9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 795.815 mm; NetArea: 1.03459 m2; GrossArea: 0.770294 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00153522 m3; GrossVolume: 0.00156181 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1930
HAUNCH BRACING PLATE | PL/1941

# IfcPlate: PLT3*805.4 (2)
In: Undefined
Description: PLT3*805.4; Material: STEEL/450
Tekla Common - Bottom elevation: +4.484; Top elevation: +5.423; Phase: 1; Class: 11
Tekla Quantity - Weight: 13.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 1.1 m2; Height: 805.4 mm; Width: 3 mm; Length: 1021.2 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 805.385 mm; NetArea: 1.12087 m2; GrossArea: 0.822468 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00166373 m3; GrossVolume: 0.00169033 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1932
HAUNCH BRACING PLATE | PL/1943

# IfcPlate: PLT3*814.1 (2)
In: Undefined
Description: PLT3*814.1; Material: STEEL/450
Tekla Common - Bottom elevation: +4.534; Top elevation: +5.526; Phase: 1; Class: 11
Tekla Quantity - Weight: 14.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 1.2 m2; Height: 814.1 mm; Width: 3 mm; Length: 1087.8 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 814.128 mm; NetArea: 1.22594 m2; GrossArea: 0.885644 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00182024 m3; GrossVolume: 0.00184684 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1934
HAUNCH BRACING PLATE | PL/1945

# IfcPlate: PLT3*831.2 (2)
In: Undefined
Description: PLT3*831.2; Material: STEEL/450
Tekla Common - Bottom elevation: +4.724; Top elevation: +5.899; Phase: 1; Class: 11
Tekla Quantity - Weight: 18.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.7 m2; Net surface area: 1.6 m2; Height: 831.2 mm; Width: 3 mm; Length: 1330.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 831.166 mm; NetArea: 1.59149 m2; GrossArea: 1.10592 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00236479 m3; GrossVolume: 0.00239139 m3
Name | ASSEMBLY_POS = Reference
HAUNCH BRACING PLATE | PL/1936
HAUNCH BRACING PLATE | PL/1947
