Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView_V2.0, QuantityTakeOffAddOnView], Option [BaseQuantities:On], Option [GridExport:On], Option [Assemblies:On], Option [Bolts:On], Option [Rebars:On], Option [PourObjects:Off], Option [Welds:Off], Option [SurfaceTreatments:Off], Option [LocationBy:0], Option [ViewColors:Off], Option [SectionedSpine:Off], Option [PropertySets:On], Option [Export all:Off]
File name: Single C-Section Column Baseplate.ifc
Time: 2026-03-26T06:52:12
Author: DESKTOP-BKNQL56\admin
Organization: Structural Designer
Written by: IFC Database Version: Work
Made in: Tekla Structures 2019 Service Pack 13, IFC Export Version: 4.0.0.0 Oct 18 2021

# IfcBuildingStorey, Undefined
In: Undefined
Elevation: 0 mm

# IfcBeam: FL6*100, BASEPLATE
In: Undefined
Description: FL6*100; Material: STEEL/450
Default - ASSEMBLY_POS: PL/27
Tekla Common - Finish: GALVANIZE; Bottom elevation: +0.006; Top elevation: +0.166; Phase: 1; Class: 5
Tekla Quantity - Weight: 3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 45.5 m2; Net surface area: 0.1 m2; Height: 100 mm; Width: 6 mm; Length: 637.7 mm
Pset_BeamCommon - LoadBearing: no; Reference: PL/27
BaseQuantities - Length: 637.708 mm; OuterSurfaceArea: 0.138321 m2; NetVolume: 0.0003876 m3; NetWeight: 3.04266 kg

# IfcBeam: PLT6*125, BASEPLATE
In: Undefined
Description: PLT6*125; Material: STEEL/450
Default - ASSEMBLY_POS: PL/26
Tekla Common - Finish: GALVANIZE; Bottom elevation: -0.000; Top elevation: +0.166; Phase: 1; Class: 5
Tekla Quantity - Weight: 4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 44.9 m2; Net surface area: 0.2 m2; Height: 125 mm; Width: 6 mm; Length: 671.7 mm
Pset_BeamCommon - LoadBearing: no; Reference: PL/26
BaseQuantities - Length: 671.708 mm; OuterSurfaceArea: 0.179872 m2; NetVolume: 0.00051 m3; NetWeight: 4.0035 kg

# IfcBeam: PLT6*49, BASEPLATE
In: Undefined
Description: PLT6*49; Material: STEEL/450
Tekla Common - Finish: GALVANIZE; Bottom elevation: -0.000; Top elevation: +0.155; Phase: 1; Class: 5
Default - ASSEMBLY_POS: PL/10
Tekla Quantity - Weight: 1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 48.3 m2; Net surface area: 0 m2; Height: 49 mm; Width: 6 mm; Length: 430.9 mm
Pset_BeamCommon - LoadBearing: no; Reference: PL/10
BaseQuantities - Length: 430.908 mm; OuterSurfaceArea: 0.048983 m2; NetVolume: 0.000129125 m3; NetWeight: 1.01363 kg

# IfcBeam: PLT6*61 (2)
In: Undefined
Description: PLT6*61; Material: STEEL/450
Tekla Common - Finish: GALVANIZE; Bottom elevation: -0.000; Top elevation: +0.155; Phase: 1; Class: 5
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 47.2 m2; Net surface area: 0.1 m2; Height: 61 mm; Width: 6 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Weight (kg) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
BASEPLATE | PL/20 | 1.6 | 532.9 | 532.908 | 0.0733561 | 0.000198079 | 1.55492
BASEPLATE | PL/19 | 1.4 | 481.9 | 481.908 | 0.0665221 | 0.000179413 | 1.40839

# IfcBeam: PLT6*80, BASEPLATE
In: Undefined
Description: PLT6*80; Material: STEEL/450
Tekla Common - Finish: GALVANIZE; Bottom elevation: +0.006; Top elevation: +0.166; Phase: 1; Class: 5
Default - ASSEMBLY_POS: PL/25
Tekla Quantity - Weight: 2.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 46.1 m2; Net surface area: 0.1 m2; Height: 80 mm; Width: 6 mm; Length: 587.7 mm
Pset_BeamCommon - LoadBearing: no; Reference: PL/25
BaseQuantities - Length: 587.708 mm; OuterSurfaceArea: 0.103607 m2; NetVolume: 0.00028608 m3; NetWeight: 2.24573 kg

# IfcBeam: PLT6*96, BASEPLATE
In: Undefined
Description: PLT6*96; Material: STEEL/450
Tekla Common - Finish: GALVANIZE; Bottom elevation: -0.000; Top elevation: +0.166; Phase: 1; Class: 5
Default - ASSEMBLY_POS: PL/24
Tekla Quantity - Weight: 2.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 45.6 m2; Net surface area: 0.1 m2; Height: 96 mm; Width: 6 mm; Length: 621.7 mm
Pset_BeamCommon - LoadBearing: no; Reference: PL/24
BaseQuantities - Length: 621.708 mm; OuterSurfaceArea: 0.129835 m2; NetVolume: 0.00036288 m3; NetWeight: 2.84861 kg

# IfcColumn: C:150-24, COLUMN
In: Undefined
Description: C:150-24; Material: STEEL/G450
Tekla Common - Finish: 1mm ggap +4; Bottom elevation: +0.000; Top elevation: +1.500; Phase: 1; Class: 12
Default - ASSEMBLY_POS: Z/66
Tekla Quantity - Weight: 8.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 111.3 m2; Net surface area: 0.9 m2; Height: 152 mm; Width: 64 mm; Length: 1499.6 mm
Pset_ColumnCommon - LoadBearing: no; Reference: Z/66
BaseQuantities - Length: 1499.71 mm; OuterSurfaceArea: 0.930694 m2; NetVolume: 0.00110642 m3; NetWeight: 8.68543 kg

# IfcColumn: C:200-24, COLUMN
In: Undefined
Description: C:200-24; Material: STEEL/G450
Tekla Common - Finish: 1mm ggap +4; Bottom elevation: +0.000; Top elevation: +1.500; Phase: 1; Class: 12
Default - ASSEMBLY_POS: Z/67
Tekla Quantity - Weight: 10.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 110.2 m2; Net surface area: 1.3 m2; Height: 203 mm; Width: 76 mm; Length: 1499.6 mm
Pset_ColumnCommon - LoadBearing: no; Reference: Z/67
BaseQuantities - Length: 1499.71 mm; OuterSurfaceArea: 1.17103 m2; NetVolume: 0.00139437 m3; NetWeight: 10.9458 kg

# IfcColumn: C:250-24, COLUMN
In: Undefined
Description: C:250-24; Material: STEEL/G450
Default - ASSEMBLY_POS: Z/68
Tekla Common - Finish: 1mm ggap +4; Bottom elevation: +0.000; Top elevation: +1.500; Phase: 1; Class: 12
Tekla Quantity - Weight: 12 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 109.8 m2; Net surface area: 1.3 m2; Height: 254 mm; Width: 76 mm; Length: 1499.6 mm
Pset_ColumnCommon - LoadBearing: no; Reference: Z/68
BaseQuantities - Length: 1499.61 mm; OuterSurfaceArea: 1.32115 m2; NetVolume: 0.00157423 m3; NetWeight: 12.3577 kg

# IfcColumn: C:300-30, COLUMN
In: Undefined
Description: C:300-30; Material: STEEL/G450
Tekla Common - Finish: 1mm ggap +4; Bottom elevation: +0.011; Top elevation: +1.500; Phase: 1; Class: 12
Default - ASSEMBLY_POS: Z/74
Tekla Quantity - Weight: 18.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.5 m2; Net surface area: 1.6 m2; Height: 300 mm; Width: 96 mm; Length: 1489 mm
Pset_ColumnCommon - LoadBearing: no; Reference: Z/74
BaseQuantities - Length: 1489 mm; OuterSurfaceArea: 1.62924 m2; NetVolume: 0.00242558 m3; NetWeight: 19.0408 kg

# IfcColumn: C:350-30, COLUMN
In: Undefined
Description: C:350-30; Material: STEEL/G450
Default - ASSEMBLY_POS: Z/75
Tekla Common - Finish: 1mm ggap +4; Bottom elevation: +0.011; Top elevation: +1.500; Phase: 1; Class: 12
Tekla Quantity - Weight: 22.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.2 m2; Net surface area: 1.9 m2; Height: 350 mm; Width: 125 mm; Length: 1489 mm
Pset_ColumnCommon - LoadBearing: no; Reference: Z/75
BaseQuantities - Length: 1489 mm; OuterSurfaceArea: 1.94256 m2; NetVolume: 0.00289461 m3; NetWeight: 22.7227 kg

# IfcColumn: D16 (14)
In: Undefined
Description: D16; Material: STEEL/300
Default - ASSEMBLY_POS: Z/65
Tekla Common - Phase: 1; Class: 1
Tekla Quantity - Weight: 0.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 36.2 m2; Net surface area: 0 m2; Height: 16 mm; Width: 16 mm; Length: 150 mm
Pset_ColumnCommon - LoadBearing: no; Reference: Z/65
BaseQuantities - Length: 150 mm; OuterSurfaceArea: 0.00770956 m2; NetVolume: 0.0000271529 m3; NetWeight: 0.21315 kg
Name | Bottom elevation | Top elevation
8 x THROUGH BOLTS | -0.120 | +0.030
4 x THROUGH BOLTS | -0.119 | +0.031
2 x THROUGH BOLTS | -0.118 | +0.032

# IfcElementAssembly (26)
In: Undefined
PredefinedType: RIGID_FRAME
Name | ASSEMBLY_POSITION_CODE = Assembly/Cast unit position code | ASSEMBLY_POS = Assembly/Cast unit Mark | Assembly/Cast unit weight (kg) | Assembly/Cast unit bottom elevation | Assembly/Cast unit top elevation | Width (mm)
4 x THROUGH BOLTS | C350SD/1 | Z/65 | 0.2 | -0.120 | +0.030 | 16
BASEPLATE | C350SD/1 | PL/27 | 3 | +0.006 | +0.166 | 346
4 x THROUGH BOLTS | C300SD/1 | Z/65 | 0.2 | -0.120 | +0.030 | 16
BASEPLATE | C300SD/1 | PL/24 | 2.8 | -0.000 | +0.166 | 318
COLUMN | C350SD/1 | Z/75 | 22.3 | +0.011 | +1.500 | 125
COLUMN | C300SD/1 | Z/74 | 18.6 | +0.011 | +1.500 | 96
BASEPLATE | C350SD/1 | PL/26 | 4 | -0.000 | +0.166 | 368
BASEPLATE | C300SD/1 | PL/25 | 2.2 | +0.006 | +0.166 | 296
COLUMN | C250SD/1 | Z/68 | 12 | +0.000 | +1.500 | 76
BASEPLATE | C250SD/1 | PL/20 | 1.6 | -0.000 | +0.155 | 251.2
BASEPLATE | C200SD/1 | PL/19 | 1.4 | -0.000 | +0.155 | 200.2
COLUMN | C200SD/1 | Z/67 | 10.6 | +0.000 | +1.500 | 76
BASEPLATE | C150SD/1 | PL/10 | 1 | -0.000 | +0.155 | 149.2
COLUMN | C150SD/1 | Z/66 | 8.4 | +0.000 | +1.500 | 64
2 x THROUGH BOLTS | C250SD/1 | Z/65 | 0.2 | -0.119 | +0.031 | 16
2 x THROUGH BOLTS | C200SD/1 | Z/65 | 0.2 | -0.119 | +0.031 | 16
2 x THROUGH BOLTS | C150SD/1 | Z/65 | 0.2 | -0.118 | +0.032 | 16

# IfcMechanicalFastener: Bolt assembly (17)
In: Undefined
Material: 8.8S
Tekla Bolt - Washer type: HARD; Nut type: 8.8-HEX; Location: Site; Bolt count: 2; Bolt standard: 8.8S
Name | NominalDiameter (mm) = Washer diameter (mm) = Bolt size (mm) | NominalLength (mm) = Bolt length (mm) | Washer count = Nut count | Washer name | Nut name | Slotted hole y (mm) | Slotted hole x (mm) | Bolt hole diameter (mm) | Bolt Name
4 x Bolt assembly | 20 | 22 | 0 | WASHERM20-HARD | NUTM20-8.8-HEX | 0 | 0 | 20 | BOLTM20*25
4 x Bolt assembly | 16 | 50 | 2 | WASHERM16-HARD | NUTM16-8.8-HEX | 0 | 6 | 18 | BOLTM16*50
2 x Bolt assembly | 16 | 35 | 2 | WASHERM16-HARD | NUTM16-8.8-HEX | 0 | 4 | 18 | BOLTM16*35
3 x Bolt assembly | 20 | 16 | 0 | WASHERM20-HARD | NUTM20-8.8-HEX | 0 | 0 | 20 | BOLTM20*25
2 x Bolt assembly | 12 | 30 | 2 | WASHERM12-HARD | NUTM12-8.8-HEX | 4 | 8 | 14 | BOLTM12*30
2 x Bolt assembly | 12 | 35 | 2 | WASHERM12-HARD | NUTM12-8.8-HEX | 4 | 8 | 14 | BOLTM12*35
