Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView_V2.0, QuantityTakeOffAddOnView], Option [BaseQuantities:On], Option [GridExport:On], Option [Assemblies:On], Option [Bolts:On], Option [Rebars:On], Option [PourObjects:Off], Option [Welds:Off], Option [SurfaceTreatments:Off], Option [LocationBy:0], Option [ViewColors:Off], Option [SectionedSpine:Off], Option [PropertySets:On], Option [Export all:Off]
File name: Single C-Section Column Welded Baseplate.ifc
Time: 2026-02-25T14:24:55
Author: DESKTOP-BKNQL56\admin
Organization: Structural Designer
Written by: IFC Database Version: Work
Made in: Tekla Structures 2019 Service Pack 13, IFC Export Version: 4.0.0.0 Oct 18 2021

# IfcBuildingStorey, Undefined
In: Undefined
Elevation: 0 mm

# IfcBeam: D20 (4)
In: Undefined
Description: D20; Material: STEEL/250
Default - ASSEMBLY_POS: Z/953
Tekla Common - Bottom elevation: -0.088; Top elevation: +0.062; Phase: 1; Class: 1
Tekla Quantity - Weight: 0.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 29.3 m2; Net surface area: 0 m2; Height: 20 mm; Width: 20 mm; Length: 150 mm
Pset_BeamCommon - LoadBearing: no; Reference: Z/953
BaseQuantities - Length: 150 mm; OuterSurfaceArea: 0.00975009 m2; NetVolume: 0.0000424264 m3; NetWeight: 0.333047 kg

# IfcColumn: C:300-30, COLUMN
In: Undefined
Description: C:300-30; Material: STEEL/G450
Tekla Common - Finish: 1mm ggap +4; Bottom elevation: +0.012; Top elevation: +1.500; Phase: 1; Class: 12
Default - ASSEMBLY_POS: Z/188(?)
Tekla Quantity - Weight: 18.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.5 m2; Net surface area: 1.6 m2; Height: 300 mm; Width: 96 mm; Length: 1488 mm
Pset_ColumnCommon - LoadBearing: no; Reference: Z/188(?)
BaseQuantities - Length: 1488 mm; OuterSurfaceArea: 1.62815 m2; NetVolume: 0.00242395 m3; NetWeight: 19.028 kg

# IfcColumn: C:350-30, COLUMN
In: Undefined
Description: C:350-30; Material: STEEL/G450
Default - ASSEMBLY_POS: Z/202(?)
Tekla Common - Finish: 1mm ggap +4; Bottom elevation: +0.012; Top elevation: +1.500; Phase: 1; Class: 12
Tekla Quantity - Weight: 22.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.2 m2; Net surface area: 1.9 m2; Height: 350 mm; Width: 125 mm; Length: 1488 mm
Pset_ColumnCommon - LoadBearing: no; Reference: Z/202(?)
BaseQuantities - Length: 1488 mm; OuterSurfaceArea: 1.94126 m2; NetVolume: 0.00289267 m3; NetWeight: 22.7074 kg

# IfcDiscreteAccessory: BASEPLATE (6)
In: Undefined
Material: STEEL/450
Tekla Common - Phase: 1; Class: 5
Tekla Quantity - Volume: 0 m3
Pset_PlateCommon - LoadBearing: no
Name | Description | Finish | Bottom elevation | Top elevation | Weight (kg) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) | Height (mm) | Width (mm) | Length (mm) | Reference | NetArea (m2) = GrossArea (m2) | CrossSectionArea (m2) | NetVolume (m3) = GrossVolume (m3)
2 x BASEPLATE | PLT6*95 | GALVANIZE | +0.012 | +0.236 | 1 | 0 | 46.3 | 0 | 95 | 6 | 224 | z/960(?) | 0.046388 | 0.00057 | 0.00012768
2 x BASEPLATE | PLT6*125 | GALVANIZE | +0.012 | +0.236 | 1.3 | 0 | 45.6 | 0.1 | 125 | 6 | 224 | z/959(?) | 0.060188 | 0.00075 | 0.000168
BASEPLATE | PLT12*120 |  | +0.000 | +0.012 | 5.4 | 0.1 | 23.9 | 0.1 | 120 | 12 | 480 | Z/954(?) | 0.1296 | 0.00144 | 0.0006912
BASEPLATE | FL12*150 |  | +0.000 | +0.012 | 7.5 | 0.1 | 23.4 | 0.2 | 150 | 12 | 530 | Z/958(?) | 0.17532 | 0.0018 | 0.000954

# IfcDiscreteAccessory: PLATE (8)
In: Undefined
Description: PLT6*81; Material: STEEL/450
Tekla Common - Bottom elevation: +0.012; Top elevation: +0.236; Phase: 1; Class: 5
Tekla Quantity - Weight: 0.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 50.1 m2; Net surface area: 0 m2; Height: 81 mm; Width: 6 mm; Length: 224 mm
Pset_PlateCommon - LoadBearing: no; Reference: z/961(?)
BaseQuantities - NetArea: 0.0214032 m2; GrossArea: 0.018144 m2; CrossSectionArea: 0.000036 m2; NetVolume: 0.000054432 m3; GrossVolume: 0.000054432 m3

# IfcElementAssembly (8)
In: Undefined
PredefinedType: RIGID_FRAME
Name | ASSEMBLY_POSITION_CODE = Assembly/Cast unit position code | ASSEMBLY_POS = Assembly/Cast unit Mark | Assembly/Cast unit weight (kg) | Assembly/Cast unit bottom elevation | Assembly/Cast unit top elevation | Width (mm)
BASEPLATE | C300SD/4 | Z/954(?) | 9.1 | +0.000 | +0.236 | 236
BASEPLATE | C350SD/4 | Z/958(?) | 11.8 | +0.000 | +0.236 | 236
2 x ANCHOR ROD | C300SD/4 | Z/953 | 0.3 | -0.088 | +0.062 | 20
2 x ANCHOR ROD | C350SD/4 | Z/953 | 0.3 | -0.088 | +0.062 | 20
COLUMN | C350SD/4 | Z/202(?) | 22.3 | +0.012 | +1.500 | 125
COLUMN | C300SD/4 | Z/188(?) | 18.6 | +0.012 | +1.500 | 96

# IfcMechanicalFastener: Bolt assembly (6)
In: Undefined
Tekla Bolt - Slotted hole y: 0 mm; Location: Site
Name | NominalDiameter (mm) = Washer diameter (mm) | NominalLength (mm) = Bolt length (mm) | Material | Washer count = Nut count | Washer type | Washer name | Nut type | Nut name | Slotted hole x (mm) | Bolt hole diameter (mm) | Bolt count | Bolt size (mm) | Bolt standard | Bolt Name
2 x Bolt assembly | 20 | 12 | HIT_HY150 | 0 | WASHER-HAS | HAS-WASHER-20 | NUT-HAS | HAS-NUT-20 | 0 | 26 | 2 | 26 | HILTI_HY150-E | HAS
4 x Bolt assembly | 16 | 45 | 8.8S | 3 | HARD | WASHERM16-HARD | 8.8-HEX | NUTM16-8.8-HEX | 6 | 18 | 3 | 16 | 8.8S | BOLTM16*45
