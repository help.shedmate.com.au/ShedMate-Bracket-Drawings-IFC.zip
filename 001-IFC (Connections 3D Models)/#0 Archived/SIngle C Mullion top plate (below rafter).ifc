Properties of the parts of a building model (IFC2X3), part 1 of 3

# File
Description: ViewDefinition[CoordinationView_V2.0, QuantityTakeOffAddOnView], Option [BaseQuantities:On], Option [GridExport:On], Option [Assemblies:On], Option [Bolts:On], Option [Rebars:On], Option [PourObjects:Off], Option [Welds:Off], Option [SurfaceTreatments:Off], Option [LocationBy:0], Option [ViewColors:Off], Option [SectionedSpine:Off], Option [PropertySets:On], Option [Export all:Off]
File name: SIngle C Mullion top plate (below rafter).ifc
Time: 2026-05-22T07:02:31
Author: DESKTOP-BKNQL56\admin
Organization: Structural Designer
Written by: IFC Database version: Work
Made in: Tekla Structures 2019 Service Pack 13, IFC Export Version: 4.0.0.0 Oct 18 2021

# IfcBuildingStorey, Undefined
In: Undefined
Elevation: 0 mm

# IfcBeam: C:150-24 (48)
In: Undefined
Description: C:150-24; Material: STEEL/G450
Tekla Quantity - Weight: 21.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 111.2 m2; Net surface area: 2.4 m2; Height: 152 mm; Width: 64 mm; Length: 3927.1 mm
Tekla Common - Phase: 200; Class: 1
Pset_BeamCommon - LoadBearing: no
BaseQuantities - Length: 3927.11 mm; OuterSurfaceArea: 2.43471 m2; NetVolume: 0.00289726 m3; NetWeight: 22.7435 kg
Name | ASSEMBLY_POS = Reference | Finish | Bottom elevation | Top elevation
8 x RAFTER | Z/175 | 18 deg | +4.667 | +6.026
8 x RAFTER | Z/158 | 15 deg | +4.708 | +5.871
8 x RAFTER | Z/159 | 12 deg | +4.748 | +5.713
4 x RAFTER | Z/158 | 15 deg | +4.784 | +5.549
4 x RAFTER | Z/269 | 9 deg | +4.784 | +5.549
8 x RAFTER | Z/140 | 5 deg | +4.834 | +5.328
6 x RAFTER | Z/55 | 3 deg | +4.858 | +5.216
RAFTER | Z/2167 | 3 deg | +4.858 | +5.216
RAFTER | Z/2109 | 3 deg | +4.858 | +5.216

# IfcBeam: C:200-24 (118)
In: Undefined
Description: C:200-24; Material: STEEL/G450
Tekla Common - Phase: 200
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 110 m2; Height: 203 mm; Width: 76 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Finish | Bottom elevation | Top elevation | Class | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x MULLION | Z/1554 | 3 deg | +0.000 | +4.720 | 2 | 33.5 | 3.7 | 4719.9 | 4719.86 | 3.68146 | 0.00438834 | 34.4484
2 x MULLION | Z/1555 | 5 deg | +0.000 | +4.727 | 2 | 33.5 | 3.7 | 4727 | 4727.03 | 3.68705 | 0.004395 | 34.5008
2 x MULLION | Z/1556 | 9 deg | +0.000 | +4.742 | 2 | 33.6 | 3.7 | 4741.5 | 4741.51 | 3.69834 | 0.00440847 | 34.6065
2 x MULLION | Z/1557 | 12 deg | +0.000 | +4.753 | 2 | 33.7 | 3.7 | 4752.6 | 4752.57 | 3.70696 | 0.00441875 | 34.6872
2 x MULLION | Z/1704 | 15 deg | +0.000 | +4.764 | 2 | 33.8 | 3.7 | 4763.9 | 4763.88 | 3.71578 | 0.00442927 | 34.7697
2 x MULLION | Z/1705 | 18 deg | +0.000 | +4.776 | 2 | 33.8 | 3.7 | 4775.5 | 4775.52 | 3.72485 | 0.00444009 | 34.8547
2 x MULLION | Z/1724 | 25 deg | +0.000 | +4.804 | 2 | 34.1 | 3.7 | 4804.4 | 4804.39 | 3.74736 | 0.00446693 | 35.0654
2 x MULLION | Z/924 | 25 deg | +0.000 | +4.859 | 2 | 34.4 | 3.8 | 4859.2 | 4859.17 | 3.79007 | 0.00451786 | 35.4652
2 x MULLION | Z/921 | 18 deg | +0.000 | +4.825 | 2 | 34.2 | 3.8 | 4825.3 | 4825.29 | 3.76366 | 0.00448636 | 35.2179
2 x MULLION | Z/920 | 15 deg | +0.000 | +4.812 | 2 | 34.1 | 3.8 | 4811.6 | 4811.64 | 3.75301 | 0.00447367 | 35.1183
2 x MULLION | Z/919 | 12 deg | +0.000 | +4.798 | 2 | 34 | 3.7 | 4798.4 | 4798.37 | 3.74267 | 0.00446133 | 35.0215
2 x MULLION | Z/918 | 9 deg | +0.000 | +4.785 | 2 | 33.8 | 3.7 | 4785.4 | 4785.39 | 3.73255 | 0.00444926 | 34.9267
2 x MULLION | Z/917 | 5 deg | +0.000 | +4.768 | 2 | 33.8 | 3.7 | 4768.4 | 4768.4 | 3.7193 | 0.00443347 | 34.8027
2 x MULLION | Z/139 | 3 deg | +0.000 | +4.760 | 2 | 33.7 | 3.7 | 4760 | 4760 | 3.71276 | 0.00442566 | 34.7414
2 x MULLION | Z/54 | 3 deg | +0.000 | +4.797 | 2 | 34 | 3.7 | 4796.5 | 4796.53 | 3.74123 | 0.00445962 | 35.008
2 x MULLION | Z/883 | 5 deg | +0.000 | +4.806 | 2 | 34.1 | 3.7 | 4806.1 | 4806.08 | 3.74868 | 0.0044685 | 35.0777
2 x MULLION | Z/884 | 9 deg | +0.000 | +4.825 | 2 | 34.2 | 3.8 | 4825.4 | 4825.37 | 3.76372 | 0.00448644 | 35.2185
2 x MULLION | Z/885 | 12 deg | +0.000 | +4.840 | 2 | 34.4 | 3.8 | 4840.1 | 4840.12 | 3.77522 | 0.00450015 | 35.3262
2 x MULLION | Z/886 | 15 deg | +0.000 | +4.855 | 2 | 34.4 | 3.8 | 4855.2 | 4855.19 | 3.78697 | 0.00451416 | 35.4362
2 x MULLION | Z/887 | 18 deg | +0.000 | +4.871 | 2 | 34.5 | 3.8 | 4870.7 | 4870.7 | 3.79906 | 0.00452858 | 35.5494
2 x MULLION | Z/888 | 25 deg | +0.000 | +4.909 | 2 | 34.8 | 3.8 | 4909.2 | 4909.18 | 3.82906 | 0.00456436 | 35.8302
2 x MULLION | Z/859 | 15 deg | +0.000 | +4.965 | 2 | 35.2 | 3.9 | 4965.2 | 4965.16 | 3.8727 | 0.00461641 | 36.2388
8 x RAFTER | Z/703 | 18 deg | +4.619 | +6.026 | 1 | 27.8 | 3.1 | 3927.1 | 3927.11 | 3.06343 | 0.00365127 | 28.6625
2 x MULLION | Z/858 | 18 deg | +0.000 | +4.922 | 2 | 34.8 | 3.8 | 4921.6 | 4921.57 | 3.83872 | 0.00457588 | 35.9207
8 x RAFTER | Z/701 | 15 deg | +4.659 | +5.871 | 1 | 27.8 | 3.1 | 3927.1 | 3927.11 | 3.06343 | 0.00365127 | 28.6625
2 x MULLION | Z/857 | 15 deg | +0.000 | +4.904 | 2 | 34.8 | 3.8 | 4904 | 4904.01 | 3.82503 | 0.00455955 | 35.7925
8 x RAFTER | Z/696 | 12 deg | +4.698 | +5.713 | 1 | 27.8 | 3.1 | 3927.1 | 3927.11 | 3.06343 | 0.00365127 | 28.6625
2 x MULLION | Z/856 | 12 deg | +0.000 | +4.887 | 2 | 34.6 | 3.8 | 4886.9 | 4886.93 | 3.81171 | 0.00454367 | 35.6678
4 x RAFTER | Z/701 | 15 deg | +4.734 | +5.549 | 1 | 27.8 | 3.1 | 3927.1 | 3927.11 | 3.06343 | 0.00365127 | 28.6625
4 x RAFTER | Z/726 | 9 deg | +4.734 | +5.549 | 1 | 27.8 | 3.1 | 3927.1 | 3927.11 | 3.06343 | 0.00365127 | 28.6625
2 x MULLION | Z/855 | 9 deg | +0.000 | +4.871 | 2 | 34.5 | 3.8 | 4870.7 | 4870.73 | 3.79908 | 0.00452861 | 35.5496
8 x RAFTER | Z/699 | 5 deg | +4.783 | +5.328 | 1 | 27.8 | 3.1 | 3927.1 | 3927.11 | 3.06343 | 0.00365127 | 28.6625
2 x MULLION | Z/854 | 5 deg | +0.000 | +4.848 | 2 | 34.4 | 3.8 | 4847.9 | 4847.88 | 3.78127 | 0.00450737 | 35.3828
8 x RAFTER | Z/697 | 3 deg | +4.807 | +5.216 | 1 | 27.8 | 3.1 | 3927.1 | 3927.11 | 3.06343 | 0.00365127 | 28.6625
2 x MULLION | Z/853 | 3 deg | +0.000 | +4.836 | 2 | 34.4 | 3.8 | 4836.5 | 4836.45 | 3.77236 | 0.00449674 | 35.2994
2 x MULLION | Z/199 | 15 deg | +0.000 | +5.021 | 2 | 35.6 | 3.9 | 5021.4 | 5021.43 | 3.91657 | 0.00466872 | 36.6495
2 x MULLION | Z/196 | 18 deg | +0.000 | +4.975 | 2 | 35.3 | 3.9 | 4975.2 | 4975.19 | 3.88052 | 0.00462573 | 36.312
2 x MULLION | Z/179 | 15 deg | +0.000 | +4.957 | 2 | 35.1 | 3.9 | 4956.8 | 4956.81 | 3.86619 | 0.00460864 | 36.1779
2 x MULLION | Z/178 | 12 deg | +0.000 | +4.939 | 2 | 35 | 3.9 | 4939.1 | 4939.07 | 3.85236 | 0.00459215 | 36.0484
2 x MULLION | Z/176 | 9 deg | +0.000 | +4.922 | 2 | 34.8 | 3.8 | 4922.4 | 4922.37 | 3.83934 | 0.00457662 | 35.9265
2 x MULLION | Z/141 | 5 deg | +0.000 | +4.899 | 2 | 34.7 | 3.8 | 4899.1 | 4899.07 | 3.82117 | 0.00455496 | 35.7564
2 x MULLION | Z/56 | 3 deg | +0.000 | +4.888 | 2 | 34.6 | 3.8 | 4887.5 | 4887.52 | 3.81217 | 0.00454422 | 35.6721

# IfcBeam: C:250-24 (118)
In: Undefined
Description: C:250-24; Material: STEEL/G450
Tekla Common - Phase: 200
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 109.7 m2; Height: 254 mm; Width: 76 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Finish | Bottom elevation | Top elevation | Class | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x MULLION | Z/1725 | 3 deg | +0.000 | +4.757 | 2 | 38.2 | 4.2 | 4756.6 | 4756.55 | 4.18596 | 0.00499324 | 39.1969
2 x MULLION | Z/1741 | 5 deg | +0.000 | +4.788 | 2 | 38.4 | 4.2 | 4788.3 | 4788.27 | 4.21386 | 0.00502653 | 39.4583
2 x MULLION | Z/1742 | 9 deg | +0.000 | +4.852 | 2 | 38.9 | 4.2 | 4852.4 | 4852.38 | 4.27025 | 0.00509383 | 39.9866
2 x MULLION | Z/1758 | 12 deg | +0.000 | +4.901 | 2 | 39.3 | 4.2 | 4901.4 | 4901.36 | 4.31334 | 0.00514525 | 40.3902
2 x MULLION | Z/1759 | 15 deg | +0.000 | +4.951 | 2 | 39.7 | 4.4 | 4951.5 | 4951.45 | 4.35739 | 0.00519783 | 40.803
2 x MULLION | Z/1796 | 18 deg | +0.000 | +5.003 | 2 | 40.1 | 4.4 | 5003 | 5002.96 | 4.4027 | 0.00525191 | 41.2275
2 x MULLION | Z/1876 | 25 deg | +0.000 | +5.131 | 2 | 41.2 | 4.4 | 5130.8 | 5130.81 | 4.51516 | 0.00538612 | 42.281
2 x MULLION | Z/936 | 25 deg | +0.000 | +5.186 | 2 | 41.6 | 4.6 | 5185.6 | 5185.59 | 4.56334 | 0.00544363 | 42.7325
2 x MULLION | Z/935 | 18 deg | +0.000 | +5.053 | 2 | 40.5 | 4.4 | 5052.7 | 5052.74 | 4.44649 | 0.00530416 | 41.6377
2 x MULLION | Z/934 | 15 deg | +0.000 | +4.999 | 2 | 40.1 | 4.4 | 4999.2 | 4999.21 | 4.3994 | 0.00524797 | 41.1966
2 x MULLION | Z/933 | 12 deg | +0.000 | +4.947 | 2 | 39.7 | 4.4 | 4947.2 | 4947.16 | 4.35362 | 0.00519333 | 40.7676
2 x MULLION | Z/929 | 9 deg | +0.000 | +4.896 | 2 | 39.3 | 4.2 | 4896.3 | 4896.26 | 4.30885 | 0.0051399 | 40.3482
2 x MULLION | Z/926 | 5 deg | +0.000 | +4.830 | 2 | 38.7 | 4.2 | 4829.6 | 4829.64 | 4.25025 | 0.00506996 | 39.7992
2 x MULLION | Z/925 | 3 deg | +0.000 | +4.797 | 2 | 38.4 | 4.2 | 4796.7 | 4796.68 | 4.22126 | 0.00503536 | 39.5276
8 x RAFTER | Z/745 | 3 deg | +4.771 | +5.228 | 1 | 31.2 | 3.4 | 3890.2 | 3890.2 | 3.42392 | 0.00408377 | 32.0576
2 x MULLION | Z/889 | 3 deg | +0.000 | +4.833 | 2 | 38.8 | 4.2 | 4833.2 | 4833.21 | 4.25339 | 0.00507371 | 39.8286
8 x RAFTER | Z/746 | 5 deg | +4.746 | +5.338 | 1 | 31.2 | 3.4 | 3890.2 | 3890.2 | 3.42392 | 0.00408377 | 32.0576
2 x MULLION | Z/890 | 5 deg | +0.000 | +4.867 | 2 | 38.9 | 4.2 | 4867.3 | 4867.32 | 4.28339 | 0.00510952 | 40.1097
8 x RAFTER | Z/747 | 9 deg | +4.696 | +5.556 | 1 | 31.2 | 3.4 | 3890.2 | 3890.2 | 3.42392 | 0.00408377 | 32.0576
2 x MULLION | Z/891 | 9 deg | +0.000 | +4.936 | 2 | 39.6 | 4.2 | 4936.2 | 4936.24 | 4.34402 | 0.00518187 | 40.6777
8 x RAFTER | Z/705 | 12 deg | +4.658 | +5.716 | 1 | 31.2 | 3.4 | 3890.2 | 3890.2 | 3.42392 | 0.00408377 | 32.0576
2 x MULLION | Z/892 | 12 deg | +0.000 | +4.989 | 2 | 40 | 4.4 | 4988.9 | 4988.91 | 4.39034 | 0.00523716 | 41.1117
8 x RAFTER | Z/748 | 15 deg | +4.620 | +5.872 | 1 | 31.2 | 3.4 | 3890.2 | 3890.2 | 3.42392 | 0.00408377 | 32.0576
2 x MULLION | Z/895 | 15 deg | +0.000 | +5.043 | 2 | 40.5 | 4.4 | 5042.8 | 5042.75 | 4.4377 | 0.00529368 | 41.5554
8 x RAFTER | Z/749 | 18 deg | +4.580 | +6.024 | 1 | 31.2 | 3.4 | 3890.2 | 3890.2 | 3.42392 | 0.00408377 | 32.0576
2 x MULLION | Z/896 | 18 deg | +0.000 | +5.098 | 2 | 40.9 | 4.4 | 5098.1 | 5098.14 | 4.48642 | 0.00535182 | 42.0118
2 x MULLION | Z/898 | 25 deg | +0.000 | +5.236 | 2 | 42 | 4.6 | 5235.6 | 5235.6 | 4.60733 | 0.00549612 | 43.1446
2 x MULLION | Z/868 | 15 deg | +0.000 | +5.292 | 2 | 42.5 | 4.6 | 5291.6 | 5291.58 | 4.65657 | 0.00555489 | 43.6059
2 x MULLION | Z/867 | 18 deg | +0.000 | +5.149 | 2 | 41.3 | 4.4 | 5149 | 5149.02 | 4.53118 | 0.00540524 | 42.4311
2 x MULLION | Z/864 | 15 deg | +0.000 | +5.092 | 2 | 40.8 | 4.4 | 5091.6 | 5091.58 | 4.48065 | 0.00534494 | 41.9578
2 x MULLION | Z/863 | 12 deg | +0.000 | +5.036 | 2 | 40.5 | 4.4 | 5035.7 | 5035.72 | 4.43152 | 0.0052863 | 41.4974
2 x MULLION | Z/862 | 9 deg | +0.000 | +4.982 | 2 | 40 | 4.4 | 4981.6 | 4981.6 | 4.38391 | 0.00522948 | 41.0515
2 x MULLION | Z/861 | 5 deg | +0.000 | +4.909 | 2 | 39.4 | 4.2 | 4909.2 | 4909.12 | 4.32016 | 0.0051534 | 40.4542
2 x MULLION | Z/860 | 3 deg | +0.000 | +4.873 | 2 | 39.1 | 4.2 | 4873.1 | 4873.13 | 4.2885 | 0.00511562 | 40.1576
2 x MULLION | Z/312 | 15 deg | +0.000 | +5.348 | 2 | 42.9 | 4.6 | 5347.9 | 5347.85 | 4.70607 | 0.00561396 | 44.0696
2 x MULLION | Z/311 | 18 deg | +0.000 | +5.203 | 2 | 41.7 | 4.6 | 5202.6 | 5202.64 | 4.57834 | 0.00546152 | 42.873
2 x MULLION | Z/279 | 15 deg | +0.000 | +5.144 | 2 | 41.3 | 4.4 | 5144.4 | 5144.38 | 4.5271 | 0.00540036 | 42.3929
2 x MULLION | Z/278 | 12 deg | +0.000 | +5.088 | 2 | 40.8 | 4.4 | 5087.9 | 5087.86 | 4.47738 | 0.00534103 | 41.9271
2 x MULLION | Z/270 | 9 deg | +0.000 | +5.033 | 2 | 40.5 | 4.4 | 5033.2 | 5033.24 | 4.42934 | 0.00528369 | 41.477
2 x MULLION | Z/155 | 5 deg | +0.000 | +4.960 | 2 | 39.8 | 4.4 | 4960.3 | 4960.31 | 4.36519 | 0.00520714 | 40.876
2 x MULLION | Z/136 | 3 deg | +0.000 | +4.924 | 2 | 39.4 | 4.2 | 4924.2 | 4924.2 | 4.33343 | 0.00516923 | 40.5784

# IfcBeam: C:300-30 (118)
In: Undefined
Description: C:300-30; Material: STEEL/G450
Tekla Common - Phase: 200
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.4 m2; Height: 300 mm; Width: 96 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Finish | Bottom elevation | Top elevation | Class | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x MULLION | Z/2021 | 3 deg | +0.000 | +4.793 | 2 | 59.9 | 5.2 | 4792.7 | 4792.71 | 5.2369 | 0.00780732 | 61.2875
2 x MULLION | Z/2022 | 5 deg | +0.000 | +4.849 | 2 | 60.6 | 5.3 | 4848.6 | 4848.64 | 5.29797 | 0.00789843 | 62.0027
2 x MULLION | Z/2023 | 9 deg | +0.000 | +4.962 | 2 | 62 | 5.3 | 4961.7 | 4961.66 | 5.42139 | 0.00808254 | 63.448
2 x MULLION | Z/2048 | 12 deg | +0.000 | +5.048 | 2 | 63.1 | 5.5 | 5048 | 5048.02 | 5.5157 | 0.00822322 | 64.5523
2 x MULLION | Z/2049 | 15 deg | +0.000 | +5.136 | 2 | 64.2 | 5.6 | 5136.3 | 5136.33 | 5.61213 | 0.00836708 | 65.6816
2 x MULLION | Z/2050 | 18 deg | +0.000 | +5.227 | 2 | 65.4 | 5.6 | 5227.2 | 5227.15 | 5.71131 | 0.00851503 | 66.843
2 x MULLION | Z/2051 | 25 deg | +0.000 | +5.453 | 2 | 68.2 | 6 | 5452.6 | 5452.56 | 5.95745 | 0.00888222 | 69.7254
2 x MULLION | Z/943 | 25 deg | +0.000 | +5.507 | 2 | 68.9 | 6 | 5507.3 | 5507.34 | 6.01727 | 0.00897146 | 70.4259
8 x RAFTER | Z/779 | 18 deg | +4.545 | +6.022 | 1 | 48.2 | 4.2 | 3856.9 | 3856.9 | 4.21499 | 0.00628289 | 49.3207
2 x MULLION | Z/942 | 18 deg | +0.000 | +5.277 | 2 | 66 | 5.8 | 5276.9 | 5276.93 | 5.76567 | 0.00859612 | 67.4795
8 x RAFTER | Z/778 | 15 deg | +4.585 | +5.873 | 1 | 48.2 | 4.2 | 3856.9 | 3856.9 | 4.21499 | 0.00628289 | 49.3207
2 x MULLION | Z/941 | 15 deg | +0.000 | +5.184 | 2 | 64.8 | 5.6 | 5184.1 | 5184.09 | 5.66428 | 0.00844488 | 66.2923
8 x RAFTER | Z/714 | 12 deg | +4.624 | +5.719 | 1 | 48.2 | 4.2 | 3856.9 | 3856.9 | 4.21499 | 0.00628289 | 49.3207
2 x MULLION | Z/940 | 12 deg | +0.000 | +5.094 | 2 | 63.7 | 5.6 | 5093.8 | 5093.82 | 5.56571 | 0.00829783 | 65.138
8 x RAFTER | Z/777 | 9 deg | +4.662 | +5.561 | 1 | 48.2 | 4.2 | 3856.9 | 3856.9 | 4.21499 | 0.00628289 | 49.3207
2 x MULLION | Z/939 | 9 deg | +0.000 | +5.006 | 2 | 62.6 | 5.5 | 5005.5 | 5005.54 | 5.46931 | 0.00815402 | 64.0091
8 x RAFTER | Z/776 | 5 deg | +4.711 | +5.346 | 1 | 48.2 | 4.2 | 3856.9 | 3856.9 | 4.21499 | 0.00628289 | 49.3207
2 x MULLION | Z/938 | 5 deg | +0.000 | +4.890 | 2 | 61.1 | 5.3 | 4890 | 4890.01 | 5.34315 | 0.00796583 | 62.5317
8 x RAFTER | Z/775 | 3 deg | +4.736 | +5.237 | 1 | 48.2 | 4.2 | 3856.9 | 3856.9 | 4.21499 | 0.00628289 | 49.3207
2 x MULLION | Z/937 | 3 deg | +0.000 | +4.833 | 2 | 60.4 | 5.3 | 4832.8 | 4832.84 | 5.28072 | 0.0078727 | 61.8007
2 x MULLION | Z/901 | 3 deg | +0.000 | +4.869 | 2 | 60.9 | 5.3 | 4869.4 | 4869.38 | 5.32062 | 0.00793222 | 62.2679
2 x MULLION | Z/904 | 5 deg | +0.000 | +4.928 | 2 | 61.6 | 5.3 | 4927.7 | 4927.69 | 5.3843 | 0.00802721 | 63.0136
2 x MULLION | Z/905 | 9 deg | +0.000 | +5.046 | 2 | 63.1 | 5.5 | 5045.5 | 5045.53 | 5.51298 | 0.00821917 | 64.5205
2 x MULLION | Z/906 | 12 deg | +0.000 | +5.136 | 2 | 64.2 | 5.6 | 5135.6 | 5135.57 | 5.6113 | 0.00836584 | 65.6719
2 x MULLION | Z/907 | 15 deg | +0.000 | +5.228 | 2 | 65.4 | 5.6 | 5227.6 | 5227.64 | 5.71184 | 0.00851583 | 66.8492
2 x MULLION | Z/908 | 18 deg | +0.000 | +5.322 | 2 | 66.6 | 5.8 | 5322.3 | 5322.34 | 5.81525 | 0.00867009 | 68.0602
2 x MULLION | Z/909 | 25 deg | +0.000 | +5.557 | 2 | 69.5 | 6.1 | 5557.4 | 5557.35 | 6.07188 | 0.00905292 | 71.0654
2 x MULLION | Z/875 | 15 deg | +0.000 | +5.613 | 2 | 70.2 | 6.1 | 5613.3 | 5613.33 | 6.13301 | 0.00914411 | 71.7813
2 x MULLION | Z/874 | 18 deg | +0.000 | +5.373 | 2 | 67.2 | 5.8 | 5373.2 | 5373.21 | 5.8708 | 0.00875296 | 68.7107
2 x MULLION | Z/873 | 15 deg | +0.000 | +5.276 | 2 | 66 | 5.8 | 5276.5 | 5276.46 | 5.76515 | 0.00859535 | 67.4735
2 x MULLION | Z/872 | 12 deg | +0.000 | +5.182 | 2 | 64.8 | 5.6 | 5182.4 | 5182.39 | 5.66243 | 0.00844211 | 66.2706
2 x MULLION | Z/871 | 9 deg | +0.000 | +5.091 | 2 | 63.7 | 5.6 | 5090.9 | 5090.89 | 5.56251 | 0.00829306 | 65.1005
2 x MULLION | Z/870 | 5 deg | +0.000 | +4.969 | 2 | 62.1 | 5.3 | 4969.5 | 4969.49 | 5.42994 | 0.0080953 | 63.5481
2 x MULLION | Z/869 | 3 deg | +0.000 | +4.909 | 2 | 61.4 | 5.3 | 4909.3 | 4909.3 | 5.36421 | 0.00799725 | 62.7784
2 x MULLION | Z/847 | 15 deg | +0.000 | +5.670 | 2 | 70.9 | 6.1 | 5669.6 | 5669.6 | 6.19446 | 0.00923578 | 72.5009
2 x MULLION | Z/838 | 18 deg | +0.000 | +5.427 | 2 | 67.9 | 5.8 | 5426.8 | 5426.83 | 5.92936 | 0.00884031 | 69.3964
2 x MULLION | Z/837 | 15 deg | +0.000 | +5.329 | 2 | 66.6 | 5.8 | 5329.3 | 5329.26 | 5.82281 | 0.00868136 | 68.1487
2 x MULLION | Z/836 | 12 deg | +0.000 | +5.235 | 2 | 65.4 | 5.6 | 5234.5 | 5234.53 | 5.71936 | 0.00852705 | 66.9373
2 x MULLION | Z/835 | 9 deg | +0.000 | +5.143 | 2 | 64.2 | 5.6 | 5142.5 | 5142.53 | 5.6189 | 0.00837718 | 65.7609
2 x MULLION | Z/156 | 5 deg | +0.000 | +5.021 | 2 | 62.8 | 5.5 | 5020.7 | 5020.68 | 5.48584 | 0.00817869 | 64.2027
2 x MULLION | Z/137 | 3 deg | +0.000 | +4.960 | 2 | 62 | 5.3 | 4960.4 | 4960.37 | 5.41998 | 0.00808044 | 63.4315

# IfcBeam: C:350-30 (118)
In: Undefined
Description: C:350-30; Material: STEEL/G450
Tekla Common - Phase: 200
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.2 m2; Height: 350 mm; Width: 125 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Finish | Bottom elevation | Top elevation | Class | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
8 x RAFTER | Z/805 | 3 deg | +4.697 | +5.247 | 1 | 57.1 | 5 | 3820.7 | 3820.71 | 4.97845 | 0.00742746 | 58.3056
2 x MULLION | Z/2052 | 3 deg | +0.000 | +4.829 | 2 | 72.2 | 6.3 | 4828.6 | 4828.64 | 6.29078 | 0.00938688 | 73.687
8 x RAFTER | Z/806 | 5 deg | +4.673 | +5.355 | 1 | 57.1 | 5 | 3820.7 | 3820.71 | 4.97845 | 0.00742746 | 58.3056
2 x MULLION | Z/2053 | 5 deg | +0.000 | +4.909 | 2 | 73.4 | 6.3 | 4908.6 | 4908.61 | 6.3949 | 0.00954234 | 74.9074
8 x RAFTER | Z/807 | 9 deg | +4.623 | +5.567 | 1 | 57.1 | 5 | 3820.7 | 3820.71 | 4.97845 | 0.00742746 | 58.3056
2 x MULLION | Z/2054 | 9 deg | +0.000 | +5.070 | 2 | 75.8 | 6.6 | 5070.2 | 5070.23 | 6.60533 | 0.00985653 | 77.3737
7 x RAFTER | Z/719 | 12 deg | +4.585 | +5.722 | 1 | 57.1 | 5 | 3820.7 | 3820.71 | 4.97845 | 0.00742746 | 58.3056
2 x MULLION | Z/2101 | 12 deg | +0.000 | +5.194 | 2 | 77.7 | 6.8 | 5193.7 | 5193.73 | 6.76612 | 0.0100966 | 79.2584
7 x RAFTER | Z/808 | 15 deg | +4.547 | +5.874 | 1 | 57.1 | 5 | 3820.7 | 3820.71 | 4.97845 | 0.00742746 | 58.3056
2 x MULLION | Z/2105 | 15 deg | +0.000 | +5.320 | 2 | 79.6 | 6.8 | 5320 | 5320.01 | 6.93054 | 0.0103421 | 81.1855
8 x RAFTER | Z/809 | 18 deg | +4.507 | +6.021 | 1 | 57.1 | 5 | 3820.7 | 3820.71 | 4.97845 | 0.00742746 | 58.3056
2 x MULLION | Z/2106 | 18 deg | +0.000 | +5.450 | 2 | 81.5 | 7.1 | 5449.9 | 5449.89 | 7.09964 | 0.0105946 | 83.1675
2 x MULLION | Z/2107 | 25 deg | +0.000 | +5.772 | 2 | 86.3 | 7.5 | 5772.2 | 5772.21 | 7.51931 | 0.0112212 | 88.0862
2 x MULLION | Z/1551 | 25 deg | +0.000 | +5.827 | 2 | 87.1 | 7.6 | 5827 | 5827 | 7.59064 | 0.0113277 | 88.9224
2 x MULLION | Z/1550 | 18 deg | +0.000 | +5.500 | 2 | 82.2 | 7.1 | 5499.7 | 5499.67 | 7.16446 | 0.0106914 | 83.9272
2 x MULLION | Z/1549 | 15 deg | +0.000 | +5.368 | 2 | 80.3 | 7 | 5367.8 | 5367.77 | 6.99272 | 0.0104349 | 81.9143
2 x MULLION | Z/1548 | 12 deg | +0.000 | +5.240 | 2 | 78.4 | 6.8 | 5239.5 | 5239.53 | 6.82576 | 0.0101856 | 79.9573
2 x MULLION | Z/946 | 9 deg | +0.000 | +5.114 | 2 | 76.5 | 6.6 | 5114.1 | 5114.12 | 6.66247 | 0.00994185 | 78.0435
2 x MULLION | Z/945 | 5 deg | +0.000 | +4.950 | 2 | 74 | 6.3 | 4950 | 4949.98 | 6.44876 | 0.00962276 | 75.5387
2 x MULLION | Z/944 | 3 deg | +0.000 | +4.869 | 2 | 72.8 | 6.3 | 4868.8 | 4868.77 | 6.34303 | 0.00946489 | 74.2994
2 x MULLION | Z/910 | 3 deg | +0.000 | +4.905 | 2 | 73.4 | 6.3 | 4905.3 | 4905.3 | 6.39059 | 0.0095359 | 74.8568
2 x MULLION | Z/911 | 5 deg | +0.000 | +4.988 | 2 | 74.6 | 6.5 | 4987.7 | 4987.66 | 6.49782 | 0.00969601 | 76.1137
2 x MULLION | Z/912 | 9 deg | +0.000 | +5.154 | 2 | 77.1 | 6.6 | 5154.1 | 5154.1 | 6.71453 | 0.0100196 | 78.6536
2 x MULLION | Z/913 | 12 deg | +0.000 | +5.281 | 2 | 79 | 6.8 | 5281.3 | 5281.28 | 6.88011 | 0.0102668 | 80.5944
2 x MULLION | Z/914 | 15 deg | +0.000 | +5.411 | 2 | 80.9 | 7 | 5411.3 | 5411.32 | 7.04943 | 0.0105196 | 82.5789
2 x MULLION | Z/915 | 18 deg | +0.000 | +5.545 | 2 | 82.9 | 7.1 | 5545.1 | 5545.07 | 7.22357 | 0.0107796 | 84.62
2 x MULLION | Z/916 | 25 deg | +0.000 | +5.877 | 2 | 87.9 | 7.6 | 5877 | 5877.01 | 7.65576 | 0.0114249 | 89.6855
2 x MULLION | Z/882 | 15 deg | +0.000 | +5.933 | 2 | 88.7 | 7.6 | 5933 | 5932.99 | 7.72864 | 0.0115337 | 90.5398
2 x MULLION | Z/881 | 18 deg | +0.000 | +5.596 | 2 | 83.7 | 7.3 | 5596 | 5595.95 | 7.28981 | 0.0108785 | 85.3964
2 x MULLION | Z/880 | 15 deg | +0.000 | +5.460 | 2 | 81.7 | 7.1 | 5460.1 | 5460.14 | 7.11299 | 0.0106145 | 83.3239
2 x MULLION | Z/879 | 12 deg | +0.000 | +5.328 | 2 | 79.6 | 6.8 | 5328.1 | 5328.1 | 6.94107 | 0.0103578 | 81.3089
2 x MULLION | Z/878 | 9 deg | +0.000 | +5.199 | 2 | 77.8 | 6.8 | 5199.5 | 5199.46 | 6.77358 | 0.0101078 | 79.3458
2 x MULLION | Z/877 | 5 deg | +0.000 | +5.029 | 2 | 75.2 | 6.6 | 5029.5 | 5029.47 | 6.55226 | 0.00977729 | 76.7517
2 x MULLION | Z/876 | 3 deg | +0.000 | +4.945 | 2 | 74 | 6.3 | 4945.2 | 4945.22 | 6.44256 | 0.00961351 | 75.466
2 x MULLION | Z/852 | 15 deg | +0.000 | +5.989 | 2 | 89.6 | 7.8 | 5989.3 | 5989.26 | 7.8019 | 0.0116431 | 91.3985
2 x MULLION | Z/851 | 18 deg | +0.000 | +5.650 | 2 | 84.5 | 7.3 | 5649.6 | 5649.57 | 7.35963 | 0.0109828 | 86.2147
2 x MULLION | Z/850 | 15 deg | +0.000 | +5.513 | 2 | 82.4 | 7.1 | 5512.9 | 5512.94 | 7.18174 | 0.0107172 | 84.1297
2 x MULLION | Z/849 | 12 deg | +0.000 | +5.380 | 2 | 80.5 | 7 | 5380.2 | 5380.24 | 7.00896 | 0.0104592 | 82.1046
2 x MULLION | Z/848 | 9 deg | +0.000 | +5.251 | 2 | 78.4 | 6.8 | 5251.1 | 5251.1 | 6.84082 | 0.0102081 | 80.1339
2 x MULLION | Z/157 | 5 deg | +0.000 | +5.081 | 2 | 76 | 6.6 | 5080.7 | 5080.66 | 6.61891 | 0.0098768 | 77.5329
2 x MULLION | Z/138 | 3 deg | +0.000 | +4.996 | 2 | 74.6 | 6.5 | 4996.3 | 4996.29 | 6.50906 | 0.00971279 | 76.2454
RAFTER | Z/1553 | 15 deg | +4.547 | +5.874 | 1 | 57.1 | 5 | 3820.7 | 3820.71 | 4.97845 | 0.00742746 | 58.3056
RAFTER | Z/1552 | 12 deg | +4.585 | +5.722 | 1 | 57.1 | 5 | 3820.7 | 3820.71 | 4.97845 | 0.00742746 | 58.3056

# IfcColumn: C:150-24 (140)
In: Undefined
Description: C:150-24; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Phase: 200; Class: 2
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 111.2 m2; Height: 152 mm; Width: 64 mm
Pset_ColumnCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Finish | Top elevation | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
4 x MULLION | Z/2276 | 15 deg | +4.481 | 25 | 2.8 | 4480.8 | 4480.76 | 2.77775 | 0.00330573 | 25.9499
4 x MULLION | Z/2275 | 18 deg | +4.550 | 25.4 | 2.8 | 4550.5 | 4550.46 | 2.82094 | 0.00335715 | 26.3536
4 x MULLION | Z/2274 | 15 deg | +4.578 | 25.4 | 2.8 | 4577.9 | 4577.92 | 2.83795 | 0.00337741 | 26.5126
4 x MULLION | Z/2273 | 12 deg | +4.605 | 25.7 | 2.9 | 4605.1 | 4605.05 | 2.85476 | 0.00339742 | 26.6698
4 x MULLION | Z/2266 | 9 deg | +4.632 | 25.7 | 2.9 | 4631.6 | 4631.58 | 2.8712 | 0.00341699 | 26.8234
4 x MULLION | Z/2265 | 5 deg | +4.666 | 26 | 2.9 | 4666.3 | 4666.3 | 2.89271 | 0.00344261 | 27.0245
4 x MULLION | Z/2264 | 3 deg | +4.683 | 26.1 | 2.9 | 4683.5 | 4683.49 | 2.90337 | 0.00345529 | 27.124
4 x MULLION | Z/2263 | 15 deg | +4.536 | 25.3 | 2.8 | 4535.6 | 4535.55 | 2.8117 | 0.00334615 | 26.2673
4 x MULLION | Z/2262 | 18 deg | +4.600 | 25.6 | 2.9 | 4599.8 | 4599.79 | 2.85151 | 0.00339354 | 26.6393
4 x MULLION | Z/2261 | 15 deg | +4.626 | 25.7 | 2.9 | 4625.7 | 4625.68 | 2.86755 | 0.00341264 | 26.7892
4 x MULLION | Z/2260 | 12 deg | +4.651 | 26 | 2.9 | 4650.9 | 4650.85 | 2.88314 | 0.00343121 | 26.935
4 x MULLION | Z/2259 | 9 deg | +4.675 | 26.1 | 2.9 | 4675.5 | 4675.47 | 2.8984 | 0.00344937 | 27.0776
4 x MULLION | Z/2258 | 5 deg | +4.708 | 26.2 | 2.9 | 4707.7 | 4707.69 | 2.91836 | 0.00347315 | 27.2642
4 x MULLION | Z/2257 | 3 deg | +4.724 | 26.2 | 2.9 | 4723.6 | 4723.62 | 2.92823 | 0.0034849 | 27.3564
4 x MULLION | Z/2248 | 15 deg | +4.669 | 26 | 2.9 | 4669.2 | 4669.24 | 2.89454 | 0.00344478 | 27.0415
4 x MULLION | Z/2256 | 15 deg | +4.586 | 25.6 | 2.8 | 4585.6 | 4585.57 | 2.84269 | 0.00338305 | 26.5569
4 x MULLION | Z/2255 | 18 deg | +4.645 | 26 | 2.9 | 4645.2 | 4645.21 | 2.87965 | 0.00342705 | 26.9023
4 x MULLION | Z/2247 | 12 deg | +4.693 | 26.2 | 2.9 | 4692.6 | 4692.6 | 2.90901 | 0.00346201 | 27.1768
4 x MULLION | Z/2246 | 9 deg | +4.715 | 26.2 | 2.9 | 4715.5 | 4715.45 | 2.92317 | 0.00347887 | 27.3091
4 x MULLION | Z/2245 | 5 deg | +4.745 | 26.4 | 2.9 | 4745.4 | 4745.36 | 2.9417 | 0.00350094 | 27.4824
4 x MULLION | Z/2244 | 3 deg | +4.760 | 26.4 | 2.9 | 4760.2 | 4760.16 | 2.95087 | 0.00351186 | 27.5681
4 x MULLION | Z/2237 | 3 deg | +4.800 | 26.8 | 2.9 | 4800.1 | 4800.07 | 2.9756 | 0.0035413 | 27.7992
4 x MULLION | Z/2238 | 5 deg | +4.787 | 26.8 | 2.9 | 4787.2 | 4787.17 | 2.96761 | 0.00353178 | 27.7245
4 x MULLION | Z/2239 | 9 deg | +4.761 | 26.4 | 2.9 | 4760.8 | 4760.81 | 2.95127 | 0.00351234 | 27.5718
4 x MULLION | Z/2240 | 12 deg | +4.739 | 26.4 | 2.9 | 4739.4 | 4739.42 | 2.93802 | 0.00349655 | 27.448
4 x MULLION | Z/2241 | 15 deg | +4.718 | 26.2 | 2.9 | 4718.1 | 4718.05 | 2.92478 | 0.00348079 | 27.3242
4 x MULLION | Z/2242 | 18 deg | +4.696 | 26.2 | 2.9 | 4696.1 | 4696.08 | 2.91117 | 0.00346458 | 27.197
4 x MULLION | Z/2243 | 15 deg | +4.642 | 26 | 2.9 | 4641.5 | 4641.54 | 2.87737 | 0.00342434 | 26.8811
4 x MULLION | Z/2173 | 15 deg | +4.698 | 26.2 | 2.9 | 4697.8 | 4697.81 | 2.91224 | 0.00346586 | 27.207
4 x MULLION | Z/2172 | 18 deg | +4.750 | 26.4 | 2.9 | 4749.7 | 4749.69 | 2.94438 | 0.00350413 | 27.5074
4 x MULLION | Z/2171 | 15 deg | +4.771 | 26.6 | 2.9 | 4770.9 | 4770.85 | 2.95749 | 0.00351974 | 27.63
4 x MULLION | Z/2170 | 12 deg | +4.792 | 26.8 | 2.9 | 4791.6 | 4791.55 | 2.97032 | 0.00353501 | 27.7499
4 x MULLION | Z/2169 | 9 deg | +4.812 | 26.8 | 2.9 | 4812.5 | 4812.45 | 2.98327 | 0.00355043 | 27.8709
4 x MULLION | Z/2168 | 5 deg | +4.838 | 27 | 2.9 | 4838.4 | 4838.35 | 2.99932 | 0.00356954 | 28.0209
4 x MULLION | Z/2108 | 3 deg | +4.851 | 27 | 2.9 | 4851.1 | 4851.14 | 3.00724 | 0.00357898 | 28.095

# IfcColumn: C:200-24 (70)
In: Undefined
Description: C:200-24; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Phase: 200; Class: 2
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 110 m2; Height: 203 mm; Width: 76 mm
Pset_ColumnCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Finish | Top elevation | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x MULLION | Z/1554 | 3 deg | +4.720 | 33.5 | 3.7 | 4719.9 | 4719.86 | 3.68146 | 0.00438834 | 34.4484
2 x MULLION | Z/1555 | 5 deg | +4.727 | 33.5 | 3.7 | 4727 | 4727.03 | 3.68705 | 0.004395 | 34.5008
2 x MULLION | Z/1556 | 9 deg | +4.742 | 33.6 | 3.7 | 4741.5 | 4741.51 | 3.69834 | 0.00440847 | 34.6065
2 x MULLION | Z/1557 | 12 deg | +4.753 | 33.7 | 3.7 | 4752.6 | 4752.57 | 3.70696 | 0.00441875 | 34.6872
2 x MULLION | Z/1704 | 15 deg | +4.764 | 33.8 | 3.7 | 4763.9 | 4763.88 | 3.71578 | 0.00442927 | 34.7697
2 x MULLION | Z/1705 | 18 deg | +4.776 | 33.8 | 3.7 | 4775.5 | 4775.52 | 3.72485 | 0.00444009 | 34.8547
2 x MULLION | Z/1724 | 25 deg | +4.804 | 34.1 | 3.7 | 4804.4 | 4804.39 | 3.74736 | 0.00446693 | 35.0654
2 x MULLION | Z/924 | 25 deg | +4.859 | 34.4 | 3.8 | 4859.2 | 4859.17 | 3.79007 | 0.00451786 | 35.4652
2 x MULLION | Z/921 | 18 deg | +4.825 | 34.2 | 3.8 | 4825.3 | 4825.29 | 3.76366 | 0.00448636 | 35.2179
2 x MULLION | Z/920 | 15 deg | +4.812 | 34.1 | 3.8 | 4811.6 | 4811.64 | 3.75301 | 0.00447367 | 35.1183
2 x MULLION | Z/919 | 12 deg | +4.798 | 34 | 3.7 | 4798.4 | 4798.37 | 3.74267 | 0.00446133 | 35.0215
2 x MULLION | Z/918 | 9 deg | +4.785 | 33.8 | 3.7 | 4785.4 | 4785.39 | 3.73255 | 0.00444926 | 34.9267
2 x MULLION | Z/917 | 5 deg | +4.768 | 33.8 | 3.7 | 4768.4 | 4768.4 | 3.7193 | 0.00443347 | 34.8027
2 x MULLION | Z/139 | 3 deg | +4.760 | 33.7 | 3.7 | 4760 | 4760 | 3.71276 | 0.00442566 | 34.7414
2 x MULLION | Z/54 | 3 deg | +4.797 | 34 | 3.7 | 4796.5 | 4796.53 | 3.74123 | 0.00445962 | 35.008
2 x MULLION | Z/883 | 5 deg | +4.806 | 34.1 | 3.7 | 4806.1 | 4806.08 | 3.74868 | 0.0044685 | 35.0777
2 x MULLION | Z/884 | 9 deg | +4.825 | 34.2 | 3.8 | 4825.4 | 4825.37 | 3.76372 | 0.00448644 | 35.2185
2 x MULLION | Z/885 | 12 deg | +4.840 | 34.4 | 3.8 | 4840.1 | 4840.12 | 3.77522 | 0.00450015 | 35.3262
2 x MULLION | Z/886 | 15 deg | +4.855 | 34.4 | 3.8 | 4855.2 | 4855.19 | 3.78697 | 0.00451416 | 35.4362
2 x MULLION | Z/887 | 18 deg | +4.871 | 34.5 | 3.8 | 4870.7 | 4870.7 | 3.79906 | 0.00452858 | 35.5494
2 x MULLION | Z/888 | 25 deg | +4.909 | 34.8 | 3.8 | 4909.2 | 4909.18 | 3.82906 | 0.00456436 | 35.8302
2 x MULLION | Z/859 | 15 deg | +4.965 | 35.2 | 3.9 | 4965.2 | 4965.16 | 3.8727 | 0.00461641 | 36.2388
2 x MULLION | Z/858 | 18 deg | +4.922 | 34.8 | 3.8 | 4921.6 | 4921.57 | 3.83872 | 0.00457588 | 35.9207
2 x MULLION | Z/857 | 15 deg | +4.904 | 34.8 | 3.8 | 4904 | 4904.01 | 3.82503 | 0.00455955 | 35.7925
2 x MULLION | Z/856 | 12 deg | +4.887 | 34.6 | 3.8 | 4886.9 | 4886.93 | 3.81171 | 0.00454367 | 35.6678
2 x MULLION | Z/855 | 9 deg | +4.871 | 34.5 | 3.8 | 4870.7 | 4870.73 | 3.79908 | 0.00452861 | 35.5496
2 x MULLION | Z/854 | 5 deg | +4.848 | 34.4 | 3.8 | 4847.9 | 4847.88 | 3.78127 | 0.00450737 | 35.3828
2 x MULLION | Z/853 | 3 deg | +4.836 | 34.4 | 3.8 | 4836.5 | 4836.45 | 3.77236 | 0.00449674 | 35.2994
2 x MULLION | Z/199 | 15 deg | +5.021 | 35.6 | 3.9 | 5021.4 | 5021.43 | 3.91657 | 0.00466872 | 36.6495
2 x MULLION | Z/196 | 18 deg | +4.975 | 35.3 | 3.9 | 4975.2 | 4975.19 | 3.88052 | 0.00462573 | 36.312
2 x MULLION | Z/179 | 15 deg | +4.957 | 35.1 | 3.9 | 4956.8 | 4956.81 | 3.86619 | 0.00460864 | 36.1779
2 x MULLION | Z/178 | 12 deg | +4.939 | 35 | 3.9 | 4939.1 | 4939.07 | 3.85236 | 0.00459215 | 36.0484
2 x MULLION | Z/176 | 9 deg | +4.922 | 34.8 | 3.8 | 4922.4 | 4922.37 | 3.83934 | 0.00457662 | 35.9265
2 x MULLION | Z/141 | 5 deg | +4.899 | 34.7 | 3.8 | 4899.1 | 4899.07 | 3.82117 | 0.00455496 | 35.7564
2 x MULLION | Z/56 | 3 deg | +4.888 | 34.6 | 3.8 | 4887.5 | 4887.52 | 3.81217 | 0.00454422 | 35.6721

# IfcColumn: C:250-24 (70)
In: Undefined
Description: C:250-24; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Phase: 200; Class: 2
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 109.7 m2; Height: 254 mm; Width: 76 mm
Pset_ColumnCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Finish | Top elevation | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x MULLION | Z/1725 | 3 deg | +4.757 | 38.2 | 4.2 | 4756.6 | 4756.55 | 4.18596 | 0.00499324 | 39.1969
2 x MULLION | Z/1741 | 5 deg | +4.788 | 38.4 | 4.2 | 4788.3 | 4788.27 | 4.21386 | 0.00502653 | 39.4583
2 x MULLION | Z/1742 | 9 deg | +4.852 | 38.9 | 4.2 | 4852.4 | 4852.38 | 4.27025 | 0.00509383 | 39.9866
2 x MULLION | Z/1758 | 12 deg | +4.901 | 39.3 | 4.2 | 4901.4 | 4901.36 | 4.31334 | 0.00514525 | 40.3902
2 x MULLION | Z/1759 | 15 deg | +4.951 | 39.7 | 4.4 | 4951.5 | 4951.45 | 4.35739 | 0.00519783 | 40.803
2 x MULLION | Z/1796 | 18 deg | +5.003 | 40.1 | 4.4 | 5003 | 5002.96 | 4.4027 | 0.00525191 | 41.2275
2 x MULLION | Z/1876 | 25 deg | +5.131 | 41.2 | 4.4 | 5130.8 | 5130.81 | 4.51516 | 0.00538612 | 42.281
2 x MULLION | Z/936 | 25 deg | +5.186 | 41.6 | 4.6 | 5185.6 | 5185.59 | 4.56334 | 0.00544363 | 42.7325
2 x MULLION | Z/935 | 18 deg | +5.053 | 40.5 | 4.4 | 5052.7 | 5052.74 | 4.44649 | 0.00530416 | 41.6377
2 x MULLION | Z/934 | 15 deg | +4.999 | 40.1 | 4.4 | 4999.2 | 4999.21 | 4.3994 | 0.00524797 | 41.1966
2 x MULLION | Z/933 | 12 deg | +4.947 | 39.7 | 4.4 | 4947.2 | 4947.16 | 4.35362 | 0.00519333 | 40.7676
2 x MULLION | Z/929 | 9 deg | +4.896 | 39.3 | 4.2 | 4896.3 | 4896.26 | 4.30885 | 0.0051399 | 40.3482
2 x MULLION | Z/926 | 5 deg | +4.830 | 38.7 | 4.2 | 4829.6 | 4829.64 | 4.25025 | 0.00506996 | 39.7992
2 x MULLION | Z/925 | 3 deg | +4.797 | 38.4 | 4.2 | 4796.7 | 4796.68 | 4.22126 | 0.00503536 | 39.5276
2 x MULLION | Z/889 | 3 deg | +4.833 | 38.8 | 4.2 | 4833.2 | 4833.21 | 4.25339 | 0.00507371 | 39.8286
2 x MULLION | Z/890 | 5 deg | +4.867 | 38.9 | 4.2 | 4867.3 | 4867.32 | 4.28339 | 0.00510952 | 40.1097
2 x MULLION | Z/891 | 9 deg | +4.936 | 39.6 | 4.2 | 4936.2 | 4936.24 | 4.34402 | 0.00518187 | 40.6777
2 x MULLION | Z/892 | 12 deg | +4.989 | 40 | 4.4 | 4988.9 | 4988.91 | 4.39034 | 0.00523716 | 41.1117
2 x MULLION | Z/895 | 15 deg | +5.043 | 40.5 | 4.4 | 5042.8 | 5042.75 | 4.4377 | 0.00529368 | 41.5554
2 x MULLION | Z/896 | 18 deg | +5.098 | 40.9 | 4.4 | 5098.1 | 5098.14 | 4.48642 | 0.00535182 | 42.0118
2 x MULLION | Z/898 | 25 deg | +5.236 | 42 | 4.6 | 5235.6 | 5235.6 | 4.60733 | 0.00549612 | 43.1446
2 x MULLION | Z/868 | 15 deg | +5.292 | 42.5 | 4.6 | 5291.6 | 5291.58 | 4.65657 | 0.00555489 | 43.6059
2 x MULLION | Z/867 | 18 deg | +5.149 | 41.3 | 4.4 | 5149 | 5149.02 | 4.53118 | 0.00540524 | 42.4311
2 x MULLION | Z/864 | 15 deg | +5.092 | 40.8 | 4.4 | 5091.6 | 5091.58 | 4.48065 | 0.00534494 | 41.9578
2 x MULLION | Z/863 | 12 deg | +5.036 | 40.5 | 4.4 | 5035.7 | 5035.72 | 4.43152 | 0.0052863 | 41.4974
2 x MULLION | Z/862 | 9 deg | +4.982 | 40 | 4.4 | 4981.6 | 4981.6 | 4.38391 | 0.00522948 | 41.0515
2 x MULLION | Z/861 | 5 deg | +4.909 | 39.4 | 4.2 | 4909.2 | 4909.12 | 4.32016 | 0.0051534 | 40.4542
2 x MULLION | Z/860 | 3 deg | +4.873 | 39.1 | 4.2 | 4873.1 | 4873.13 | 4.2885 | 0.00511562 | 40.1576
2 x MULLION | Z/312 | 15 deg | +5.348 | 42.9 | 4.6 | 5347.9 | 5347.85 | 4.70607 | 0.00561396 | 44.0696
2 x MULLION | Z/311 | 18 deg | +5.203 | 41.7 | 4.6 | 5202.6 | 5202.64 | 4.57834 | 0.00546152 | 42.873
2 x MULLION | Z/279 | 15 deg | +5.144 | 41.3 | 4.4 | 5144.4 | 5144.38 | 4.5271 | 0.00540036 | 42.3929
2 x MULLION | Z/278 | 12 deg | +5.088 | 40.8 | 4.4 | 5087.9 | 5087.86 | 4.47738 | 0.00534103 | 41.9271
2 x MULLION | Z/270 | 9 deg | +5.033 | 40.5 | 4.4 | 5033.2 | 5033.24 | 4.42934 | 0.00528369 | 41.477
2 x MULLION | Z/155 | 5 deg | +4.960 | 39.8 | 4.4 | 4960.3 | 4960.31 | 4.36519 | 0.00520714 | 40.876
2 x MULLION | Z/136 | 3 deg | +4.924 | 39.4 | 4.2 | 4924.2 | 4924.2 | 4.33343 | 0.00516923 | 40.5784

# IfcColumn: C:300-30 (70)
In: Undefined
Description: C:300-30; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Phase: 200; Class: 2
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.4 m2; Height: 300 mm; Width: 96 mm
Pset_ColumnCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Finish | Top elevation | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x MULLION | Z/2021 | 3 deg | +4.793 | 59.9 | 5.2 | 4792.7 | 4792.71 | 5.2369 | 0.00780732 | 61.2875
2 x MULLION | Z/2022 | 5 deg | +4.849 | 60.6 | 5.3 | 4848.6 | 4848.64 | 5.29797 | 0.00789843 | 62.0027
2 x MULLION | Z/2023 | 9 deg | +4.962 | 62 | 5.3 | 4961.7 | 4961.66 | 5.42139 | 0.00808254 | 63.448
2 x MULLION | Z/2048 | 12 deg | +5.048 | 63.1 | 5.5 | 5048 | 5048.02 | 5.5157 | 0.00822322 | 64.5523
2 x MULLION | Z/2049 | 15 deg | +5.136 | 64.2 | 5.6 | 5136.3 | 5136.33 | 5.61213 | 0.00836708 | 65.6816
2 x MULLION | Z/2050 | 18 deg | +5.227 | 65.4 | 5.6 | 5227.2 | 5227.15 | 5.71131 | 0.00851503 | 66.843
2 x MULLION | Z/2051 | 25 deg | +5.453 | 68.2 | 6 | 5452.6 | 5452.56 | 5.95745 | 0.00888222 | 69.7254
2 x MULLION | Z/943 | 25 deg | +5.507 | 68.9 | 6 | 5507.3 | 5507.34 | 6.01727 | 0.00897146 | 70.4259
2 x MULLION | Z/942 | 18 deg | +5.277 | 66 | 5.8 | 5276.9 | 5276.93 | 5.76567 | 0.00859612 | 67.4795
2 x MULLION | Z/941 | 15 deg | +5.184 | 64.8 | 5.6 | 5184.1 | 5184.09 | 5.66428 | 0.00844488 | 66.2923
2 x MULLION | Z/940 | 12 deg | +5.094 | 63.7 | 5.6 | 5093.8 | 5093.82 | 5.56571 | 0.00829783 | 65.138
2 x MULLION | Z/939 | 9 deg | +5.006 | 62.6 | 5.5 | 5005.5 | 5005.54 | 5.46931 | 0.00815402 | 64.0091
2 x MULLION | Z/938 | 5 deg | +4.890 | 61.1 | 5.3 | 4890 | 4890.01 | 5.34315 | 0.00796583 | 62.5317
2 x MULLION | Z/937 | 3 deg | +4.833 | 60.4 | 5.3 | 4832.8 | 4832.84 | 5.28072 | 0.0078727 | 61.8007
2 x MULLION | Z/901 | 3 deg | +4.869 | 60.9 | 5.3 | 4869.4 | 4869.38 | 5.32062 | 0.00793222 | 62.2679
2 x MULLION | Z/904 | 5 deg | +4.928 | 61.6 | 5.3 | 4927.7 | 4927.69 | 5.3843 | 0.00802721 | 63.0136
2 x MULLION | Z/905 | 9 deg | +5.046 | 63.1 | 5.5 | 5045.5 | 5045.53 | 5.51298 | 0.00821917 | 64.5205
2 x MULLION | Z/906 | 12 deg | +5.136 | 64.2 | 5.6 | 5135.6 | 5135.57 | 5.6113 | 0.00836584 | 65.6719
2 x MULLION | Z/907 | 15 deg | +5.228 | 65.4 | 5.6 | 5227.6 | 5227.64 | 5.71184 | 0.00851583 | 66.8492
2 x MULLION | Z/908 | 18 deg | +5.322 | 66.6 | 5.8 | 5322.3 | 5322.34 | 5.81525 | 0.00867009 | 68.0602
2 x MULLION | Z/909 | 25 deg | +5.557 | 69.5 | 6.1 | 5557.4 | 5557.35 | 6.07188 | 0.00905292 | 71.0654
2 x MULLION | Z/875 | 15 deg | +5.613 | 70.2 | 6.1 | 5613.3 | 5613.33 | 6.13301 | 0.00914411 | 71.7813
2 x MULLION | Z/874 | 18 deg | +5.373 | 67.2 | 5.8 | 5373.2 | 5373.21 | 5.8708 | 0.00875296 | 68.7107
2 x MULLION | Z/873 | 15 deg | +5.276 | 66 | 5.8 | 5276.5 | 5276.46 | 5.76515 | 0.00859535 | 67.4735
2 x MULLION | Z/872 | 12 deg | +5.182 | 64.8 | 5.6 | 5182.4 | 5182.39 | 5.66243 | 0.00844211 | 66.2706
2 x MULLION | Z/871 | 9 deg | +5.091 | 63.7 | 5.6 | 5090.9 | 5090.89 | 5.56251 | 0.00829306 | 65.1005
2 x MULLION | Z/870 | 5 deg | +4.969 | 62.1 | 5.3 | 4969.5 | 4969.49 | 5.42994 | 0.0080953 | 63.5481
2 x MULLION | Z/869 | 3 deg | +4.909 | 61.4 | 5.3 | 4909.3 | 4909.3 | 5.36421 | 0.00799725 | 62.7784
2 x MULLION | Z/847 | 15 deg | +5.670 | 70.9 | 6.1 | 5669.6 | 5669.6 | 6.19446 | 0.00923578 | 72.5009
2 x MULLION | Z/838 | 18 deg | +5.427 | 67.9 | 5.8 | 5426.8 | 5426.83 | 5.92936 | 0.00884031 | 69.3964
2 x MULLION | Z/837 | 15 deg | +5.329 | 66.6 | 5.8 | 5329.3 | 5329.26 | 5.82281 | 0.00868136 | 68.1487
2 x MULLION | Z/836 | 12 deg | +5.235 | 65.4 | 5.6 | 5234.5 | 5234.53 | 5.71936 | 0.00852705 | 66.9373
2 x MULLION | Z/835 | 9 deg | +5.143 | 64.2 | 5.6 | 5142.5 | 5142.53 | 5.6189 | 0.00837718 | 65.7609
2 x MULLION | Z/156 | 5 deg | +5.021 | 62.8 | 5.5 | 5020.7 | 5020.68 | 5.48584 | 0.00817869 | 64.2027
2 x MULLION | Z/137 | 3 deg | +4.960 | 62 | 5.3 | 4960.4 | 4960.37 | 5.41998 | 0.00808044 | 63.4315

# IfcColumn: C:350-30 (70)
In: Undefined
Description: C:350-30; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Phase: 200; Class: 2
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.2 m2; Height: 350 mm; Width: 125 mm
Pset_ColumnCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Finish | Top elevation | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x MULLION | Z/2052 | 3 deg | +4.829 | 72.2 | 6.3 | 4828.6 | 4828.64 | 6.29078 | 0.00938688 | 73.687
2 x MULLION | Z/2053 | 5 deg | +4.909 | 73.4 | 6.3 | 4908.6 | 4908.61 | 6.3949 | 0.00954234 | 74.9074
2 x MULLION | Z/2054 | 9 deg | +5.070 | 75.8 | 6.6 | 5070.2 | 5070.23 | 6.60533 | 0.00985653 | 77.3737
2 x MULLION | Z/2101 | 12 deg | +5.194 | 77.7 | 6.8 | 5193.7 | 5193.73 | 6.76612 | 0.0100966 | 79.2584
2 x MULLION | Z/2105 | 15 deg | +5.320 | 79.6 | 6.8 | 5320 | 5320.01 | 6.93054 | 0.0103421 | 81.1855
2 x MULLION | Z/2106 | 18 deg | +5.450 | 81.5 | 7.1 | 5449.9 | 5449.89 | 7.09964 | 0.0105946 | 83.1675
2 x MULLION | Z/2107 | 25 deg | +5.772 | 86.3 | 7.5 | 5772.2 | 5772.21 | 7.51931 | 0.0112212 | 88.0862
2 x MULLION | Z/1551 | 25 deg | +5.827 | 87.1 | 7.6 | 5827 | 5827 | 7.59064 | 0.0113277 | 88.9224
2 x MULLION | Z/1550 | 18 deg | +5.500 | 82.2 | 7.1 | 5499.7 | 5499.67 | 7.16446 | 0.0106914 | 83.9272
2 x MULLION | Z/1549 | 15 deg | +5.368 | 80.3 | 7 | 5367.8 | 5367.77 | 6.99272 | 0.0104349 | 81.9143
2 x MULLION | Z/1548 | 12 deg | +5.240 | 78.4 | 6.8 | 5239.5 | 5239.53 | 6.82576 | 0.0101856 | 79.9573
2 x MULLION | Z/946 | 9 deg | +5.114 | 76.5 | 6.6 | 5114.1 | 5114.12 | 6.66247 | 0.00994185 | 78.0435
2 x MULLION | Z/945 | 5 deg | +4.950 | 74 | 6.3 | 4950 | 4949.98 | 6.44876 | 0.00962276 | 75.5387
2 x MULLION | Z/944 | 3 deg | +4.869 | 72.8 | 6.3 | 4868.8 | 4868.77 | 6.34303 | 0.00946489 | 74.2994
2 x MULLION | Z/910 | 3 deg | +4.905 | 73.4 | 6.3 | 4905.3 | 4905.3 | 6.39059 | 0.0095359 | 74.8568
2 x MULLION | Z/911 | 5 deg | +4.988 | 74.6 | 6.5 | 4987.7 | 4987.66 | 6.49782 | 0.00969601 | 76.1137
2 x MULLION | Z/912 | 9 deg | +5.154 | 77.1 | 6.6 | 5154.1 | 5154.1 | 6.71453 | 0.0100196 | 78.6536
2 x MULLION | Z/913 | 12 deg | +5.281 | 79 | 6.8 | 5281.3 | 5281.28 | 6.88011 | 0.0102668 | 80.5944
2 x MULLION | Z/914 | 15 deg | +5.411 | 80.9 | 7 | 5411.3 | 5411.32 | 7.04943 | 0.0105196 | 82.5789
2 x MULLION | Z/915 | 18 deg | +5.545 | 82.9 | 7.1 | 5545.1 | 5545.07 | 7.22357 | 0.0107796 | 84.62
2 x MULLION | Z/916 | 25 deg | +5.877 | 87.9 | 7.6 | 5877 | 5877.01 | 7.65576 | 0.0114249 | 89.6855
2 x MULLION | Z/882 | 15 deg | +5.933 | 88.7 | 7.6 | 5933 | 5932.99 | 7.72864 | 0.0115337 | 90.5398
2 x MULLION | Z/881 | 18 deg | +5.596 | 83.7 | 7.3 | 5596 | 5595.95 | 7.28981 | 0.0108785 | 85.3964
2 x MULLION | Z/880 | 15 deg | +5.460 | 81.7 | 7.1 | 5460.1 | 5460.14 | 7.11299 | 0.0106145 | 83.3239
2 x MULLION | Z/879 | 12 deg | +5.328 | 79.6 | 6.8 | 5328.1 | 5328.1 | 6.94107 | 0.0103578 | 81.3089
2 x MULLION | Z/878 | 9 deg | +5.199 | 77.8 | 6.8 | 5199.5 | 5199.46 | 6.77358 | 0.0101078 | 79.3458
2 x MULLION | Z/877 | 5 deg | +5.029 | 75.2 | 6.6 | 5029.5 | 5029.47 | 6.55226 | 0.00977729 | 76.7517
2 x MULLION | Z/876 | 3 deg | +4.945 | 74 | 6.3 | 4945.2 | 4945.22 | 6.44256 | 0.00961351 | 75.466
2 x MULLION | Z/852 | 15 deg | +5.989 | 89.6 | 7.8 | 5989.3 | 5989.26 | 7.8019 | 0.0116431 | 91.3985
2 x MULLION | Z/851 | 18 deg | +5.650 | 84.5 | 7.3 | 5649.6 | 5649.57 | 7.35963 | 0.0109828 | 86.2147
2 x MULLION | Z/850 | 15 deg | +5.513 | 82.4 | 7.1 | 5512.9 | 5512.94 | 7.18174 | 0.0107172 | 84.1297
2 x MULLION | Z/849 | 12 deg | +5.380 | 80.5 | 7 | 5380.2 | 5380.24 | 7.00896 | 0.0104592 | 82.1046
2 x MULLION | Z/848 | 9 deg | +5.251 | 78.4 | 6.8 | 5251.1 | 5251.1 | 6.84082 | 0.0102081 | 80.1339
2 x MULLION | Z/157 | 5 deg | +5.081 | 76 | 6.6 | 5080.7 | 5080.66 | 6.61891 | 0.0098768 | 77.5329
2 x MULLION | Z/138 | 3 deg | +4.996 | 74.6 | 6.5 | 4996.3 | 4996.29 | 6.50906 | 0.00971279 | 76.2454

# IfcElementAssembly (1680)
In: Undefined
PredefinedType: RIGID_FRAME
Name | ASSEMBLY_POSITION_CODE = Assembly/Cast unit position code | ASSEMBLY_POS = Assembly/Cast unit Mark | Assembly/Cast unit weight (kg) | Assembly/Cast unit bottom elevation | Assembly/Cast unit top elevation | Width (mm)
2 x MULLION TOP PLATE | C350SD/25deg | PL/1563 | 0.7 | +4.391 | +4.501 | 104.231
2 x MULLION | C350SD/25deg-25deg | Z/2276 | 25 | +0.000 | +4.481 | 64
2 x MULLION TOP PLATE | C350SD>/25deg | PL/1563 | 0.7 | +4.391 | +4.501 | 104.231
2 x MULLION | C350SD>/25deg-25deg | Z/2276 | 25 | +0.000 | +4.481 | 64
2 x MULLION TOP PLATE | C350SD/18deg | PL/1562 | 0.7 | +4.460 | +4.572 | 109.379
2 x MULLION | C350SD/18deg-18deg | Z/2275 | 25.4 | +0.000 | +4.550 | 64
2 x MULLION TOP PLATE | C350SD>/18deg | PL/1562 | 0.7 | +4.460 | +4.572 | 109.379
2 x MULLION | C350SD>/18deg-18deg | Z/2275 | 25.4 | +0.000 | +4.550 | 64
2 x MULLION TOP PLATE | C350SD/15deg | PL/1561 | 0.7 | +4.488 | +4.600 | 111.086
2 x MULLION | C350SD/15deg-15deg | Z/2274 | 25.4 | +0.000 | +4.578 | 64
2 x MULLION TOP PLATE | C350SD>/15deg | PL/1561 | 0.7 | +4.488 | +4.600 | 111.086
2 x MULLION | C350SD>/15deg-15deg | Z/2274 | 25.4 | +0.000 | +4.578 | 64
2 x MULLION TOP PLATE | C350SD/12deg | PL/1560 | 0.7 | +4.515 | +4.628 | 112.495
2 x MULLION | C350SD/12deg-12deg | Z/2273 | 25.7 | +0.000 | +4.605 | 64
2 x MULLION TOP PLATE | C350SD>/12deg | PL/1560 | 0.7 | +4.515 | +4.628 | 112.495
2 x MULLION | C350SD>/12deg-12deg | Z/2273 | 25.7 | +0.000 | +4.605 | 64
2 x MULLION TOP PLATE | C350SD/9deg | PL/1559 | 0.7 | +4.542 | +4.655 | 113.591
2 x MULLION | C350SD/9deg-9deg | Z/2266 | 25.7 | +0.000 | +4.632 | 64
2 x MULLION TOP PLATE | C350SD>/9deg | PL/1559 | 0.7 | +4.542 | +4.655 | 113.591
2 x MULLION | C350SD>/9deg-9deg | Z/2266 | 25.7 | +0.000 | +4.632 | 64
2 x MULLION TOP PLATE | C350SD/5deg | PL/1558 | 0.7 | +4.576 | +4.691 | 114.566
2 x MULLION | C350SD/5deg-5deg | Z/2265 | 26 | +0.000 | +4.666 | 64
2 x MULLION TOP PLATE | C350SD>/5deg | PL/1558 | 0.7 | +4.576 | +4.691 | 114.566
2 x MULLION | C350SD>/5deg-5deg | Z/2265 | 26 | +0.000 | +4.666 | 64
2 x MULLION TOP PLATE | C350SD/3deg | PL/1557 | 0.7 | +4.593 | +4.708 | 114.844
2 x MULLION | C350SD/3deg-3deg | Z/2264 | 26.1 | +0.000 | +4.683 | 64
2 x MULLION TOP PLATE | C350SD>/3deg | PL/1557 | 0.7 | +4.593 | +4.708 | 114.844
2 x MULLION | C350SD>/3deg-3deg | Z/2264 | 26.1 | +0.000 | +4.683 | 64
2 x MULLION TOP PLATE | C300SD/25deg | PL/1556 | 0.7 | +4.446 | +4.556 | 104.231
2 x MULLION | C300SD/25deg-25deg | Z/2263 | 25.3 | +0.000 | +4.536 | 64
2 x MULLION TOP PLATE | C300SD-C350SD/25deg | PL/1556 | 0.7 | +4.446 | +4.556 | 104.231
2 x MULLION | C300SD-C350SD/25deg-25deg | Z/2263 | 25.3 | +0.000 | +4.536 | 64
2 x MULLION TOP PLATE | C300SD/18deg | PL/1555 | 0.7 | +4.510 | +4.622 | 109.379
2 x MULLION | C300SD/18deg-18deg | Z/2262 | 25.6 | +0.000 | +4.600 | 64
2 x MULLION TOP PLATE | C300SD-C350SD/18deg | PL/1555 | 0.7 | +4.510 | +4.622 | 109.379
2 x MULLION | C300SD-C350SD/18deg-18deg | Z/2262 | 25.6 | +0.000 | +4.600 | 64
2 x MULLION TOP PLATE | C300SD/15deg | PL/1554 | 0.7 | +4.536 | +4.648 | 111.086
2 x MULLION | C300SD/15deg-15deg | Z/2261 | 25.7 | +0.000 | +4.626 | 64
2 x MULLION TOP PLATE | C300SD-C350SD/15deg | PL/1554 | 0.7 | +4.536 | +4.648 | 111.086
2 x MULLION | C300SD-C350SD/15deg-15deg | Z/2261 | 25.7 | +0.000 | +4.626 | 64
2 x MULLION TOP PLATE | C300SD/12deg | PL/1553 | 0.7 | +4.561 | +4.674 | 112.495
2 x MULLION | C300SD/12deg-12deg | Z/2260 | 26 | +0.000 | +4.651 | 64
2 x MULLION TOP PLATE | C300SD-C350SD/12deg | PL/1553 | 0.7 | +4.561 | +4.674 | 112.495
2 x MULLION | C300SD-C350SD/12deg-12deg | Z/2260 | 26 | +0.000 | +4.651 | 64
2 x MULLION TOP PLATE | C300SD/9deg | PL/1552 | 0.7 | +4.585 | +4.699 | 113.591
2 x MULLION | C300SD/9deg-9deg | Z/2259 | 26.1 | +0.000 | +4.675 | 64
2 x MULLION TOP PLATE | C300SD-C350SD/9deg | PL/1552 | 0.7 | +4.585 | +4.699 | 113.591
2 x MULLION | C300SD-C350SD/9deg-9deg | Z/2259 | 26.1 | +0.000 | +4.675 | 64
2 x MULLION TOP PLATE | C300SD/5deg | PL/1551 | 0.7 | +4.618 | +4.732 | 114.566
2 x MULLION | C300SD/5deg-5deg | Z/2258 | 26.2 | +0.000 | +4.708 | 64
2 x MULLION TOP PLATE | C300SD-C350SD/5deg | PL/1551 | 0.7 | +4.618 | +4.732 | 114.566
2 x MULLION | C300SD-C350SD/5deg-5deg | Z/2258 | 26.2 | +0.000 | +4.708 | 64
2 x MULLION TOP PLATE | C300SD/3deg | PL/1550 | 0.7 | +4.634 | +4.748 | 114.844
2 x MULLION | C300SD/3deg-3deg | Z/2257 | 26.2 | +0.000 | +4.724 | 64
2 x MULLION TOP PLATE | C300SD-C350SD/3deg | PL/1550 | 0.7 | +4.634 | +4.748 | 114.844
2 x MULLION | C300SD-C350SD/3deg-3deg | Z/2257 | 26.2 | +0.000 | +4.724 | 64
2 x MULLION TOP PLATE | C250SD/15deg | PL/1463 | 0.7 | +4.579 | +4.692 | 111.086
2 x MULLION | C250SD/15deg-15deg | Z/2248 | 26 | +0.000 | +4.669 | 64
2 x MULLION TOP PLATE | C250SD-C300SD/15deg | PL/1463 | 0.7 | +4.579 | +4.692 | 111.086
2 x MULLION | C250SD-C300SD/15deg-15deg | Z/2248 | 26 | +0.000 | +4.669 | 64
2 x MULLION TOP PLATE | C250SD/25deg | PL/1465 | 0.7 | +4.496 | +4.606 | 104.231
2 x MULLION | C250SD/25deg-25deg | Z/2256 | 25.6 | +0.000 | +4.586 | 64
2 x MULLION TOP PLATE | C250SD-C300SD/25deg | PL/1465 | 0.7 | +4.496 | +4.606 | 104.231
2 x MULLION | C250SD-C300SD/25deg-25deg | Z/2256 | 25.6 | +0.000 | +4.586 | 64
2 x MULLION TOP PLATE | C250SD/18deg | PL/1464 | 0.7 | +4.555 | +4.667 | 109.379
2 x MULLION | C250SD/18deg-18deg | Z/2255 | 26 | +0.000 | +4.645 | 64
2 x MULLION TOP PLATE | C250SD-C300SD/18deg | PL/1464 | 0.7 | +4.555 | +4.667 | 109.379
2 x MULLION | C250SD-C300SD/18deg-18deg | Z/2255 | 26 | +0.000 | +4.645 | 64
2 x MULLION TOP PLATE | C250SD/12deg | PL/1462 | 0.7 | +4.603 | +4.716 | 112.495
2 x MULLION | C250SD/12deg-12deg | Z/2247 | 26.2 | +0.000 | +4.693 | 64
2 x MULLION TOP PLATE | C250SD-C300SD/12deg | PL/1462 | 0.7 | +4.603 | +4.716 | 112.495
2 x MULLION | C250SD-C300SD/12deg-12deg | Z/2247 | 26.2 | +0.000 | +4.693 | 64
2 x MULLION TOP PLATE | C250SD/9deg | PL/1461 | 0.7 | +4.625 | +4.739 | 113.591
2 x MULLION | C250SD/9deg-9deg | Z/2246 | 26.2 | +0.000 | +4.715 | 64
2 x MULLION TOP PLATE | C250SD-C300SD/9deg | PL/1461 | 0.7 | +4.625 | +4.739 | 113.591
2 x MULLION | C250SD-C300SD/9deg-9deg | Z/2246 | 26.2 | +0.000 | +4.715 | 64
2 x MULLION TOP PLATE | C250SD/5deg | PL/1460 | 0.7 | +4.655 | +4.770 | 114.566
2 x MULLION | C250SD/5deg-5deg | Z/2245 | 26.4 | +0.000 | +4.745 | 64
2 x MULLION TOP PLATE | C250SD-C300SD/5deg | PL/1460 | 0.7 | +4.655 | +4.770 | 114.566
2 x MULLION | C250SD-C300SD/5deg-5deg | Z/2245 | 26.4 | +0.000 | +4.745 | 64
2 x MULLION TOP PLATE | C250SD/3deg | PL/1459 | 0.7 | +4.670 | +4.785 | 114.844
2 x MULLION | C250SD/3deg-3deg | Z/2244 | 26.4 | +0.000 | +4.760 | 64
2 x MULLION TOP PLATE | C250SD-C300SD/3deg | PL/1459 | 0.7 | +4.670 | +4.785 | 114.844
2 x MULLION | C250SD-C300SD/3deg-3deg | Z/2244 | 26.4 | +0.000 | +4.760 | 64
2 x MULLION TOP PLATE | C200SD/3deg | PL/1459 | 0.7 | +4.710 | +4.825 | 114.844
2 x MULLION TOP PLATE | C200SD-C250SD/3deg | PL/1459 | 0.7 | +4.710 | +4.825 | 114.844
2 x MULLION | C200SD/3deg-3deg | Z/2237 | 26.8 | +0.000 | +4.800 | 64
2 x MULLION | C200SD-C250SD/3deg-3deg | Z/2237 | 26.8 | +0.000 | +4.800 | 64
2 x MULLION TOP PLATE | C200SD/5deg | PL/1460 | 0.7 | +4.697 | +4.811 | 114.566
2 x MULLION | C200SD/5deg-5deg | Z/2238 | 26.8 | +0.000 | +4.787 | 64
2 x MULLION TOP PLATE | C200SD-C250SD/5deg | PL/1460 | 0.7 | +4.697 | +4.811 | 114.566
2 x MULLION | C200SD-C250SD/5deg-5deg | Z/2238 | 26.8 | +0.000 | +4.787 | 64
2 x MULLION TOP PLATE | C200SD/9deg | PL/1461 | 0.7 | +4.671 | +4.784 | 113.591
2 x MULLION | C200SD/9deg-9deg | Z/2239 | 26.4 | +0.000 | +4.761 | 64
2 x MULLION TOP PLATE | C200SD-C250SD/9deg | PL/1461 | 0.7 | +4.671 | +4.784 | 113.591
2 x MULLION | C200SD-C250SD/9deg-9deg | Z/2239 | 26.4 | +0.000 | +4.761 | 64
2 x MULLION TOP PLATE | C200SD/12deg | PL/1462 | 0.7 | +4.649 | +4.762 | 112.495
2 x MULLION | C200SD/12deg-12deg | Z/2240 | 26.4 | +0.000 | +4.739 | 64
2 x MULLION TOP PLATE | C200SD-C250SD/12deg | PL/1462 | 0.7 | +4.649 | +4.762 | 112.495
2 x MULLION | C200SD-C250SD/12deg-12deg | Z/2240 | 26.4 | +0.000 | +4.739 | 64
2 x MULLION TOP PLATE | C200SD/15deg | PL/1463 | 0.7 | +4.628 | +4.741 | 111.086
2 x MULLION | C200SD/15deg-15deg | Z/2241 | 26.2 | +0.000 | +4.718 | 64
2 x MULLION TOP PLATE | C200SD-C250SD/15deg | PL/1463 | 0.7 | +4.628 | +4.741 | 111.086
2 x MULLION | C200SD-C250SD/15deg-15deg | Z/2241 | 26.2 | +0.000 | +4.718 | 64
2 x MULLION TOP PLATE | C200SD/18deg | PL/1464 | 0.7 | +4.606 | +4.718 | 109.379
2 x MULLION | C200SD/18deg-18deg | Z/2242 | 26.2 | +0.000 | +4.696 | 64
2 x MULLION TOP PLATE | C200SD-C250SD/18deg | PL/1464 | 0.7 | +4.606 | +4.718 | 109.379
2 x MULLION | C200SD-C250SD/18deg-18deg | Z/2242 | 26.2 | +0.000 | +4.696 | 64
2 x MULLION TOP PLATE | C200SD/25deg | PL/1465 | 0.7 | +4.552 | +4.662 | 104.231
2 x MULLION | C200SD/25deg-25deg | Z/2243 | 26 | +0.000 | +4.642 | 64
2 x MULLION TOP PLATE | C200SD-C250SD/25deg | PL/1465 | 0.7 | +4.552 | +4.662 | 104.231
2 x MULLION | C200SD-C250SD/25deg-25deg | Z/2243 | 26 | +0.000 | +4.642 | 64
2 x MULLION TOP PLATE | C150SD/25deg | PL/1430 | 0.7 | +4.608 | +4.718 | 104.231
2 x MULLION | C150SD/25deg-25deg | Z/2173 | 26.2 | +0.000 | +4.698 | 64
2 x MULLION TOP PLATE | C150SD-C200SD/25deg | PL/1430 | 0.7 | +4.608 | +4.718 | 104.231
2 x MULLION | C150SD-C200SD/25deg-25deg | Z/2173 | 26.2 | +0.000 | +4.698 | 64
2 x MULLION TOP PLATE | C150SD/18deg | PL/1429 | 0.7 | +4.660 | +4.772 | 109.379
2 x MULLION | C150SD/18deg-18deg | Z/2172 | 26.4 | +0.000 | +4.750 | 64
2 x MULLION TOP PLATE | C150SD-C200SD/18deg | PL/1429 | 0.7 | +4.660 | +4.772 | 109.379
2 x MULLION | C150SD-C200SD/18deg-18deg | Z/2172 | 26.4 | +0.000 | +4.750 | 64
2 x MULLION TOP PLATE | C150SD/15deg | PL/1428 | 0.7 | +4.681 | +4.793 | 111.086
2 x MULLION | C150SD/15deg-15deg | Z/2171 | 26.6 | +0.000 | +4.771 | 64
2 x MULLION TOP PLATE | C150SD-C200SD/15deg | PL/1428 | 0.7 | +4.681 | +4.793 | 111.086
2 x MULLION | C150SD-C200SD/15deg-15deg | Z/2171 | 26.6 | +0.000 | +4.771 | 64
2 x MULLION TOP PLATE | C150SD/12deg | PL/1427 | 0.7 | +4.702 | +4.815 | 112.495
2 x MULLION | C150SD/12deg-12deg | Z/2170 | 26.8 | +0.000 | +4.792 | 64
2 x MULLION TOP PLATE | C150SD-C200SD/12deg | PL/1427 | 0.7 | +4.702 | +4.815 | 112.495
2 x MULLION | C150SD-C200SD/12deg-12deg | Z/2170 | 26.8 | +0.000 | +4.792 | 64
2 x MULLION TOP PLATE | C150SD/9deg | PL/1426 | 0.7 | +4.722 | +4.836 | 113.591
2 x MULLION | C150SD/9deg-9deg | Z/2169 | 26.8 | +0.000 | +4.812 | 64
2 x MULLION TOP PLATE | C150SD-C200SD/9deg | PL/1426 | 0.7 | +4.722 | +4.836 | 113.591
2 x MULLION | C150SD-C200SD/9deg-9deg | Z/2169 | 26.8 | +0.000 | +4.812 | 64
2 x MULLION TOP PLATE | C150SD/5deg | PL/1425 | 0.7 | +4.748 | +4.863 | 114.566
2 x MULLION | C150SD/5deg-5deg | Z/2168 | 27 | +0.000 | +4.838 | 64
2 x MULLION TOP PLATE | C150SD-C200SD/5deg | PL/1425 | 0.7 | +4.748 | +4.863 | 114.566
2 x MULLION | C150SD-C200SD/5deg-5deg | Z/2168 | 27 | +0.000 | +4.838 | 64
2 x MULLION TOP PLATE | C150SD/3deg | PL/1424 | 0.7 | +4.761 | +4.876 | 114.844
2 x MULLION | C150SD/3deg-3deg | Z/2108 | 27 | +0.000 | +4.851 | 64
2 x MULLION TOP PLATE | C150SD-C200SD/3deg | PL/1424 | 0.7 | +4.761 | +4.876 | 114.844
2 x MULLION | C150SD-C200SD/3deg-3deg | Z/2108 | 27 | +0.000 | +4.851 | 64
2 x MULLION TOP PLATE | C350SD>/3deg-3deg | PL/1522 | 0.9 | +4.630 | +4.744 | 127.991
2 x MULLION TOP PLATE | C350SD>/3deg-3deg | PL/1529 | 1.2 | +4.667 | +4.781 | 114.84
2 x MULLION TOP PLATE | C350SD>/3deg-3deg | PL/1536 | 1.5 | +4.703 | +4.817 | 114.842
2 x MULLION | C350SD>/3deg-3deg | Z/2021 | 59.9 | +0.000 | +4.793 | 96
2 x MULLION | C350SD>/3deg-3deg | Z/1725 | 38.2 | +0.000 | +4.757 | 76
2 x MULLION | C350SD>/3deg-3deg | Z/1554 | 33.5 | +0.000 | +4.720 | 76
2 x MULLION TOP PLATE | C350SD>/3deg-3deg | PL/1543 | 1.8 | +4.739 | +4.853 | 114.838
2 x MULLION | C350SD>/3deg-3deg | Z/2052 | 72.2 | +0.000 | +4.829 | 125
2 x MULLION TOP PLATE | C350SD/3deg-3deg | PL/1522 | 0.9 | +4.630 | +4.744 | 127.991
2 x MULLION TOP PLATE | C350SD/3deg-3deg | PL/1529 | 1.2 | +4.667 | +4.781 | 114.84
2 x MULLION TOP PLATE | C350SD/3deg-3deg | PL/1536 | 1.5 | +4.703 | +4.817 | 114.842
2 x MULLION | C350SD/3deg-3deg | Z/2021 | 59.9 | +0.000 | +4.793 | 96
2 x MULLION | C350SD/3deg-3deg | Z/1725 | 38.2 | +0.000 | +4.757 | 76
2 x MULLION | C350SD/3deg-3deg | Z/1554 | 33.5 | +0.000 | +4.720 | 76
2 x MULLION TOP PLATE | C350SD/3deg-3deg | PL/1543 | 1.8 | +4.739 | +4.853 | 114.838
2 x MULLION | C350SD/3deg-3deg | Z/2052 | 72.2 | +0.000 | +4.829 | 125
4 x RAFTER | C350SD>/3deg-3deg | Z/805 | 57.1 | +4.697 | +5.247 | 125
4 x RAFTER | C350SD/3deg-3deg | Z/805 | 57.1 | +4.697 | +5.247 | 125
2 x MULLION TOP PLATE | C350SD>/5deg-5deg | PL/1523 | 0.9 | +4.637 | +4.751 | 114.558
2 x MULLION TOP PLATE | C350SD>/5deg-5deg | PL/1530 | 1.2 | +4.698 | +4.813 | 114.561
2 x MULLION TOP PLATE | C350SD>/5deg-5deg | PL/1537 | 1.5 | +4.759 | +4.873 | 114.558
2 x MULLION | C350SD>/5deg-5deg | Z/2022 | 60.6 | +0.000 | +4.849 | 96
2 x MULLION | C350SD>/5deg-5deg | Z/1741 | 38.4 | +0.000 | +4.788 | 76
2 x MULLION | C350SD>/5deg-5deg | Z/1555 | 33.5 | +0.000 | +4.727 | 76
2 x MULLION TOP PLATE | C350SD>/5deg-5deg | PL/1544 | 1.8 | +4.819 | +4.933 | 114.562
2 x MULLION | C350SD>/5deg-5deg | Z/2053 | 73.4 | +0.000 | +4.909 | 125
2 x MULLION TOP PLATE | C350SD/5deg-5deg | PL/1523 | 0.9 | +4.637 | +4.751 | 114.558
2 x MULLION TOP PLATE | C350SD/5deg-5deg | PL/1530 | 1.2 | +4.698 | +4.813 | 114.561
2 x MULLION TOP PLATE | C350SD/5deg-5deg | PL/1537 | 1.5 | +4.759 | +4.873 | 114.558
2 x MULLION | C350SD/5deg-5deg | Z/2022 | 60.6 | +0.000 | +4.849 | 96
2 x MULLION | C350SD/5deg-5deg | Z/1741 | 38.4 | +0.000 | +4.788 | 76
2 x MULLION | C350SD/5deg-5deg | Z/1555 | 33.5 | +0.000 | +4.727 | 76
2 x MULLION TOP PLATE | C350SD/5deg-5deg | PL/1544 | 1.8 | +4.819 | +4.933 | 114.562
2 x MULLION | C350SD/5deg-5deg | Z/2053 | 73.4 | +0.000 | +4.909 | 125
4 x RAFTER | C350SD>/5deg-5deg | Z/806 | 57.1 | +4.673 | +5.355 | 125
4 x RAFTER | C350SD/5deg-5deg | Z/806 | 57.1 | +4.673 | +5.355 | 125
2 x MULLION TOP PLATE | C350SD>/9deg-9deg | PL/1524 | 0.9 | +4.652 | +4.765 | 113.578
2 x MULLION TOP PLATE | C350SD>/9deg-9deg | PL/1531 | 1.2 | +4.762 | +4.876 | 113.578
2 x MULLION TOP PLATE | C350SD>/9deg-9deg | PL/1538 | 1.5 | +4.872 | +4.985 | 113.584
2 x MULLION | C350SD>/9deg-9deg | Z/2023 | 62 | +0.000 | +4.962 | 96
2 x MULLION | C350SD>/9deg-9deg | Z/1742 | 38.9 | +0.000 | +4.852 | 76
2 x MULLION | C350SD>/9deg-9deg | Z/1556 | 33.6 | +0.000 | +4.742 | 76
2 x MULLION TOP PLATE | C350SD>/9deg-9deg | PL/1545 | 1.8 | +4.980 | +5.094 | 113.587
2 x MULLION | C350SD>/9deg-9deg | Z/2054 | 75.8 | +0.000 | +5.070 | 125
2 x MULLION TOP PLATE | C350SD/9deg-9deg | PL/1524 | 0.9 | +4.652 | +4.765 | 113.578
2 x MULLION TOP PLATE | C350SD/9deg-9deg | PL/1531 | 1.2 | +4.762 | +4.876 | 113.578
2 x MULLION TOP PLATE | C350SD/9deg-9deg | PL/1538 | 1.5 | +4.872 | +4.985 | 113.584
2 x MULLION | C350SD/9deg-9deg | Z/2023 | 62 | +0.000 | +4.962 | 96
2 x MULLION | C350SD/9deg-9deg | Z/1742 | 38.9 | +0.000 | +4.852 | 76
2 x MULLION | C350SD/9deg-9deg | Z/1556 | 33.6 | +0.000 | +4.742 | 76
2 x MULLION TOP PLATE | C350SD/9deg-9deg | PL/1545 | 1.8 | +4.980 | +5.094 | 113.587
2 x MULLION | C350SD/9deg-9deg | Z/2054 | 75.8 | +0.000 | +5.070 | 125
4 x RAFTER | C350SD>/9deg-9deg | Z/807 | 57.1 | +4.623 | +5.567 | 125
4 x RAFTER | C350SD/9deg-9deg | Z/807 | 57.1 | +4.623 | +5.567 | 125
2 x MULLION TOP PLATE | C350SD>/12deg-12deg | PL/1525 | 0.9 | +4.663 | +4.776 | 112.484
2 x MULLION TOP PLATE | C350SD>/12deg-12deg | PL/1539 | 1.5 | +4.958 | +5.071 | 125.895
2 x MULLION TOP PLATE | C350SD>/12deg-12deg | PL/1532 | 1.2 | +4.811 | +4.924 | 125.895
2 x MULLION | C350SD>/12deg-12deg | Z/2048 | 63.1 | +0.000 | +5.048 | 96
2 x MULLION | C350SD>/12deg-12deg | Z/1758 | 39.3 | +0.000 | +4.901 | 76
2 x MULLION | C350SD>/12deg-12deg | Z/1557 | 33.7 | +0.000 | +4.753 | 76
2 x MULLION TOP PLATE | C350SD>/12deg-12deg | PL/1546 | 1.8 | +5.104 | +5.217 | 112.487
2 x MULLION | C350SD>/12deg-12deg | Z/2101 | 77.7 | +0.000 | +5.194 | 125
2 x MULLION TOP PLATE | C350SD/12deg-12deg | PL/1525 | 0.9 | +4.663 | +4.776 | 112.484
2 x MULLION TOP PLATE | C350SD/12deg-12deg | PL/1539 | 1.5 | +4.958 | +5.071 | 125.895
2 x MULLION TOP PLATE | C350SD/12deg-12deg | PL/1532 | 1.2 | +4.811 | +4.924 | 125.895
2 x MULLION | C350SD/12deg-12deg | Z/2048 | 63.1 | +0.000 | +5.048 | 96
2 x MULLION | C350SD/12deg-12deg | Z/1758 | 39.3 | +0.000 | +4.901 | 76
2 x MULLION | C350SD/12deg-12deg | Z/1557 | 33.7 | +0.000 | +4.753 | 76
2 x MULLION TOP PLATE | C350SD/12deg-12deg | PL/1546 | 1.8 | +5.104 | +5.217 | 112.487
2 x MULLION | C350SD/12deg-12deg | Z/2101 | 77.7 | +0.000 | +5.194 | 125
4 x RAFTER | C350SD>/12deg-12deg | Z/719 | 57.1 | +4.585 | +5.722 | 125
