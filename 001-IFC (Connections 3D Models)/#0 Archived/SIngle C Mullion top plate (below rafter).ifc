Properties of the parts of a building model (IFC2X3), part 2 of 3

# IfcElementAssembly (1680)
Name | ASSEMBLY_POSITION_CODE = Assembly/Cast unit position code | ASSEMBLY_POS = Assembly/Cast unit Mark | Assembly/Cast unit weight (kg) | Assembly/Cast unit bottom elevation | Assembly/Cast unit top elevation | Width (mm)
3 x RAFTER | C350SD/12deg-12deg | Z/719 | 57.1 | +4.585 | +5.722 | 125
2 x MULLION TOP PLATE | C350SD>/15deg-15deg | PL/1526 | 0.9 | +4.674 | +4.786 | 111.081
2 x MULLION TOP PLATE | C350SD>/15deg-15deg | PL/1533 | 1.2 | +4.861 | +4.974 | 111.076
2 x MULLION TOP PLATE | C350SD>/15deg-15deg | PL/1540 | 1.5 | +5.046 | +5.159 | 111.081
2 x MULLION | C350SD>/15deg-15deg | Z/2049 | 64.2 | +0.000 | +5.136 | 96
2 x MULLION | C350SD>/15deg-15deg | Z/1759 | 39.7 | +0.000 | +4.951 | 76
2 x MULLION | C350SD>/15deg-15deg | Z/1704 | 33.8 | +0.000 | +4.764 | 76
2 x MULLION TOP PLATE | C350SD>/15deg-15deg | PL/1547 | 1.8 | +5.230 | +5.342 | 111.081
2 x MULLION | C350SD>/15deg-15deg | Z/2105 | 79.6 | +0.000 | +5.320 | 125
2 x MULLION TOP PLATE | C350SD/15deg-15deg | PL/1526 | 0.9 | +4.674 | +4.786 | 111.081
2 x MULLION TOP PLATE | C350SD/15deg-15deg | PL/1533 | 1.2 | +4.861 | +4.974 | 111.076
2 x MULLION TOP PLATE | C350SD/15deg-15deg | PL/1540 | 1.5 | +5.046 | +5.159 | 111.081
2 x MULLION | C350SD/15deg-15deg | Z/2049 | 64.2 | +0.000 | +5.136 | 96
2 x MULLION | C350SD/15deg-15deg | Z/1759 | 39.7 | +0.000 | +4.951 | 76
2 x MULLION | C350SD/15deg-15deg | Z/1704 | 33.8 | +0.000 | +4.764 | 76
2 x MULLION TOP PLATE | C350SD/15deg-15deg | PL/1547 | 1.8 | +5.230 | +5.342 | 111.081
2 x MULLION | C350SD/15deg-15deg | Z/2105 | 79.6 | +0.000 | +5.320 | 125
4 x RAFTER | C350SD>/15deg-15deg | Z/808 | 57.1 | +4.547 | +5.874 | 125
3 x RAFTER | C350SD/15deg-15deg | Z/808 | 57.1 | +4.547 | +5.874 | 125
2 x MULLION TOP PLATE | C350SD>/18deg-18deg | PL/1527 | 0.9 | +4.686 | +4.797 | 109.365
2 x MULLION TOP PLATE | C350SD>/18deg-18deg | PL/1534 | 1.2 | +4.913 | +5.025 | 109.37
2 x MULLION TOP PLATE | C350SD>/18deg-18deg | PL/1541 | 1.5 | +5.137 | +5.249 | 109.374
2 x MULLION | C350SD>/18deg-18deg | Z/2050 | 65.4 | +0.000 | +5.227 | 96
2 x MULLION | C350SD>/18deg-18deg | Z/1796 | 40.1 | +0.000 | +5.003 | 76
2 x MULLION | C350SD>/18deg-18deg | Z/1705 | 33.8 | +0.000 | +4.776 | 76
2 x MULLION TOP PLATE | C350SD>/18deg-18deg | PL/1548 | 1.8 | +5.360 | +5.472 | 109.368
2 x MULLION | C350SD>/18deg-18deg | Z/2106 | 81.5 | +0.000 | +5.450 | 125
2 x MULLION TOP PLATE | C350SD/18deg-18deg | PL/1527 | 0.9 | +4.686 | +4.797 | 109.365
2 x MULLION TOP PLATE | C350SD/18deg-18deg | PL/1534 | 1.2 | +4.913 | +5.025 | 109.37
2 x MULLION TOP PLATE | C350SD/18deg-18deg | PL/1541 | 1.5 | +5.137 | +5.249 | 109.374
2 x MULLION | C350SD/18deg-18deg | Z/2050 | 65.4 | +0.000 | +5.227 | 96
2 x MULLION | C350SD/18deg-18deg | Z/1796 | 40.1 | +0.000 | +5.003 | 76
2 x MULLION | C350SD/18deg-18deg | Z/1705 | 33.8 | +0.000 | +4.776 | 76
2 x MULLION TOP PLATE | C350SD/18deg-18deg | PL/1548 | 1.8 | +5.360 | +5.472 | 109.368
2 x MULLION | C350SD/18deg-18deg | Z/2106 | 81.5 | +0.000 | +5.450 | 125
4 x RAFTER | C350SD>/18deg-18deg | Z/809 | 57.1 | +4.507 | +6.021 | 125
4 x RAFTER | C350SD/18deg-18deg | Z/809 | 57.1 | +4.507 | +6.021 | 125
2 x MULLION TOP PLATE | C350SD>/25deg-25deg | PL/1528 | 0.9 | +4.714 | +4.824 | 104.223
2 x MULLION TOP PLATE | C350SD>/25deg-25deg | PL/1535 | 1.2 | +5.041 | +5.151 | 104.22
2 x MULLION TOP PLATE | C350SD>/25deg-25deg | PL/1542 | 1.5 | +5.363 | +5.473 | 104.222
2 x MULLION | C350SD>/25deg-25deg | Z/2051 | 68.2 | +0.000 | +5.453 | 96
2 x MULLION | C350SD>/25deg-25deg | Z/1876 | 41.2 | +0.000 | +5.131 | 76
2 x MULLION | C350SD>/25deg-25deg | Z/1724 | 34.1 | +0.000 | +4.804 | 76
2 x MULLION TOP PLATE | C350SD>/25deg-25deg | PL/1549 | 1.8 | +5.682 | +5.792 | 104.226
2 x MULLION | C350SD>/25deg-25deg | Z/2107 | 86.3 | +0.000 | +5.772 | 125
2 x MULLION TOP PLATE | C350SD/25deg-25deg | PL/1528 | 0.9 | +4.714 | +4.824 | 104.223
2 x MULLION TOP PLATE | C350SD/25deg-25deg | PL/1535 | 1.2 | +5.041 | +5.151 | 104.22
2 x MULLION TOP PLATE | C350SD/25deg-25deg | PL/1542 | 1.5 | +5.363 | +5.473 | 104.222
2 x MULLION | C350SD/25deg-25deg | Z/2051 | 68.2 | +0.000 | +5.453 | 96
2 x MULLION | C350SD/25deg-25deg | Z/1876 | 41.2 | +0.000 | +5.131 | 76
2 x MULLION | C350SD/25deg-25deg | Z/1724 | 34.1 | +0.000 | +4.804 | 76
2 x MULLION TOP PLATE | C350SD/25deg-25deg | PL/1549 | 1.8 | +5.682 | +5.792 | 104.226
2 x MULLION | C350SD/25deg-25deg | Z/2107 | 86.3 | +0.000 | +5.772 | 125
4 x RAFTER | C350SD>/25deg-25deg | Z/810 | 57.1 | +4.408 | +6.340 | 125
4 x RAFTER | C350SD/25deg-25deg | Z/810 | 57.1 | +4.408 | +6.340 | 125
2 x MULLION TOP PLATE | C300SD-C350SD/25deg-25deg | PL/1521 | 1.8 | +5.737 | +5.848 | 104.224
2 x MULLION TOP PLATE | C300SD-C350SD/25deg-25deg | PL/1500 | 0.9 | +4.769 | +4.880 | 104.23
2 x MULLION TOP PLATE | C300SD-C350SD/25deg-25deg | PL/1507 | 1.2 | +5.096 | +5.206 | 104.226
2 x MULLION | C300SD-C350SD/25deg-25deg | Z/1551 | 87.1 | +0.000 | +5.827 | 125
2 x MULLION | C300SD-C350SD/25deg-25deg | Z/936 | 41.6 | +0.000 | +5.186 | 76
2 x MULLION | C300SD-C350SD/25deg-25deg | Z/924 | 34.4 | +0.000 | +4.859 | 76
2 x MULLION TOP PLATE | C300SD-C350SD/25deg-25deg | PL/1514 | 1.5 | +5.417 | +5.528 | 104.229
2 x MULLION | C300SD-C350SD/25deg-25deg | Z/943 | 68.9 | +0.000 | +5.507 | 96
2 x MULLION TOP PLATE | C300SD/25deg-25deg | PL/1521 | 1.8 | +5.737 | +5.848 | 104.224
2 x MULLION TOP PLATE | C300SD/25deg-25deg | PL/1500 | 0.9 | +4.769 | +4.880 | 104.23
2 x MULLION TOP PLATE | C300SD/25deg-25deg | PL/1507 | 1.2 | +5.096 | +5.206 | 104.226
2 x MULLION | C300SD/25deg-25deg | Z/1551 | 87.1 | +0.000 | +5.827 | 125
2 x MULLION | C300SD/25deg-25deg | Z/936 | 41.6 | +0.000 | +5.186 | 76
2 x MULLION | C300SD/25deg-25deg | Z/924 | 34.4 | +0.000 | +4.859 | 76
2 x MULLION TOP PLATE | C300SD/25deg-25deg | PL/1514 | 1.5 | +5.417 | +5.528 | 104.229
2 x MULLION | C300SD/25deg-25deg | Z/943 | 68.9 | +0.000 | +5.507 | 96
4 x RAFTER | C300SD-C350SD/25deg-25deg | Z/780 | 48.2 | +4.446 | +6.348 | 96
4 x RAFTER | C300SD/25deg-25deg | Z/780 | 48.2 | +4.446 | +6.348 | 96
2 x MULLION TOP PLATE | C300SD-C350SD/18deg-18deg | PL/1520 | 1.8 | +5.410 | +5.521 | 109.37
2 x MULLION TOP PLATE | C300SD-C350SD/18deg-18deg | PL/1499 | 0.9 | +4.735 | +4.847 | 109.377
2 x MULLION TOP PLATE | C300SD-C350SD/18deg-18deg | PL/1506 | 1.2 | +4.963 | +5.075 | 109.372
2 x MULLION | C300SD-C350SD/18deg-18deg | Z/1550 | 82.2 | +0.000 | +5.500 | 125
2 x MULLION | C300SD-C350SD/18deg-18deg | Z/935 | 40.5 | +0.000 | +5.053 | 76
2 x MULLION | C300SD-C350SD/18deg-18deg | Z/921 | 34.2 | +0.000 | +4.825 | 76
2 x MULLION TOP PLATE | C300SD-C350SD/18deg-18deg | PL/1513 | 1.5 | +5.187 | +5.299 | 109.376
2 x MULLION | C300SD-C350SD/18deg-18deg | Z/942 | 66 | +0.000 | +5.277 | 96
2 x MULLION TOP PLATE | C300SD/18deg-18deg | PL/1520 | 1.8 | +5.410 | +5.521 | 109.37
2 x MULLION TOP PLATE | C300SD/18deg-18deg | PL/1499 | 0.9 | +4.735 | +4.847 | 109.377
2 x MULLION TOP PLATE | C300SD/18deg-18deg | PL/1506 | 1.2 | +4.963 | +5.075 | 109.372
2 x MULLION | C300SD/18deg-18deg | Z/1550 | 82.2 | +0.000 | +5.500 | 125
2 x MULLION | C300SD/18deg-18deg | Z/935 | 40.5 | +0.000 | +5.053 | 76
2 x MULLION | C300SD/18deg-18deg | Z/921 | 34.2 | +0.000 | +4.825 | 76
2 x MULLION TOP PLATE | C300SD/18deg-18deg | PL/1513 | 1.5 | +5.187 | +5.299 | 109.376
2 x MULLION | C300SD/18deg-18deg | Z/942 | 66 | +0.000 | +5.277 | 96
4 x RAFTER | C300SD-C350SD/18deg-18deg | Z/779 | 48.2 | +4.545 | +6.022 | 96
4 x RAFTER | C300SD/18deg-18deg | Z/779 | 48.2 | +4.545 | +6.022 | 96
2 x MULLION TOP PLATE | C300SD-C350SD/15deg-15deg | PL/1519 | 1.8 | +5.278 | +5.390 | 111.086
2 x MULLION TOP PLATE | C300SD-C350SD/15deg-15deg | PL/1498 | 0.9 | +4.722 | +4.834 | 111.086
2 x MULLION TOP PLATE | C300SD-C350SD/15deg-15deg | PL/1505 | 1.2 | +4.909 | +5.022 | 111.081
2 x MULLION | C300SD-C350SD/15deg-15deg | Z/1549 | 80.3 | +0.000 | +5.368 | 125
2 x MULLION | C300SD-C350SD/15deg-15deg | Z/934 | 40.1 | +0.000 | +4.999 | 76
2 x MULLION | C300SD-C350SD/15deg-15deg | Z/920 | 34.1 | +0.000 | +4.812 | 76
2 x MULLION TOP PLATE | C300SD-C350SD/15deg-15deg | PL/1512 | 1.5 | +5.094 | +5.207 | 111.086
2 x MULLION | C300SD-C350SD/15deg-15deg | Z/941 | 64.8 | +0.000 | +5.184 | 96
2 x MULLION TOP PLATE | C300SD/15deg-15deg | PL/1519 | 1.8 | +5.278 | +5.390 | 111.086
2 x MULLION TOP PLATE | C300SD/15deg-15deg | PL/1498 | 0.9 | +4.722 | +4.834 | 111.086
2 x MULLION TOP PLATE | C300SD/15deg-15deg | PL/1505 | 1.2 | +4.909 | +5.022 | 111.081
2 x MULLION | C300SD/15deg-15deg | Z/1549 | 80.3 | +0.000 | +5.368 | 125
2 x MULLION | C300SD/15deg-15deg | Z/934 | 40.1 | +0.000 | +4.999 | 76
2 x MULLION | C300SD/15deg-15deg | Z/920 | 34.1 | +0.000 | +4.812 | 76
2 x MULLION TOP PLATE | C300SD/15deg-15deg | PL/1512 | 1.5 | +5.094 | +5.207 | 111.086
2 x MULLION | C300SD/15deg-15deg | Z/941 | 64.8 | +0.000 | +5.184 | 96
4 x RAFTER | C300SD-C350SD/15deg-15deg | Z/778 | 48.2 | +4.585 | +5.873 | 96
4 x RAFTER | C300SD/15deg-15deg | Z/778 | 48.2 | +4.585 | +5.873 | 96
2 x MULLION TOP PLATE | C300SD-C350SD/12deg-12deg | PL/1518 | 1.8 | +5.150 | +5.263 | 112.491
2 x MULLION TOP PLATE | C300SD-C350SD/12deg-12deg | PL/1497 | 0.9 | +4.708 | +4.821 | 112.488
2 x MULLION TOP PLATE | C300SD-C350SD/12deg-12deg | PL/1504 | 1.2 | +4.857 | +4.970 | 112.489
2 x MULLION | C300SD-C350SD/12deg-12deg | Z/1548 | 78.4 | +0.000 | +5.240 | 125
2 x MULLION | C300SD-C350SD/12deg-12deg | Z/933 | 39.7 | +0.000 | +4.947 | 76
2 x MULLION | C300SD-C350SD/12deg-12deg | Z/919 | 34 | +0.000 | +4.798 | 76
2 x MULLION TOP PLATE | C300SD-C350SD/12deg-12deg | PL/1511 | 1.5 | +5.004 | +5.117 | 112.493
2 x MULLION | C300SD-C350SD/12deg-12deg | Z/940 | 63.7 | +0.000 | +5.094 | 96
2 x MULLION TOP PLATE | C300SD/12deg-12deg | PL/1518 | 1.8 | +5.150 | +5.263 | 112.491
2 x MULLION TOP PLATE | C300SD/12deg-12deg | PL/1497 | 0.9 | +4.708 | +4.821 | 112.488
2 x MULLION TOP PLATE | C300SD/12deg-12deg | PL/1504 | 1.2 | +4.857 | +4.970 | 112.489
2 x MULLION | C300SD/12deg-12deg | Z/1548 | 78.4 | +0.000 | +5.240 | 125
2 x MULLION | C300SD/12deg-12deg | Z/933 | 39.7 | +0.000 | +4.947 | 76
2 x MULLION | C300SD/12deg-12deg | Z/919 | 34 | +0.000 | +4.798 | 76
2 x MULLION TOP PLATE | C300SD/12deg-12deg | PL/1511 | 1.5 | +5.004 | +5.117 | 112.493
2 x MULLION | C300SD/12deg-12deg | Z/940 | 63.7 | +0.000 | +5.094 | 96
4 x RAFTER | C300SD-C350SD/12deg-12deg | Z/714 | 48.2 | +4.624 | +5.719 | 96
4 x RAFTER | C300SD/12deg-12deg | Z/714 | 48.2 | +4.624 | +5.719 | 96
2 x MULLION TOP PLATE | C300SD-C350SD/9deg-9deg | PL/1517 | 1.8 | +5.024 | +5.138 | 113.583
2 x MULLION TOP PLATE | C300SD-C350SD/9deg-9deg | PL/1496 | 0.9 | +4.695 | +4.809 | 113.585
2 x MULLION TOP PLATE | C300SD-C350SD/9deg-9deg | PL/1503 | 1.2 | +4.806 | +4.920 | 113.585
2 x MULLION | C300SD-C350SD/9deg-9deg | Z/946 | 76.5 | +0.000 | +5.114 | 125
2 x MULLION | C300SD-C350SD/9deg-9deg | Z/929 | 39.3 | +0.000 | +4.896 | 76
2 x MULLION | C300SD-C350SD/9deg-9deg | Z/918 | 33.8 | +0.000 | +4.785 | 76
2 x MULLION TOP PLATE | C300SD-C350SD/9deg-9deg | PL/1510 | 1.5 | +4.916 | +5.029 | 113.59
2 x MULLION | C300SD-C350SD/9deg-9deg | Z/939 | 62.6 | +0.000 | +5.006 | 96
2 x MULLION TOP PLATE | C300SD/9deg-9deg | PL/1517 | 1.8 | +5.024 | +5.138 | 113.583
2 x MULLION TOP PLATE | C300SD/9deg-9deg | PL/1496 | 0.9 | +4.695 | +4.809 | 113.585
2 x MULLION TOP PLATE | C300SD/9deg-9deg | PL/1503 | 1.2 | +4.806 | +4.920 | 113.585
2 x MULLION | C300SD/9deg-9deg | Z/946 | 76.5 | +0.000 | +5.114 | 125
2 x MULLION | C300SD/9deg-9deg | Z/929 | 39.3 | +0.000 | +4.896 | 76
2 x MULLION | C300SD/9deg-9deg | Z/918 | 33.8 | +0.000 | +4.785 | 76
2 x MULLION TOP PLATE | C300SD/9deg-9deg | PL/1510 | 1.5 | +4.916 | +5.029 | 113.59
2 x MULLION | C300SD/9deg-9deg | Z/939 | 62.6 | +0.000 | +5.006 | 96
4 x RAFTER | C300SD-C350SD/9deg-9deg | Z/777 | 48.2 | +4.662 | +5.561 | 96
4 x RAFTER | C300SD/9deg-9deg | Z/777 | 48.2 | +4.662 | +5.561 | 96
2 x MULLION TOP PLATE | C300SD-C350SD/5deg-5deg | PL/1516 | 1.8 | +4.860 | +4.974 | 114.569
2 x MULLION TOP PLATE | C300SD-C350SD/5deg-5deg | PL/1495 | 0.9 | +4.678 | +4.793 | 114.565
2 x MULLION TOP PLATE | C300SD-C350SD/5deg-5deg | PL/1502 | 1.2 | +4.740 | +4.854 | 114.568
2 x MULLION | C300SD-C350SD/5deg-5deg | Z/945 | 74 | +0.000 | +4.950 | 125
2 x MULLION | C300SD-C350SD/5deg-5deg | Z/926 | 38.7 | +0.000 | +4.830 | 76
2 x MULLION | C300SD-C350SD/5deg-5deg | Z/917 | 33.8 | +0.000 | +4.768 | 76
2 x MULLION TOP PLATE | C300SD-C350SD/5deg-5deg | PL/1509 | 1.5 | +4.800 | +4.914 | 114.565
2 x MULLION | C300SD-C350SD/5deg-5deg | Z/938 | 61.1 | +0.000 | +4.890 | 96
2 x MULLION TOP PLATE | C300SD/5deg-5deg | PL/1516 | 1.8 | +4.860 | +4.974 | 114.569
2 x MULLION TOP PLATE | C300SD/5deg-5deg | PL/1495 | 0.9 | +4.678 | +4.793 | 114.565
2 x MULLION TOP PLATE | C300SD/5deg-5deg | PL/1502 | 1.2 | +4.740 | +4.854 | 114.568
2 x MULLION | C300SD/5deg-5deg | Z/945 | 74 | +0.000 | +4.950 | 125
2 x MULLION | C300SD/5deg-5deg | Z/926 | 38.7 | +0.000 | +4.830 | 76
2 x MULLION | C300SD/5deg-5deg | Z/917 | 33.8 | +0.000 | +4.768 | 76
2 x MULLION TOP PLATE | C300SD/5deg-5deg | PL/1509 | 1.5 | +4.800 | +4.914 | 114.565
2 x MULLION | C300SD/5deg-5deg | Z/938 | 61.1 | +0.000 | +4.890 | 96
4 x RAFTER | C300SD-C350SD/5deg-5deg | Z/776 | 48.2 | +4.711 | +5.346 | 96
4 x RAFTER | C300SD/5deg-5deg | Z/776 | 48.2 | +4.711 | +5.346 | 96
2 x MULLION TOP PLATE | C300SD-C350SD/3deg-3deg | PL/1515 | 1.8 | +4.779 | +4.893 | 127.995
2 x MULLION TOP PLATE | C300SD-C350SD/3deg-3deg | PL/1508 | 1.5 | +4.743 | +4.857 | 127.989
2 x MULLION TOP PLATE | C300SD-C350SD/3deg-3deg | PL/1494 | 0.9 | +4.670 | +4.785 | 114.839
2 x MULLION TOP PLATE | C300SD-C350SD/3deg-3deg | PL/1501 | 1.2 | +4.707 | +4.821 | 114.845
2 x MULLION | C300SD-C350SD/3deg-3deg | Z/944 | 72.8 | +0.000 | +4.869 | 125
2 x MULLION | C300SD-C350SD/3deg-3deg | Z/925 | 38.4 | +0.000 | +4.797 | 76
2 x MULLION | C300SD-C350SD/3deg-3deg | Z/139 | 33.7 | +0.000 | +4.760 | 76
2 x MULLION | C300SD-C350SD/3deg-3deg | Z/937 | 60.4 | +0.000 | +4.833 | 96
2 x MULLION TOP PLATE | C300SD/3deg-3deg | PL/1515 | 1.8 | +4.779 | +4.893 | 127.995
2 x MULLION TOP PLATE | C300SD/3deg-3deg | PL/1508 | 1.5 | +4.743 | +4.857 | 127.989
2 x MULLION TOP PLATE | C300SD/3deg-3deg | PL/1494 | 0.9 | +4.670 | +4.785 | 114.839
2 x MULLION TOP PLATE | C300SD/3deg-3deg | PL/1501 | 1.2 | +4.707 | +4.821 | 114.845
2 x MULLION | C300SD/3deg-3deg | Z/944 | 72.8 | +0.000 | +4.869 | 125
2 x MULLION | C300SD/3deg-3deg | Z/925 | 38.4 | +0.000 | +4.797 | 76
2 x MULLION | C300SD/3deg-3deg | Z/139 | 33.7 | +0.000 | +4.760 | 76
2 x MULLION | C300SD/3deg-3deg | Z/937 | 60.4 | +0.000 | +4.833 | 96
4 x RAFTER | C300SD-C350SD/3deg-3deg | Z/775 | 48.2 | +4.736 | +5.237 | 96
4 x RAFTER | C300SD/3deg-3deg | Z/775 | 48.2 | +4.736 | +5.237 | 96
2 x MULLION TOP PLATE | C250SD/3deg-3deg | PL/1466 | 0.9 | +4.707 | +4.821 | 114.847
2 x MULLION TOP PLATE | C250SD/3deg-3deg | PL/1473 | 1.2 | +4.743 | +4.858 | 114.853
2 x MULLION TOP PLATE | C250SD/3deg-3deg | PL/1480 | 1.6 | +4.779 | +4.894 | 114.845
2 x MULLION TOP PLATE | C250SD/3deg-3deg | PL/1487 | 1.9 | +4.815 | +4.930 | 114.851
2 x MULLION TOP PLATE | C250SD-C300SD/3deg-3deg | PL/1466 | 0.9 | +4.707 | +4.821 | 114.847
2 x MULLION TOP PLATE | C250SD-C300SD/3deg-3deg | PL/1473 | 1.2 | +4.743 | +4.858 | 114.853
2 x MULLION TOP PLATE | C250SD-C300SD/3deg-3deg | PL/1480 | 1.6 | +4.779 | +4.894 | 114.845
2 x MULLION TOP PLATE | C250SD-C300SD/3deg-3deg | PL/1487 | 1.9 | +4.815 | +4.930 | 114.851
2 x MULLION | C250SD-C300SD/3deg-3deg | Z/910 | 73.4 | +0.000 | +4.905 | 125
2 x MULLION | C250SD-C300SD/3deg-3deg | Z/901 | 60.9 | +0.000 | +4.869 | 96
2 x MULLION | C250SD-C300SD/3deg-3deg | Z/54 | 34 | +0.000 | +4.797 | 76
2 x MULLION | C250SD-C300SD/3deg-3deg | Z/889 | 38.8 | +0.000 | +4.833 | 76
2 x MULLION | C250SD/3deg-3deg | Z/910 | 73.4 | +0.000 | +4.905 | 125
2 x MULLION | C250SD/3deg-3deg | Z/901 | 60.9 | +0.000 | +4.869 | 96
2 x MULLION | C250SD/3deg-3deg | Z/54 | 34 | +0.000 | +4.797 | 76
2 x MULLION | C250SD/3deg-3deg | Z/889 | 38.8 | +0.000 | +4.833 | 76
4 x RAFTER | C250SD-C300SD/3deg-3deg | Z/745 | 31.2 | +4.771 | +5.228 | 76
4 x RAFTER | C250SD/3deg-3deg | Z/745 | 31.2 | +4.771 | +5.228 | 76
2 x MULLION TOP PLATE | C250SD/5deg-5deg | PL/1467 | 0.9 | +4.716 | +4.830 | 114.566
2 x MULLION TOP PLATE | C250SD/5deg-5deg | PL/1474 | 1.2 | +4.777 | +4.892 | 114.568
2 x MULLION TOP PLATE | C250SD/5deg-5deg | PL/1481 | 1.6 | +4.838 | +4.952 | 114.566
2 x MULLION TOP PLATE | C250SD/5deg-5deg | PL/1488 | 1.9 | +4.898 | +5.012 | 114.57
2 x MULLION TOP PLATE | C250SD-C300SD/5deg-5deg | PL/1467 | 0.9 | +4.716 | +4.830 | 114.566
2 x MULLION TOP PLATE | C250SD-C300SD/5deg-5deg | PL/1474 | 1.2 | +4.777 | +4.892 | 114.568
2 x MULLION TOP PLATE | C250SD-C300SD/5deg-5deg | PL/1481 | 1.6 | +4.838 | +4.952 | 114.566
2 x MULLION TOP PLATE | C250SD-C300SD/5deg-5deg | PL/1488 | 1.9 | +4.898 | +5.012 | 114.57
2 x MULLION | C250SD-C300SD/5deg-5deg | Z/911 | 74.6 | +0.000 | +4.988 | 125
2 x MULLION | C250SD-C300SD/5deg-5deg | Z/904 | 61.6 | +0.000 | +4.928 | 96
2 x MULLION | C250SD-C300SD/5deg-5deg | Z/883 | 34.1 | +0.000 | +4.806 | 76
2 x MULLION | C250SD-C300SD/5deg-5deg | Z/890 | 38.9 | +0.000 | +4.867 | 76
2 x MULLION | C250SD/5deg-5deg | Z/911 | 74.6 | +0.000 | +4.988 | 125
2 x MULLION | C250SD/5deg-5deg | Z/904 | 61.6 | +0.000 | +4.928 | 96
2 x MULLION | C250SD/5deg-5deg | Z/883 | 34.1 | +0.000 | +4.806 | 76
2 x MULLION | C250SD/5deg-5deg | Z/890 | 38.9 | +0.000 | +4.867 | 76
4 x RAFTER | C250SD-C300SD/5deg-5deg | Z/746 | 31.2 | +4.746 | +5.338 | 76
4 x RAFTER | C250SD/5deg-5deg | Z/746 | 31.2 | +4.746 | +5.338 | 76
2 x MULLION TOP PLATE | C250SD/9deg-9deg | PL/1468 | 0.9 | +4.735 | +4.849 | 113.594
2 x MULLION TOP PLATE | C250SD/9deg-9deg | PL/1475 | 1.2 | +4.846 | +4.960 | 113.593
2 x MULLION TOP PLATE | C250SD/9deg-9deg | PL/1482 | 1.6 | +4.956 | +5.069 | 113.589
2 x MULLION TOP PLATE | C250SD/9deg-9deg | PL/1489 | 1.8 | +5.064 | +5.178 | 113.592
2 x MULLION TOP PLATE | C250SD-C300SD/9deg-9deg | PL/1468 | 0.9 | +4.735 | +4.849 | 113.594
2 x MULLION TOP PLATE | C250SD-C300SD/9deg-9deg | PL/1475 | 1.2 | +4.846 | +4.960 | 113.593
2 x MULLION TOP PLATE | C250SD-C300SD/9deg-9deg | PL/1482 | 1.6 | +4.956 | +5.069 | 113.589
2 x MULLION TOP PLATE | C250SD-C300SD/9deg-9deg | PL/1489 | 1.8 | +5.064 | +5.178 | 113.592
2 x MULLION | C250SD-C300SD/9deg-9deg | Z/912 | 77.1 | +0.000 | +5.154 | 125
2 x MULLION | C250SD-C300SD/9deg-9deg | Z/905 | 63.1 | +0.000 | +5.046 | 96
2 x MULLION | C250SD-C300SD/9deg-9deg | Z/884 | 34.2 | +0.000 | +4.825 | 76
2 x MULLION | C250SD-C300SD/9deg-9deg | Z/891 | 39.6 | +0.000 | +4.936 | 76
2 x MULLION | C250SD/9deg-9deg | Z/912 | 77.1 | +0.000 | +5.154 | 125
2 x MULLION | C250SD/9deg-9deg | Z/905 | 63.1 | +0.000 | +5.046 | 96
2 x MULLION | C250SD/9deg-9deg | Z/884 | 34.2 | +0.000 | +4.825 | 76
2 x MULLION | C250SD/9deg-9deg | Z/891 | 39.6 | +0.000 | +4.936 | 76
4 x RAFTER | C250SD-C300SD/9deg-9deg | Z/747 | 31.2 | +4.696 | +5.556 | 76
4 x RAFTER | C250SD/9deg-9deg | Z/747 | 31.2 | +4.696 | +5.556 | 76
2 x MULLION TOP PLATE | C250SD/12deg-12deg | PL/1490 | 1.8 | +5.191 | +5.304 | 125.894
2 x MULLION TOP PLATE | C250SD/12deg-12deg | PL/1483 | 1.6 | +5.046 | +5.159 | 125.894
2 x MULLION TOP PLATE | C250SD/12deg-12deg | PL/1476 | 1.2 | +4.899 | +5.012 | 125.894
2 x MULLION TOP PLATE | C250SD/12deg-12deg | PL/1469 | 0.9 | +4.750 | +4.863 | 125.894
2 x MULLION TOP PLATE | C250SD-C300SD/12deg-12deg | PL/1469 | 0.9 | +4.750 | +4.863 | 125.894
2 x MULLION TOP PLATE | C250SD-C300SD/12deg-12deg | PL/1476 | 1.2 | +4.899 | +5.012 | 125.894
2 x MULLION TOP PLATE | C250SD-C300SD/12deg-12deg | PL/1483 | 1.6 | +5.046 | +5.159 | 125.894
2 x MULLION TOP PLATE | C250SD-C300SD/12deg-12deg | PL/1490 | 1.8 | +5.191 | +5.304 | 125.894
2 x MULLION | C250SD-C300SD/12deg-12deg | Z/913 | 79 | +0.000 | +5.281 | 125
2 x MULLION | C250SD-C300SD/12deg-12deg | Z/906 | 64.2 | +0.000 | +5.136 | 96
2 x MULLION | C250SD-C300SD/12deg-12deg | Z/885 | 34.4 | +0.000 | +4.840 | 76
2 x MULLION | C250SD-C300SD/12deg-12deg | Z/892 | 40 | +0.000 | +4.989 | 76
2 x MULLION | C250SD/12deg-12deg | Z/892 | 40 | +0.000 | +4.989 | 76
2 x MULLION | C250SD/12deg-12deg | Z/913 | 79 | +0.000 | +5.281 | 125
2 x MULLION | C250SD/12deg-12deg | Z/906 | 64.2 | +0.000 | +5.136 | 96
2 x MULLION | C250SD/12deg-12deg | Z/885 | 34.4 | +0.000 | +4.840 | 76
4 x RAFTER | C250SD-C300SD/12deg-12deg | Z/705 | 31.2 | +4.658 | +5.716 | 76
4 x RAFTER | C250SD/12deg-12deg | Z/705 | 31.2 | +4.658 | +5.716 | 76
2 x MULLION TOP PLATE | C250SD/15deg-15deg | PL/1470 | 0.9 | +4.765 | +4.878 | 111.092
2 x MULLION TOP PLATE | C250SD/15deg-15deg | PL/1477 | 1.2 | +4.953 | +5.065 | 111.097
2 x MULLION TOP PLATE | C250SD/15deg-15deg | PL/1484 | 1.6 | +5.138 | +5.250 | 111.093
2 x MULLION TOP PLATE | C250SD/15deg-15deg | PL/1491 | 1.8 | +5.321 | +5.434 | 111.092
2 x MULLION TOP PLATE | C250SD-C300SD/15deg-15deg | PL/1470 | 0.9 | +4.765 | +4.878 | 111.092
2 x MULLION TOP PLATE | C250SD-C300SD/15deg-15deg | PL/1477 | 1.2 | +4.953 | +5.065 | 111.097
2 x MULLION TOP PLATE | C250SD-C300SD/15deg-15deg | PL/1484 | 1.6 | +5.138 | +5.250 | 111.093
2 x MULLION TOP PLATE | C250SD-C300SD/15deg-15deg | PL/1491 | 1.8 | +5.321 | +5.434 | 111.092
2 x MULLION | C250SD-C300SD/15deg-15deg | Z/914 | 80.9 | +0.000 | +5.411 | 125
2 x MULLION | C250SD-C300SD/15deg-15deg | Z/907 | 65.4 | +0.000 | +5.228 | 96
2 x MULLION | C250SD-C300SD/15deg-15deg | Z/886 | 34.4 | +0.000 | +4.855 | 76
2 x MULLION | C250SD-C300SD/15deg-15deg | Z/895 | 40.5 | +0.000 | +5.043 | 76
2 x MULLION | C250SD/15deg-15deg | Z/914 | 80.9 | +0.000 | +5.411 | 125
2 x MULLION | C250SD/15deg-15deg | Z/907 | 65.4 | +0.000 | +5.228 | 96
2 x MULLION | C250SD/15deg-15deg | Z/886 | 34.4 | +0.000 | +4.855 | 76
2 x MULLION | C250SD/15deg-15deg | Z/895 | 40.5 | +0.000 | +5.043 | 76
4 x RAFTER | C250SD-C300SD/15deg-15deg | Z/748 | 31.2 | +4.620 | +5.872 | 76
4 x RAFTER | C250SD/15deg-15deg | Z/748 | 31.2 | +4.620 | +5.872 | 76
2 x MULLION TOP PLATE | C250SD/18deg-18deg | PL/1471 | 0.9 | +4.781 | +4.893 | 109.379
2 x MULLION TOP PLATE | C250SD/18deg-18deg | PL/1478 | 1.2 | +5.008 | +5.120 | 109.383
2 x MULLION TOP PLATE | C250SD/18deg-18deg | PL/1485 | 1.6 | +5.232 | +5.344 | 109.378
2 x MULLION TOP PLATE | C250SD/18deg-18deg | PL/1492 | 1.8 | +5.455 | +5.567 | 109.381
2 x MULLION TOP PLATE | C250SD-C300SD/18deg-18deg | PL/1471 | 0.9 | +4.781 | +4.893 | 109.379
2 x MULLION TOP PLATE | C250SD-C300SD/18deg-18deg | PL/1478 | 1.2 | +5.008 | +5.120 | 109.383
2 x MULLION TOP PLATE | C250SD-C300SD/18deg-18deg | PL/1485 | 1.6 | +5.232 | +5.344 | 109.378
2 x MULLION TOP PLATE | C250SD-C300SD/18deg-18deg | PL/1492 | 1.8 | +5.455 | +5.567 | 109.381
2 x MULLION | C250SD-C300SD/18deg-18deg | Z/915 | 82.9 | +0.000 | +5.545 | 125
2 x MULLION | C250SD-C300SD/18deg-18deg | Z/908 | 66.6 | +0.000 | +5.322 | 96
2 x MULLION | C250SD-C300SD/18deg-18deg | Z/887 | 34.5 | +0.000 | +4.871 | 76
2 x MULLION | C250SD-C300SD/18deg-18deg | Z/896 | 40.9 | +0.000 | +5.098 | 76
2 x MULLION | C250SD/18deg-18deg | Z/915 | 82.9 | +0.000 | +5.545 | 125
2 x MULLION | C250SD/18deg-18deg | Z/908 | 66.6 | +0.000 | +5.322 | 96
2 x MULLION | C250SD/18deg-18deg | Z/887 | 34.5 | +0.000 | +4.871 | 76
2 x MULLION | C250SD/18deg-18deg | Z/896 | 40.9 | +0.000 | +5.098 | 76
4 x RAFTER | C250SD-C300SD/18deg-18deg | Z/749 | 31.2 | +4.580 | +6.024 | 76
4 x RAFTER | C250SD/18deg-18deg | Z/749 | 31.2 | +4.580 | +6.024 | 76
2 x MULLION TOP PLATE | C250SD/25deg-25deg | PL/1472 | 0.9 | +4.819 | +4.929 | 104.235
2 x MULLION TOP PLATE | C250SD/25deg-25deg | PL/1479 | 1.2 | +5.146 | +5.256 | 104.232
2 x MULLION TOP PLATE | C250SD/25deg-25deg | PL/1486 | 1.5 | +5.467 | +5.577 | 104.234
2 x MULLION TOP PLATE | C250SD/25deg-25deg | PL/1493 | 1.8 | +5.787 | +5.897 | 104.229
2 x MULLION TOP PLATE | C250SD-C300SD/25deg-25deg | PL/1472 | 0.9 | +4.819 | +4.929 | 104.235
2 x MULLION TOP PLATE | C250SD-C300SD/25deg-25deg | PL/1479 | 1.2 | +5.146 | +5.256 | 104.232
2 x MULLION TOP PLATE | C250SD-C300SD/25deg-25deg | PL/1486 | 1.5 | +5.467 | +5.577 | 104.234
2 x MULLION TOP PLATE | C250SD-C300SD/25deg-25deg | PL/1493 | 1.8 | +5.787 | +5.897 | 104.229
2 x MULLION | C250SD-C300SD/25deg-25deg | Z/916 | 87.9 | +0.000 | +5.877 | 125
2 x MULLION | C250SD-C300SD/25deg-25deg | Z/909 | 69.5 | +0.000 | +5.557 | 96
2 x MULLION | C250SD-C300SD/25deg-25deg | Z/888 | 34.8 | +0.000 | +4.909 | 76
2 x MULLION | C250SD-C300SD/25deg-25deg | Z/898 | 42 | +0.000 | +5.236 | 76
2 x MULLION | C250SD/25deg-25deg | Z/916 | 87.9 | +0.000 | +5.877 | 125
2 x MULLION | C250SD/25deg-25deg | Z/909 | 69.5 | +0.000 | +5.557 | 96
2 x MULLION | C250SD/25deg-25deg | Z/888 | 34.8 | +0.000 | +4.909 | 76
2 x MULLION | C250SD/25deg-25deg | Z/898 | 42 | +0.000 | +5.236 | 76
4 x RAFTER | C250SD-C300SD/25deg-25deg | Z/750 | 31.2 | +4.481 | +6.355 | 76
4 x RAFTER | C250SD/25deg-25deg | Z/750 | 31.2 | +4.481 | +6.355 | 76
2 x MULLION TOP PLATE | C200SD-C250SD/25deg-25deg | PL/1493 | 1.8 | +5.843 | +5.953 | 104.227
2 x MULLION TOP PLATE | C200SD-C250SD/25deg-25deg | PL/1486 | 1.5 | +5.523 | +5.633 | 104.231
2 x MULLION TOP PLATE | C200SD-C250SD/25deg-25deg | PL/1479 | 1.2 | +5.202 | +5.312 | 104.228
2 x MULLION | C200SD-C250SD/25deg-25deg | Z/882 | 88.7 | +0.000 | +5.933 | 125
2 x MULLION | C200SD-C250SD/25deg-25deg | Z/875 | 70.2 | +0.000 | +5.613 | 96
2 x MULLION | C200SD-C250SD/25deg-25deg | Z/868 | 42.5 | +0.000 | +5.292 | 76
2 x MULLION TOP PLATE | C200SD-C250SD/25deg-25deg | PL/1472 | 0.9 | +4.875 | +4.985 | 104.231
2 x MULLION | C200SD-C250SD/25deg-25deg | Z/859 | 35.2 | +0.000 | +4.965 | 76
2 x MULLION TOP PLATE | C200SD/25deg-25deg | PL/1493 | 1.8 | +5.843 | +5.953 | 104.227
2 x MULLION TOP PLATE | C200SD/25deg-25deg | PL/1486 | 1.5 | +5.523 | +5.633 | 104.231
2 x MULLION TOP PLATE | C200SD/25deg-25deg | PL/1479 | 1.2 | +5.202 | +5.312 | 104.228
2 x MULLION | C200SD/25deg-25deg | Z/882 | 88.7 | +0.000 | +5.933 | 125
2 x MULLION | C200SD/25deg-25deg | Z/875 | 70.2 | +0.000 | +5.613 | 96
2 x MULLION | C200SD/25deg-25deg | Z/868 | 42.5 | +0.000 | +5.292 | 76
2 x MULLION TOP PLATE | C200SD/25deg-25deg | PL/1472 | 0.9 | +4.875 | +4.985 | 104.231
2 x MULLION | C200SD/25deg-25deg | Z/859 | 35.2 | +0.000 | +4.965 | 76
4 x RAFTER | C200SD-C250SD/25deg-25deg | Z/701 | 27.8 | +4.520 | +6.364 | 76
4 x RAFTER | C200SD/25deg-25deg | Z/701 | 27.8 | +4.520 | +6.364 | 76
2 x MULLION TOP PLATE | C200SD-C250SD/18deg-18deg | PL/1492 | 1.8 | +5.506 | +5.618 | 109.374
2 x MULLION TOP PLATE | C200SD-C250SD/18deg-18deg | PL/1485 | 1.6 | +5.283 | +5.395 | 109.38
2 x MULLION TOP PLATE | C200SD-C250SD/18deg-18deg | PL/1478 | 1.2 | +5.059 | +5.171 | 109.374
2 x MULLION | C200SD-C250SD/18deg-18deg | Z/881 | 83.7 | +0.000 | +5.596 | 125
2 x MULLION | C200SD-C250SD/18deg-18deg | Z/874 | 67.2 | +0.000 | +5.373 | 96
2 x MULLION | C200SD-C250SD/18deg-18deg | Z/867 | 41.3 | +0.000 | +5.149 | 76
2 x MULLION TOP PLATE | C200SD-C250SD/18deg-18deg | PL/1471 | 0.9 | +4.832 | +4.943 | 109.379
2 x MULLION | C200SD-C250SD/18deg-18deg | Z/858 | 34.8 | +0.000 | +4.922 | 76
2 x MULLION TOP PLATE | C200SD/18deg-18deg | PL/1492 | 1.8 | +5.506 | +5.618 | 109.374
2 x MULLION TOP PLATE | C200SD/18deg-18deg | PL/1485 | 1.6 | +5.283 | +5.395 | 109.38
2 x MULLION TOP PLATE | C200SD/18deg-18deg | PL/1478 | 1.2 | +5.059 | +5.171 | 109.374
2 x MULLION | C200SD/18deg-18deg | Z/881 | 83.7 | +0.000 | +5.596 | 125
2 x MULLION | C200SD/18deg-18deg | Z/874 | 67.2 | +0.000 | +5.373 | 96
2 x MULLION | C200SD/18deg-18deg | Z/867 | 41.3 | +0.000 | +5.149 | 76
2 x MULLION TOP PLATE | C200SD/18deg-18deg | PL/1471 | 0.9 | +4.832 | +4.943 | 109.379
2 x MULLION | C200SD/18deg-18deg | Z/858 | 34.8 | +0.000 | +4.922 | 76
4 x RAFTER | C200SD-C250SD/18deg-18deg | Z/703 | 27.8 | +4.619 | +6.026 | 76
4 x RAFTER | C200SD/18deg-18deg | Z/703 | 27.8 | +4.619 | +6.026 | 76
2 x MULLION TOP PLATE | C200SD/15deg-15deg | PL/1470 | 0.9 | +4.814 | +4.926 | 111.086
2 x MULLION TOP PLATE | C200SD/15deg-15deg | PL/1477 | 1.2 | +5.002 | +5.114 | 111.082
2 x MULLION TOP PLATE | C200SD/15deg-15deg | PL/1484 | 1.6 | +5.186 | +5.299 | 111.088
2 x MULLION TOP PLATE | C200SD/15deg-15deg | PL/1491 | 1.8 | +5.370 | +5.483 | 111.088
2 x MULLION TOP PLATE | C200SD-C250SD/15deg-15deg | PL/1470 | 0.9 | +4.814 | +4.926 | 111.086
2 x MULLION TOP PLATE | C200SD-C250SD/15deg-15deg | PL/1477 | 1.2 | +5.002 | +5.114 | 111.082
2 x MULLION TOP PLATE | C200SD-C250SD/15deg-15deg | PL/1484 | 1.6 | +5.186 | +5.299 | 111.088
2 x MULLION TOP PLATE | C200SD-C250SD/15deg-15deg | PL/1491 | 1.8 | +5.370 | +5.483 | 111.088
2 x MULLION | C200SD-C250SD/15deg-15deg | Z/880 | 81.7 | +0.000 | +5.460 | 125
2 x MULLION | C200SD-C250SD/15deg-15deg | Z/873 | 66 | +0.000 | +5.276 | 96
2 x MULLION | C200SD-C250SD/15deg-15deg | Z/864 | 40.8 | +0.000 | +5.092 | 76
2 x MULLION | C200SD-C250SD/15deg-15deg | Z/857 | 34.8 | +0.000 | +4.904 | 76
2 x MULLION | C200SD/15deg-15deg | Z/880 | 81.7 | +0.000 | +5.460 | 125
2 x MULLION | C200SD/15deg-15deg | Z/873 | 66 | +0.000 | +5.276 | 96
2 x MULLION | C200SD/15deg-15deg | Z/864 | 40.8 | +0.000 | +5.092 | 76
2 x MULLION | C200SD/15deg-15deg | Z/857 | 34.8 | +0.000 | +4.904 | 76
4 x RAFTER | C200SD-C250SD/15deg-15deg | Z/701 | 27.8 | +4.659 | +5.871 | 76
4 x RAFTER | C200SD/15deg-15deg | Z/701 | 27.8 | +4.659 | +5.871 | 76
2 x MULLION TOP PLATE | C200SD-C250SD/12deg-12deg | PL/1490 | 1.8 | +5.238 | +5.351 | 125.891
2 x MULLION TOP PLATE | C200SD-C250SD/12deg-12deg | PL/1483 | 1.6 | +5.092 | +5.205 | 125.896
2 x MULLION TOP PLATE | C200SD-C250SD/12deg-12deg | PL/1476 | 1.2 | +4.946 | +5.059 | 125.891
2 x MULLION | C200SD-C250SD/12deg-12deg | Z/879 | 79.6 | +0.000 | +5.328 | 125
2 x MULLION | C200SD-C250SD/12deg-12deg | Z/872 | 64.8 | +0.000 | +5.182 | 96
2 x MULLION | C200SD-C250SD/12deg-12deg | Z/863 | 40.5 | +0.000 | +5.036 | 76
2 x MULLION TOP PLATE | C200SD-C250SD/12deg-12deg | PL/1469 | 0.9 | +4.797 | +4.910 | 112.495
2 x MULLION | C200SD-C250SD/12deg-12deg | Z/856 | 34.6 | +0.000 | +4.887 | 76
2 x MULLION TOP PLATE | C200SD/12deg-12deg | PL/1490 | 1.8 | +5.238 | +5.351 | 125.891
2 x MULLION TOP PLATE | C200SD/12deg-12deg | PL/1483 | 1.6 | +5.092 | +5.205 | 125.896
2 x MULLION TOP PLATE | C200SD/12deg-12deg | PL/1476 | 1.2 | +4.946 | +5.059 | 125.891
2 x MULLION | C200SD/12deg-12deg | Z/879 | 79.6 | +0.000 | +5.328 | 125
2 x MULLION | C200SD/12deg-12deg | Z/872 | 64.8 | +0.000 | +5.182 | 96
2 x MULLION | C200SD/12deg-12deg | Z/863 | 40.5 | +0.000 | +5.036 | 76
2 x MULLION TOP PLATE | C200SD/12deg-12deg | PL/1469 | 0.9 | +4.797 | +4.910 | 112.495
2 x MULLION | C200SD/12deg-12deg | Z/856 | 34.6 | +0.000 | +4.887 | 76
4 x RAFTER | C200SD-C250SD/12deg-12deg | Z/696 | 27.8 | +4.698 | +5.713 | 76
4 x RAFTER | C200SD/12deg-12deg | Z/696 | 27.8 | +4.698 | +5.713 | 76
2 x MULLION TOP PLATE | C200SD-C250SD/9deg-9deg | PL/1489 | 1.8 | +5.109 | +5.223 | 113.592
2 x MULLION TOP PLATE | C200SD-C250SD/9deg-9deg | PL/1482 | 1.6 | +5.001 | +5.115 | 113.588
2 x MULLION TOP PLATE | C200SD-C250SD/9deg-9deg | PL/1475 | 1.2 | +4.892 | +5.005 | 113.592
2 x MULLION TOP PLATE | C200SD-C250SD/9deg-9deg | PL/1468 | 0.9 | +4.781 | +4.894 | 113.591
2 x MULLION | C200SD-C250SD/9deg-9deg | Z/878 | 77.8 | +0.000 | +5.199 | 125
2 x MULLION | C200SD-C250SD/9deg-9deg | Z/871 | 63.7 | +0.000 | +5.091 | 96
2 x MULLION | C200SD-C250SD/9deg-9deg | Z/862 | 40 | +0.000 | +4.982 | 76
2 x MULLION | C200SD-C250SD/9deg-9deg | Z/855 | 34.5 | +0.000 | +4.871 | 76
2 x MULLION TOP PLATE | C200SD/9deg-9deg | PL/1489 | 1.8 | +5.109 | +5.223 | 113.592
2 x MULLION TOP PLATE | C200SD/9deg-9deg | PL/1482 | 1.6 | +5.001 | +5.115 | 113.588
2 x MULLION TOP PLATE | C200SD/9deg-9deg | PL/1475 | 1.2 | +4.892 | +5.005 | 113.592
2 x MULLION TOP PLATE | C200SD/9deg-9deg | PL/1468 | 0.9 | +4.781 | +4.894 | 113.591
2 x MULLION | C200SD/9deg-9deg | Z/878 | 77.8 | +0.000 | +5.199 | 125
2 x MULLION | C200SD/9deg-9deg | Z/871 | 63.7 | +0.000 | +5.091 | 96
2 x MULLION | C200SD/9deg-9deg | Z/862 | 40 | +0.000 | +4.982 | 76
2 x MULLION | C200SD/9deg-9deg | Z/855 | 34.5 | +0.000 | +4.871 | 76
2 x RAFTER | C200SD-C250SD/9deg-9deg | Z/701 | 27.8 | +4.734 | +5.549 | 76
2 x RAFTER | C200SD-C250SD/9deg-9deg | Z/726 | 27.8 | +4.734 | +5.549 | 76
2 x RAFTER | C200SD/9deg-9deg | Z/701 | 27.8 | +4.734 | +5.549 | 76
2 x RAFTER | C200SD/9deg-9deg | Z/726 | 27.8 | +4.734 | +5.549 | 76
2 x MULLION TOP PLATE | C200SD-C250SD/5deg-5deg | PL/1488 | 1.9 | +4.939 | +5.054 | 114.562
2 x MULLION TOP PLATE | C200SD-C250SD/5deg-5deg | PL/1481 | 1.6 | +4.879 | +4.994 | 114.568
2 x MULLION TOP PLATE | C200SD-C250SD/5deg-5deg | PL/1474 | 1.2 | +4.819 | +4.933 | 114.57
2 x MULLION TOP PLATE | C200SD-C250SD/5deg-5deg | PL/1467 | 0.9 | +4.758 | +4.872 | 114.566
2 x MULLION | C200SD-C250SD/5deg-5deg | Z/877 | 75.2 | +0.000 | +5.029 | 125
2 x MULLION | C200SD-C250SD/5deg-5deg | Z/870 | 62.1 | +0.000 | +4.969 | 96
2 x MULLION | C200SD-C250SD/5deg-5deg | Z/861 | 39.4 | +0.000 | +4.909 | 76
2 x MULLION | C200SD-C250SD/5deg-5deg | Z/854 | 34.4 | +0.000 | +4.848 | 76
2 x MULLION TOP PLATE | C200SD/5deg-5deg | PL/1488 | 1.9 | +4.939 | +5.054 | 114.562
2 x MULLION TOP PLATE | C200SD/5deg-5deg | PL/1481 | 1.6 | +4.879 | +4.994 | 114.568
2 x MULLION TOP PLATE | C200SD/5deg-5deg | PL/1474 | 1.2 | +4.819 | +4.933 | 114.57
2 x MULLION TOP PLATE | C200SD/5deg-5deg | PL/1467 | 0.9 | +4.758 | +4.872 | 114.566
2 x MULLION | C200SD/5deg-5deg | Z/877 | 75.2 | +0.000 | +5.029 | 125
2 x MULLION | C200SD/5deg-5deg | Z/870 | 62.1 | +0.000 | +4.969 | 96
2 x MULLION | C200SD/5deg-5deg | Z/861 | 39.4 | +0.000 | +4.909 | 76
2 x MULLION | C200SD/5deg-5deg | Z/854 | 34.4 | +0.000 | +4.848 | 76
4 x RAFTER | C200SD-C250SD/5deg-5deg | Z/699 | 27.8 | +4.783 | +5.328 | 76
4 x RAFTER | C200SD/5deg-5deg | Z/699 | 27.8 | +4.783 | +5.328 | 76
2 x MULLION TOP PLATE | C200SD-C250SD/3deg-3deg | PL/1487 | 1.9 | +4.855 | +4.970 | 114.85
2 x MULLION TOP PLATE | C200SD-C250SD/3deg-3deg | PL/1480 | 1.6 | +4.819 | +4.934 | 114.843
2 x MULLION TOP PLATE | C200SD-C250SD/3deg-3deg | PL/1473 | 1.2 | +4.783 | +4.898 | 114.851
2 x MULLION | C200SD-C250SD/3deg-3deg | Z/876 | 74 | +0.000 | +4.945 | 125
2 x MULLION | C200SD-C250SD/3deg-3deg | Z/869 | 61.4 | +0.000 | +4.909 | 96
2 x MULLION | C200SD-C250SD/3deg-3deg | Z/860 | 39.1 | +0.000 | +4.873 | 76
2 x MULLION TOP PLATE | C200SD-C250SD/3deg-3deg | PL/1466 | 0.9 | +4.746 | +4.861 | 114.844
2 x MULLION | C200SD-C250SD/3deg-3deg | Z/853 | 34.4 | +0.000 | +4.836 | 76
2 x MULLION TOP PLATE | C200SD/3deg-3deg | PL/1487 | 1.9 | +4.855 | +4.970 | 114.85
2 x MULLION TOP PLATE | C200SD/3deg-3deg | PL/1480 | 1.6 | +4.819 | +4.934 | 114.843
2 x MULLION TOP PLATE | C200SD/3deg-3deg | PL/1473 | 1.2 | +4.783 | +4.898 | 114.851
2 x MULLION | C200SD/3deg-3deg | Z/876 | 74 | +0.000 | +4.945 | 125
2 x MULLION | C200SD/3deg-3deg | Z/869 | 61.4 | +0.000 | +4.909 | 96
2 x MULLION | C200SD/3deg-3deg | Z/860 | 39.1 | +0.000 | +4.873 | 76
2 x MULLION TOP PLATE | C200SD/3deg-3deg | PL/1466 | 0.9 | +4.746 | +4.861 | 114.844
2 x MULLION | C200SD/3deg-3deg | Z/853 | 34.4 | +0.000 | +4.836 | 76
4 x RAFTER | C200SD-C250SD/3deg-3deg | Z/697 | 27.8 | +4.807 | +5.216 | 76
4 x RAFTER | C200SD/3deg-3deg | Z/697 | 27.8 | +4.807 | +5.216 | 76
2 x MULLION TOP PLATE | C150SD-C200SD/25deg-25deg | PL/1458 | 1.9 | +5.899 | +6.009 | 104.227
2 x MULLION TOP PLATE | C150SD-C200SD/25deg-25deg | PL/1451 | 1.6 | +5.580 | +5.690 | 104.231
2 x MULLION TOP PLATE | C150SD-C200SD/25deg-25deg | PL/1444 | 1.5 | +5.258 | +5.368 | 104.228
2 x MULLION | C150SD-C200SD/25deg-25deg | Z/852 | 89.6 | +0.000 | +5.989 | 125
2 x MULLION | C150SD-C200SD/25deg-25deg | Z/847 | 70.9 | +0.000 | +5.670 | 96
2 x MULLION | C150SD-C200SD/25deg-25deg | Z/312 | 42.9 | +0.000 | +5.348 | 76
2 x MULLION TOP PLATE | C150SD-C200SD/25deg-25deg | PL/1437 | 1.1 | +4.931 | +5.041 | 104.231
2 x MULLION | C150SD-C200SD/25deg-25deg | Z/199 | 35.6 | +0.000 | +5.021 | 76
2 x MULLION TOP PLATE | C150SD/25deg-25deg | PL/1458 | 1.9 | +5.899 | +6.009 | 104.227
2 x MULLION TOP PLATE | C150SD/25deg-25deg | PL/1451 | 1.6 | +5.580 | +5.690 | 104.231
2 x MULLION TOP PLATE | C150SD/25deg-25deg | PL/1444 | 1.5 | +5.258 | +5.368 | 104.228
2 x MULLION | C150SD/25deg-25deg | Z/852 | 89.6 | +0.000 | +5.989 | 125
2 x MULLION | C150SD/25deg-25deg | Z/847 | 70.9 | +0.000 | +5.670 | 96
2 x MULLION | C150SD/25deg-25deg | Z/312 | 42.9 | +0.000 | +5.348 | 76
2 x MULLION TOP PLATE | C150SD/25deg-25deg | PL/1437 | 1.1 | +4.931 | +5.041 | 104.231
2 x MULLION | C150SD/25deg-25deg | Z/199 | 35.6 | +0.000 | +5.021 | 76
4 x RAFTER | C150SD-C200SD/25deg-25deg | Z/158 | 21.9 | +4.566 | +6.364 | 64
4 x RAFTER | C150SD/25deg-25deg | Z/158 | 21.9 | +4.566 | +6.364 | 64
2 x MULLION TOP PLATE | C150SD-C200SD/18deg-18deg | PL/1457 | 1.9 | +5.560 | +5.671 | 109.374
2 x MULLION TOP PLATE | C150SD-C200SD/18deg-18deg | PL/1450 | 1.6 | +5.337 | +5.449 | 109.38
2 x MULLION TOP PLATE | C150SD-C200SD/18deg-18deg | PL/1443 | 1.5 | +5.113 | +5.224 | 109.374
2 x MULLION | C150SD-C200SD/18deg-18deg | Z/851 | 84.5 | +0.000 | +5.650 | 125
2 x MULLION | C150SD-C200SD/18deg-18deg | Z/838 | 67.9 | +0.000 | +5.427 | 96
2 x MULLION | C150SD-C200SD/18deg-18deg | Z/311 | 41.7 | +0.000 | +5.203 | 76
2 x MULLION TOP PLATE | C150SD-C200SD/18deg-18deg | PL/1436 | 1.1 | +4.885 | +4.997 | 109.379
2 x MULLION | C150SD-C200SD/18deg-18deg | Z/196 | 35.3 | +0.000 | +4.975 | 76
2 x MULLION TOP PLATE | C150SD/18deg-18deg | PL/1457 | 1.9 | +5.560 | +5.671 | 109.374
2 x MULLION TOP PLATE | C150SD/18deg-18deg | PL/1450 | 1.6 | +5.337 | +5.449 | 109.38
2 x MULLION TOP PLATE | C150SD/18deg-18deg | PL/1443 | 1.5 | +5.113 | +5.224 | 109.374
2 x MULLION | C150SD/18deg-18deg | Z/851 | 84.5 | +0.000 | +5.650 | 125
2 x MULLION | C150SD/18deg-18deg | Z/838 | 67.9 | +0.000 | +5.427 | 96
2 x MULLION | C150SD/18deg-18deg | Z/311 | 41.7 | +0.000 | +5.203 | 76
2 x MULLION TOP PLATE | C150SD/18deg-18deg | PL/1436 | 1.1 | +4.885 | +4.997 | 109.379
2 x MULLION | C150SD/18deg-18deg | Z/196 | 35.3 | +0.000 | +4.975 | 76
4 x RAFTER | C150SD-C200SD/18deg-18deg | Z/175 | 21.9 | +4.667 | +6.026 | 64
4 x RAFTER | C150SD/18deg-18deg | Z/175 | 21.9 | +4.667 | +6.026 | 64
2 x MULLION TOP PLATE | C150SD-C200SD/15deg-15deg | PL/1456 | 1.9 | +5.423 | +5.535 | 111.088
2 x MULLION TOP PLATE | C150SD-C200SD/15deg-15deg | PL/1449 | 1.6 | +5.239 | +5.352 | 111.088
2 x MULLION TOP PLATE | C150SD-C200SD/15deg-15deg | PL/1442 | 1.5 | +5.054 | +5.167 | 111.082
2 x MULLION | C150SD-C200SD/15deg-15deg | Z/850 | 82.4 | +0.000 | +5.513 | 125
2 x MULLION | C150SD-C200SD/15deg-15deg | Z/837 | 66.6 | +0.000 | +5.329 | 96
2 x MULLION | C150SD-C200SD/15deg-15deg | Z/279 | 41.3 | +0.000 | +5.144 | 76
2 x MULLION TOP PLATE | C150SD-C200SD/15deg-15deg | PL/1435 | 1.1 | +4.867 | +4.979 | 111.086
2 x MULLION | C150SD-C200SD/15deg-15deg | Z/179 | 35.1 | +0.000 | +4.957 | 76
2 x MULLION TOP PLATE | C150SD/15deg-15deg | PL/1456 | 1.9 | +5.423 | +5.535 | 111.088
2 x MULLION TOP PLATE | C150SD/15deg-15deg | PL/1449 | 1.6 | +5.239 | +5.352 | 111.088
2 x MULLION TOP PLATE | C150SD/15deg-15deg | PL/1442 | 1.5 | +5.054 | +5.167 | 111.082
2 x MULLION | C150SD/15deg-15deg | Z/850 | 82.4 | +0.000 | +5.513 | 125
2 x MULLION | C150SD/15deg-15deg | Z/837 | 66.6 | +0.000 | +5.329 | 96
2 x MULLION | C150SD/15deg-15deg | Z/279 | 41.3 | +0.000 | +5.144 | 76
2 x MULLION TOP PLATE | C150SD/15deg-15deg | PL/1435 | 1.1 | +4.867 | +4.979 | 111.086
2 x MULLION | C150SD/15deg-15deg | Z/179 | 35.1 | +0.000 | +4.957 | 76
4 x RAFTER | C150SD-C200SD/15deg-15deg | Z/158 | 21.9 | +4.708 | +5.871 | 64
4 x RAFTER | C150SD/15deg-15deg | Z/158 | 21.9 | +4.708 | +5.871 | 64
2 x MULLION TOP PLATE | C150SD-C200SD/12deg-12deg | PL/1455 | 1.9 | +5.290 | +5.403 | 125.891
2 x MULLION TOP PLATE | C150SD-C200SD/12deg-12deg | PL/1448 | 1.6 | +5.145 | +5.258 | 125.896
2 x MULLION TOP PLATE | C150SD-C200SD/12deg-12deg | PL/1441 | 1.5 | +4.998 | +5.111 | 125.891
2 x MULLION | C150SD-C200SD/12deg-12deg | Z/849 | 80.5 | +0.000 | +5.380 | 125
2 x MULLION | C150SD-C200SD/12deg-12deg | Z/836 | 65.4 | +0.000 | +5.235 | 96
2 x MULLION | C150SD-C200SD/12deg-12deg | Z/278 | 40.8 | +0.000 | +5.088 | 76
2 x MULLION TOP PLATE | C150SD-C200SD/12deg-12deg | PL/1434 | 1.1 | +4.849 | +4.962 | 112.495
2 x MULLION | C150SD-C200SD/12deg-12deg | Z/178 | 35 | +0.000 | +4.939 | 76
2 x MULLION TOP PLATE | C150SD/12deg-12deg | PL/1455 | 1.9 | +5.290 | +5.403 | 125.891
2 x MULLION TOP PLATE | C150SD/12deg-12deg | PL/1448 | 1.6 | +5.145 | +5.258 | 125.896
2 x MULLION TOP PLATE | C150SD/12deg-12deg | PL/1441 | 1.5 | +4.998 | +5.111 | 125.891
2 x MULLION | C150SD/12deg-12deg | Z/849 | 80.5 | +0.000 | +5.380 | 125
2 x MULLION | C150SD/12deg-12deg | Z/836 | 65.4 | +0.000 | +5.235 | 96
2 x MULLION | C150SD/12deg-12deg | Z/278 | 40.8 | +0.000 | +5.088 | 76
2 x MULLION TOP PLATE | C150SD/12deg-12deg | PL/1434 | 1.1 | +4.849 | +4.962 | 112.495
2 x MULLION | C150SD/12deg-12deg | Z/178 | 35 | +0.000 | +4.939 | 76
4 x RAFTER | C150SD-C200SD/12deg-12deg | Z/159 | 21.9 | +4.748 | +5.713 | 64
4 x RAFTER | C150SD/12deg-12deg | Z/159 | 21.9 | +4.748 | +5.713 | 64
2 x MULLION TOP PLATE | C150SD/9deg-9deg | PL/1433 | 1.1 | +4.832 | +4.946 | 113.591
2 x MULLION TOP PLATE | C150SD/9deg-9deg | PL/1440 | 1.5 | +4.943 | +5.057 | 113.592
2 x MULLION TOP PLATE | C150SD/9deg-9deg | PL/1447 | 1.6 | +5.053 | +5.166 | 113.588
2 x MULLION TOP PLATE | C150SD/9deg-9deg | PL/1454 | 1.9 | +5.161 | +5.275 | 113.592
2 x MULLION TOP PLATE | C150SD-C200SD/9deg-9deg | PL/1433 | 1.1 | +4.832 | +4.946 | 113.591
2 x MULLION TOP PLATE | C150SD-C200SD/9deg-9deg | PL/1440 | 1.5 | +4.943 | +5.057 | 113.592
2 x MULLION TOP PLATE | C150SD-C200SD/9deg-9deg | PL/1447 | 1.6 | +5.053 | +5.166 | 113.588
2 x MULLION TOP PLATE | C150SD-C200SD/9deg-9deg | PL/1454 | 1.9 | +5.161 | +5.275 | 113.592
2 x MULLION | C150SD-C200SD/9deg-9deg | Z/848 | 78.4 | +0.000 | +5.251 | 125
2 x MULLION | C150SD-C200SD/9deg-9deg | Z/835 | 64.2 | +0.000 | +5.143 | 96
2 x MULLION | C150SD-C200SD/9deg-9deg | Z/270 | 40.5 | +0.000 | +5.033 | 76
2 x MULLION | C150SD-C200SD/9deg-9deg | Z/176 | 34.8 | +0.000 | +4.922 | 76
2 x MULLION | C150SD/9deg-9deg | Z/176 | 34.8 | +0.000 | +4.922 | 76
2 x MULLION | C150SD/9deg-9deg | Z/848 | 78.4 | +0.000 | +5.251 | 125
2 x MULLION | C150SD/9deg-9deg | Z/835 | 64.2 | +0.000 | +5.143 | 96
2 x MULLION | C150SD/9deg-9deg | Z/270 | 40.5 | +0.000 | +5.033 | 76
2 x RAFTER | C150SD-C200SD/9deg-9deg | Z/158 | 21.9 | +4.784 | +5.549 | 64
2 x RAFTER | C150SD-C200SD/9deg-9deg | Z/269 | 21.9 | +4.784 | +5.549 | 64
2 x RAFTER | C150SD/9deg-9deg | Z/158 | 21.9 | +4.784 | +5.549 | 64
2 x RAFTER | C150SD/9deg-9deg | Z/269 | 21.9 | +4.784 | +5.549 | 64
2 x MULLION TOP PLATE | C150SD/5deg-5deg | PL/1432 | 1.1 | +4.809 | +4.923 | 114.566
2 x MULLION TOP PLATE | C150SD/5deg-5deg | PL/1439 | 1.5 | +4.870 | +4.985 | 114.57
2 x MULLION TOP PLATE | C150SD/5deg-5deg | PL/1446 | 1.6 | +4.931 | +5.045 | 114.568
2 x MULLION TOP PLATE | C150SD/5deg-5deg | PL/1453 | 1.9 | +4.991 | +5.105 | 114.562
2 x MULLION TOP PLATE | C150SD-C200SD/5deg-5deg | PL/1432 | 1.1 | +4.809 | +4.923 | 114.566
2 x MULLION TOP PLATE | C150SD-C200SD/5deg-5deg | PL/1439 | 1.5 | +4.870 | +4.985 | 114.57
2 x MULLION TOP PLATE | C150SD-C200SD/5deg-5deg | PL/1446 | 1.6 | +4.931 | +5.045 | 114.568
2 x MULLION TOP PLATE | C150SD-C200SD/5deg-5deg | PL/1453 | 1.9 | +4.991 | +5.105 | 114.562
2 x MULLION | C150SD-C200SD/5deg-5deg | Z/141 | 34.7 | +0.000 | +4.899 | 76
2 x MULLION | C150SD-C200SD/5deg-5deg | Z/157 | 76 | +0.000 | +5.081 | 125
2 x MULLION | C150SD-C200SD/5deg-5deg | Z/156 | 62.8 | +0.000 | +5.021 | 96
2 x MULLION | C150SD-C200SD/5deg-5deg | Z/155 | 39.8 | +0.000 | +4.960 | 76
2 x MULLION | C150SD/5deg-5deg | Z/141 | 34.7 | +0.000 | +4.899 | 76
2 x MULLION | C150SD/5deg-5deg | Z/157 | 76 | +0.000 | +5.081 | 125
2 x MULLION | C150SD/5deg-5deg | Z/156 | 62.8 | +0.000 | +5.021 | 96
2 x MULLION | C150SD/5deg-5deg | Z/155 | 39.8 | +0.000 | +4.960 | 76
4 x RAFTER | C150SD-C200SD/5deg-5deg | Z/140 | 21.9 | +4.834 | +5.328 | 64
4 x RAFTER | C150SD/5deg-5deg | Z/140 | 21.9 | +4.834 | +5.328 | 64
2 x MULLION TOP PLATE | C150SD-C200SD/3deg-3deg | PL/1452 | 1.9 | +4.906 | +5.021 | 114.85
2 x MULLION TOP PLATE | C150SD-C200SD/3deg-3deg | PL/1445 | 1.6 | +4.870 | +4.985 | 114.843
2 x MULLION TOP PLATE | C150SD-C200SD/3deg-3deg | PL/1438 | 1.5 | +4.834 | +4.949 | 114.851
2 x MULLION | C150SD-C200SD/3deg-3deg | Z/138 | 74.6 | +0.000 | +4.996 | 125
2 x MULLION | C150SD-C200SD/3deg-3deg | Z/137 | 62 | +0.000 | +4.960 | 96
2 x MULLION | C150SD-C200SD/3deg-3deg | Z/136 | 39.4 | +0.000 | +4.924 | 76
2 x MULLION TOP PLATE | C150SD-C200SD/3deg-3deg | PL/1431 | 1.1 | +4.798 | +4.912 | 114.844
2 x MULLION | C150SD-C200SD/3deg-3deg | Z/56 | 34.6 | +0.000 | +4.888 | 76
2 x MULLION TOP PLATE | C150SD/3deg-3deg | PL/1452 | 1.9 | +4.906 | +5.021 | 114.85
2 x MULLION TOP PLATE | C150SD/3deg-3deg | PL/1445 | 1.6 | +4.870 | +4.985 | 114.843
2 x MULLION TOP PLATE | C150SD/3deg-3deg | PL/1438 | 1.5 | +4.834 | +4.949 | 114.851
2 x MULLION | C150SD/3deg-3deg | Z/138 | 74.6 | +0.000 | +4.996 | 125
2 x MULLION | C150SD/3deg-3deg | Z/137 | 62 | +0.000 | +4.960 | 96
2 x MULLION | C150SD/3deg-3deg | Z/136 | 39.4 | +0.000 | +4.924 | 76
2 x MULLION TOP PLATE | C150SD/3deg-3deg | PL/1431 | 1.1 | +4.798 | +4.912 | 114.844
2 x MULLION | C150SD/3deg-3deg | Z/56 | 34.6 | +0.000 | +4.888 | 76
2 x RAFTER | C150SD-C200SD/3deg-3deg | Z/55 | 21.9 | +4.858 | +5.216 | 64
RAFTER | C150SD-C200SD/3deg-3deg | Z/2167 | 21.9 | +4.858 | +5.216 | 64
4 x RAFTER | C150SD/3deg-3deg | Z/55 | 21.9 | +4.858 | +5.216 | 64
RAFTER | C150SD-C200SD/3deg-3deg | Z/2109 | 21.9 | +4.858 | +5.216 | 64
RAFTER | C350SD/15deg-15deg | Z/1553 | 57.1 | +4.547 | +5.874 | 125
RAFTER | C350SD/12deg-12deg | Z/1552 | 57.1 | +4.585 | +5.722 | 125

# IfcMechanicalFastener: Bolt assembly (2100)
In: Undefined
NominalDiameter: 12 mm; Material: PB1230
Tekla Bolt - Washer diameter: 12 mm; Washer type: FLAT; Washer name: WASHERM12-FLAT; Nut type: 4.6-HEX; Nut name: NUTM12-4.6-HEX; Slotted hole y: 0 mm; Bolt hole diameter: 18 mm; Location: Site; Bolt count: 2; Bolt standard: PB1230; Bolt Name: BOLTPB1230
Name | NominalLength (mm) = Bolt length (mm) | Washer count = Nut count | Slotted hole x (mm) | Bolt size (mm)
711 x Bolt assembly | 30 | 2 | 22 | 12
689 x Bolt assembly | 8 | 0 | 22 | 18
700 x Bolt assembly | 30 | 2 | 57 | 12

# IfcMember: C:150-24 (8)
In: Undefined
Description: C:150-24; Material: STEEL/G450
Tekla Common - Finish: 15 deg; Bottom elevation: +4.566; Top elevation: +6.364; Phase: 200; Class: 1
Tekla Quantity - Weight: 21.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 111.2 m2; Net surface area: 2.4 m2; Height: 152 mm; Width: 64 mm; Length: 3927.1 mm
Pset_MemberCommon - LoadBearing: no; Reference: Z/158
BaseQuantities - Length: 3927.11 mm; OuterSurfaceArea: 2.43471 m2; GrossSurfaceArea: 0 m2; CrossSectionArea: 0.00071 m2; NetVolume: 0.00289726 m3; GrossVolume: 0.00278825 m3; NetWeight: 22.7435 kg; GrossWeight: 21.8877 kg

# IfcMember: C:200-24 (8)
In: Undefined
Description: C:200-24; Material: STEEL/G450
Tekla Common - Finish: 15 deg; Bottom elevation: +4.520; Top elevation: +6.364; Phase: 200; Class: 1
Tekla Quantity - Weight: 27.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 110 m2; Net surface area: 3.1 m2; Height: 203 mm; Width: 76 mm; Length: 3927.1 mm
Pset_MemberCommon - LoadBearing: no; Reference: Z/701
BaseQuantities - Length: 3927.11 mm; OuterSurfaceArea: 3.06343 m2; GrossSurfaceArea: 0 m2; CrossSectionArea: 0.000903 m2; NetVolume: 0.00365127 m3; GrossVolume: 0.00354618 m3; NetWeight: 28.6625 kg; GrossWeight: 27.8375 kg

# IfcMember: C:250-24 (8)
In: Undefined
Description: C:250-24; Material: STEEL/G450
Tekla Quantity - Weight: 31.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 109.7 m2; Net surface area: 3.4 m2; Height: 254 mm; Width: 76 mm; Length: 3890.2 mm
Tekla Common - Finish: 25 deg; Bottom elevation: +4.481; Top elevation: +6.355; Phase: 200; Class: 1
Pset_MemberCommon - LoadBearing: no; Reference: Z/750
BaseQuantities - Length: 3890.2 mm; OuterSurfaceArea: 3.42392 m2; GrossSurfaceArea: 0 m2; CrossSectionArea: 0.001022 m2; NetVolume: 0.00408377 m3; GrossVolume: 0.00397578 m3; NetWeight: 32.0576 kg; GrossWeight: 31.2099 kg

# IfcMember: C:300-30 (8)
In: Undefined
Description: C:300-30; Material: STEEL/G450
Tekla Common - Finish: 25 deg; Bottom elevation: +4.446; Top elevation: +6.348; Phase: 200; Class: 1
Tekla Quantity - Weight: 48.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.4 m2; Net surface area: 4.2 m2; Height: 300 mm; Width: 96 mm; Length: 3856.9 mm
Pset_MemberCommon - LoadBearing: no; Reference: Z/780
BaseQuantities - Length: 3856.9 mm; OuterSurfaceArea: 4.21499 m2; GrossSurfaceArea: 0 m2; CrossSectionArea: 0.001593 m2; NetVolume: 0.00628289 m3; GrossVolume: 0.00614404 m3; NetWeight: 49.3207 kg; GrossWeight: 48.2307 kg

# IfcMember: C:350-30 (8)
In: Undefined
Description: C:350-30; Material: STEEL/G450
Tekla Quantity - Weight: 57.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.2 m2; Net surface area: 5 m2; Height: 350 mm; Width: 125 mm; Length: 3820.7 mm
Tekla Common - Finish: 25 deg; Bottom elevation: +4.408; Top elevation: +6.340; Phase: 200; Class: 1
Pset_MemberCommon - LoadBearing: no; Reference: Z/810
BaseQuantities - Length: 3820.71 mm; OuterSurfaceArea: 4.97845 m2; GrossSurfaceArea: 0 m2; CrossSectionArea: 0.001905 m2; NetVolume: 0.00742746 m3; GrossVolume: 0.00727846 m3; NetWeight: 58.3056 kg; GrossWeight: 57.1359 kg

# IfcPlate: PLT3*120 (28)
In: Undefined
Description: PLT3*120; Material: STEEL/450
Tekla Common - Phase: 200; Class: 3
Tekla Quantity - Weight: 0.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.1 m2; Height: 120 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 120.001 mm; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Area per tons (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
4 x MULLION TOP PLATE | PL/1563 | +4.391 | +4.501 | 88.7 | 230.2 | 0.0579605 | 0.0276254 | 0.0000832667
4 x MULLION TOP PLATE | PL/1562 | +4.460 | +4.572 | 88.7 | 232 | 0.0583724 | 0.0278375 | 0.0000839523
4 x MULLION TOP PLATE | PL/1561 | +4.488 | +4.600 | 88.5 | 232.6 | 0.058519 | 0.0279141 | 0.0000841993
4 x MULLION TOP PLATE | PL/1560 | +4.515 | +4.628 | 88.5 | 233.2 | 0.0586517 | 0.0279842 | 0.0000844246
4 x MULLION TOP PLATE | PL/1559 | +4.542 | +4.655 | 88.5 | 233.7 | 0.0587729 | 0.028049 | 0.0000846313
4 x MULLION TOP PLATE | PL/1558 | +4.576 | +4.691 | 88.5 | 234.4 | 0.0589116 | 0.0281245 | 0.0000848709
4 x MULLION TOP PLATE | PL/1557 | +4.593 | +4.708 | 88.5 | 234.7 | 0.0589778 | 0.0281608 | 0.000084985

# IfcPlate: PLT3*126 (28)
In: Undefined
Description: PLT3*126; Material: STEEL/450
Tekla Common - Phase: 200; Class: 3
Tekla Quantity - Weight: 0.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.1 m2; Height: 126 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 126.001 mm; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Area per tons (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
4 x MULLION TOP PLATE | PL/1556 | +4.446 | +4.556 | 88.7 | 230.2 | 0.0607891 | 0.0290067 | 0.0000874301
4 x MULLION TOP PLATE | PL/1555 | +4.510 | +4.622 | 88.5 | 232 | 0.0612211 | 0.0292293 | 0.0000881499
4 x MULLION TOP PLATE | PL/1554 | +4.536 | +4.648 | 88.5 | 232.6 | 0.0613747 | 0.0293098 | 0.0000884093
4 x MULLION TOP PLATE | PL/1553 | +4.561 | +4.674 | 88.5 | 233.2 | 0.061514 | 0.0293835 | 0.0000886459
4 x MULLION TOP PLATE | PL/1552 | +4.585 | +4.699 | 88.5 | 233.7 | 0.061641 | 0.0294514 | 0.0000888629
4 x MULLION TOP PLATE | PL/1551 | +4.618 | +4.732 | 88.3 | 234.4 | 0.0617865 | 0.0295307 | 0.0000891145
4 x MULLION TOP PLATE | PL/1550 | +4.634 | +4.748 | 88.3 | 234.7 | 0.0618558 | 0.0295688 | 0.0000892343

# IfcPlate: PLT3*136 (56)
In: Undefined
Description: PLT3*136; Material: STEEL/450
Tekla Common - Phase: 200; Class: 3
Tekla Quantity - Weight: 0.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.1 m2; Height: 136 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 136.001 mm; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Area per tons (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
3 x MULLION TOP PLATE | PL/1463 | +4.579 | +4.692 | 88.3 | 232.6 | 0.0661344 | 0.0316359 | 0.0000954259
4 x MULLION TOP PLATE | PL/1465 | +4.496 | +4.606 | 88.3 | 230.2 | 0.0655035 | 0.0313088 | 0.000094369
4 x MULLION TOP PLATE | PL/1464 | +4.555 | +4.667 | 88.3 | 232 | 0.0659689 | 0.0315491 | 0.000095146
4 x MULLION TOP PLATE | PL/1462 | +4.603 | +4.716 | 88.2 | 233.2 | 0.0662844 | 0.0317155 | 0.0000956813
4 x MULLION TOP PLATE | PL/1461 | +4.625 | +4.739 | 88.2 | 233.7 | 0.0664213 | 0.0317888 | 0.0000959155
4 x MULLION TOP PLATE | PL/1460 | +4.655 | +4.770 | 88.2 | 234.4 | 0.0665779 | 0.0318744 | 0.0000961871
4 x MULLION TOP PLATE | PL/1459 | +4.670 | +4.785 | 88.2 | 234.7 | 0.0666526 | 0.0319155 | 0.0000963164
4 x MULLION TOP PLATE | PL/1459 | +4.710 | +4.825 | 88.2 | 234.7 | 0.0666526 | 0.0319155 | 0.0000963164
4 x MULLION TOP PLATE | PL/1460 | +4.697 | +4.811 | 88.2 | 234.4 | 0.0665779 | 0.0318744 | 0.0000961871
4 x MULLION TOP PLATE | PL/1461 | +4.671 | +4.784 | 88.2 | 233.7 | 0.0664213 | 0.0317888 | 0.0000959155
4 x MULLION TOP PLATE | PL/1462 | +4.649 | +4.762 | 88.2 | 233.2 | 0.0662844 | 0.0317155 | 0.0000956813
4 x MULLION TOP PLATE | PL/1463 | +4.628 | +4.741 | 88.3 | 232.6 | 0.0661344 | 0.0316359 | 0.000095426
4 x MULLION TOP PLATE | PL/1464 | +4.606 | +4.718 | 88.3 | 232 | 0.0659689 | 0.0315491 | 0.000095146
4 x MULLION TOP PLATE | PL/1465 | +4.552 | +4.662 | 88.3 | 230.2 | 0.0655035 | 0.0313088 | 0.000094369
MULLION TOP PLATE | PL/1463 | +4.579 | +4.692 | 88.3 | 232.6 | 0.0661344 | 0.0316359 | 0.000095426

# IfcPlate: PLT3*148 (28)
In: Undefined
Description: PLT3*148; Material: STEEL/450
Tekla Common - Phase: 200; Class: 3
Tekla Quantity - Weight: 0.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.1 m2; Height: 148 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 148.001 mm; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Area per tons (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
4 x MULLION TOP PLATE | PL/1430 | +4.608 | +4.718 | 88.3 | 230.2 | 0.0711608 | 0.0340713 | 0.000102696
4 x MULLION TOP PLATE | PL/1429 | +4.660 | +4.772 | 88.2 | 232 | 0.0716662 | 0.0343328 | 0.000103541
4 x MULLION TOP PLATE | PL/1428 | +4.681 | +4.793 | 88.2 | 232.6 | 0.071846 | 0.0344273 | 0.000103846
4 x MULLION TOP PLATE | PL/1427 | +4.702 | +4.815 | 88.2 | 233.2 | 0.0720089 | 0.0345139 | 0.000104124
4 x MULLION TOP PLATE | PL/1426 | +4.722 | +4.836 | 88.2 | 233.7 | 0.0721575 | 0.0345937 | 0.000104379
4 x MULLION TOP PLATE | PL/1425 | +4.748 | +4.863 | 88 | 234.4 | 0.0723276 | 0.0346868 | 0.000104674
4 x MULLION TOP PLATE | PL/1424 | +4.761 | +4.876 | 88 | 234.7 | 0.0724088 | 0.0347316 | 0.000104815

# IfcPlate: PLT3*170 (56)
In: Undefined
Description: PLT3*170; Material: STEEL/450
Tekla Common - Phase: 200; Class: 3
Tekla Quantity - Weight: 0.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.1 m2; Height: 170 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Area per tons (m2) | Length (mm) | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
4 x MULLION TOP PLATE | PL/1522 | +4.630 | +4.744 | 87.8 | 234.7 | 170.005 | 0.0829597 | 0.0398944 | 0.000120393
4 x MULLION TOP PLATE | PL/1523 | +4.637 | +4.751 | 87.8 | 234.4 | 170.001 | 0.082867 | 0.039842 | 0.000120231
4 x MULLION TOP PLATE | PL/1524 | +4.652 | +4.765 | 87.8 | 233.7 | 170.001 | 0.0826596 | 0.0397289 | 0.000119873
4 x MULLION TOP PLATE | PL/1525 | +4.663 | +4.776 | 87.8 | 233.2 | 170.001 | 0.082501 | 0.0396429 | 0.000119598
4 x MULLION TOP PLATE | PL/1526 | +4.674 | +4.786 | 87.8 | 232.6 | 170.001 | 0.0823176 | 0.0395451 | 0.000119283
4 x MULLION TOP PLATE | PL/1527 | +4.686 | +4.797 | 87.8 | 232 | 170.001 | 0.0821071 | 0.0394342 | 0.000118926
4 x MULLION TOP PLATE | PL/1528 | +4.714 | +4.824 | 88 | 230.2 | 170.001 | 0.0815293 | 0.0391343 | 0.000117957
4 x MULLION TOP PLATE | PL/1500 | +4.769 | +4.880 | 88 | 231.3 | 170.001 | 0.0819521 | 0.0393272 | 0.000118699
4 x MULLION TOP PLATE | PL/1499 | +4.735 | +4.847 | 87.8 | 232 | 170.001 | 0.0821104 | 0.0394358 | 0.000118931
4 x MULLION TOP PLATE | PL/1498 | +4.722 | +4.834 | 87.8 | 232.6 | 170.001 | 0.0823141 | 0.0395433 | 0.000119278
4 x MULLION TOP PLATE | PL/1497 | +4.708 | +4.821 | 87.8 | 233.2 | 170.001 | 0.0825013 | 0.0396431 | 0.000119598
4 x MULLION TOP PLATE | PL/1496 | +4.695 | +4.809 | 87.8 | 233.7 | 170.001 | 0.0826712 | 0.0397346 | 0.00011989
4 x MULLION TOP PLATE | PL/1495 | +4.678 | +4.793 | 87.8 | 234.4 | 170.001 | 0.0828697 | 0.0398433 | 0.000120235
4 x MULLION TOP PLATE | PL/1494 | +4.670 | +4.785 | 87.8 | 234.7 | 170.001 | 0.082956 | 0.0398915 | 0.000120387

# IfcPlate: PLT3*187 (56)
In: Undefined
Description: PLT3*187; Material: STEEL/450
Tekla Common - Phase: 200; Class: 3
Tekla Quantity - Weight: 0.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.1 m2; Height: 187 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000009 m2
Name | Bottom elevation | Top elevation | ASSEMBLY_POS = Reference | Area per tons (m2) | Length (mm) | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
4 x MULLION TOP PLATE | +4.707 | +4.821 | PL/1466 | 87.6 | 234.7 | 187.001 | 0.0911161 | 0.0438837 | 0.000132435
4 x MULLION TOP PLATE | +4.716 | +4.830 | PL/1467 | 87.6 | 234.4 | 187.001 | 0.0910147 | 0.0438274 | 0.000132258
4 x MULLION TOP PLATE | +4.735 | +4.849 | PL/1468 | 87.6 | 233.7 | 187.001 | 0.0908009 | 0.0437098 | 0.000131885
4 x MULLION TOP PLATE | +4.750 | +4.863 | PL/1469 | 87.6 | 233.2 | 187.005 | 0.0906129 | 0.0436094 | 0.000131561
4 x MULLION TOP PLATE | +4.765 | +4.878 | PL/1470 | 87.8 | 232.6 | 187.001 | 0.0904132 | 0.0435016 | 0.000131218
4 x MULLION TOP PLATE | +4.781 | +4.893 | PL/1471 | 87.8 | 232 | 187.001 | 0.090183 | 0.0433802 | 0.000130826
4 x MULLION TOP PLATE | +4.819 | +4.929 | PL/1472 | 87.8 | 230.2 | 187.001 | 0.0895482 | 0.0430501 | 0.000129759
4 x MULLION TOP PLATE | +4.875 | +4.985 | PL/1472 | 87.8 | 230.2 | 187.001 | 0.089547 | 0.0430495 | 0.000129757
4 x MULLION TOP PLATE | +4.832 | +4.943 | PL/1471 | 87.8 | 232 | 187.001 | 0.0901825 | 0.0433799 | 0.000130826
4 x MULLION TOP PLATE | +4.814 | +4.926 | PL/1470 | 87.8 | 232.6 | 187.001 | 0.0904086 | 0.0434993 | 0.000131211
4 x MULLION TOP PLATE | +4.797 | +4.910 | PL/1469 | 87.6 | 233.2 | 187.001 | 0.0906134 | 0.0436087 | 0.000131562
4 x MULLION TOP PLATE | +4.781 | +4.894 | PL/1468 | 87.6 | 233.7 | 187.001 | 0.0908003 | 0.0437095 | 0.000131884
4 x MULLION TOP PLATE | +4.758 | +4.872 | PL/1467 | 87.6 | 234.4 | 187.001 | 0.0910142 | 0.0438272 | 0.000132257
4 x MULLION TOP PLATE | +4.746 | +4.861 | PL/1466 | 87.6 | 234.7 | 187.001 | 0.0911163 | 0.0438838 | 0.000132435

# IfcPlate: PLT3*199 (28)
In: Undefined
Description: PLT3*199; Material: STEEL/450
Tekla Common - Phase: 200; Class: 3
Tekla Quantity - Weight: 1.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.1 m2; Height: 199 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 199.001 mm; CrossSectionArea: 0.000009 m2
