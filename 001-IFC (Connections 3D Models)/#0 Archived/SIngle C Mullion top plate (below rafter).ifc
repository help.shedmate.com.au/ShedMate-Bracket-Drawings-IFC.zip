Properties of the parts of a building model (IFC2X3), part 3 of 3

# IfcPlate: PLT3*199 (28)
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Area per tons (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
4 x MULLION TOP PLATE | PL/1437 | +4.931 | +5.041 | 87.8 | 230.2 | 0.0952043 | 0.045812 | 0.000138084
4 x MULLION TOP PLATE | PL/1436 | +4.885 | +4.997 | 87.6 | 232 | 0.0958799 | 0.0461636 | 0.000139221
4 x MULLION TOP PLATE | PL/1435 | +4.867 | +4.979 | 87.6 | 232.6 | 0.0961202 | 0.0462907 | 0.000139631
4 x MULLION TOP PLATE | PL/1434 | +4.849 | +4.962 | 87.6 | 233.2 | 0.0963379 | 0.0464071 | 0.000140004
4 x MULLION TOP PLATE | PL/1433 | +4.832 | +4.946 | 87.6 | 233.7 | 0.0965366 | 0.0465144 | 0.000140347
4 x MULLION TOP PLATE | PL/1432 | +4.809 | +4.923 | 87.6 | 234.4 | 0.096764 | 0.0466396 | 0.000140744
4 x MULLION TOP PLATE | PL/1431 | +4.798 | +4.912 | 87.6 | 234.7 | 0.0968724 | 0.0466998 | 0.000140934

# IfcPlate: PLT3*220 (56)
In: Undefined
Description: PLT3*220; Material: STEEL/450
Tekla Common - Phase: 200; Class: 3
Tekla Quantity - Weight: 1.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.1 m2; Height: 220 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Area per tons (m2) | Length (mm) | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
4 x MULLION TOP PLATE | PL/1529 | +4.667 | +4.781 | 87.4 | 234.7 | 220.002 | 0.106942 | 0.0516266 | 0.000155801
4 x MULLION TOP PLATE | PL/1530 | +4.698 | +4.813 | 87.4 | 234.4 | 220.002 | 0.106827 | 0.0515623 | 0.000155599
4 x MULLION TOP PLATE | PL/1531 | +4.762 | +4.876 | 87.4 | 233.7 | 220.002 | 0.106569 | 0.05142 | 0.000155148
4 x MULLION TOP PLATE | PL/1532 | +4.811 | +4.924 | 87.4 | 233.2 | 220.006 | 0.106352 | 0.0513038 | 0.000154774
4 x MULLION TOP PLATE | PL/1533 | +4.861 | +4.974 | 87.6 | 232.6 | 220.002 | 0.106112 | 0.051174 | 0.00015436
4 x MULLION TOP PLATE | PL/1534 | +4.913 | +5.025 | 87.6 | 232 | 220.002 | 0.105845 | 0.0510327 | 0.000153904
4 x MULLION TOP PLATE | PL/1535 | +5.041 | +5.151 | 87.6 | 230.2 | 220.002 | 0.105097 | 0.0506429 | 0.000152645
4 x MULLION TOP PLATE | PL/1507 | +5.096 | +5.206 | 87.6 | 231.3 | 220.002 | 0.105646 | 0.0508948 | 0.000153611
4 x MULLION TOP PLATE | PL/1506 | +4.963 | +5.075 | 87.6 | 232 | 220.002 | 0.105849 | 0.0510348 | 0.000153911
4 x MULLION TOP PLATE | PL/1505 | +4.909 | +5.022 | 87.6 | 232.6 | 220.002 | 0.106111 | 0.051174 | 0.00015436
4 x MULLION TOP PLATE | PL/1504 | +4.857 | +4.970 | 87.4 | 233.2 | 220.002 | 0.106353 | 0.0513031 | 0.000154774
4 x MULLION TOP PLATE | PL/1503 | +4.806 | +4.920 | 87.4 | 233.7 | 220.002 | 0.10657 | 0.0514208 | 0.00015515
4 x MULLION TOP PLATE | PL/1502 | +4.740 | +4.854 | 87.4 | 234.4 | 220.002 | 0.106831 | 0.051564 | 0.000155604
4 x MULLION TOP PLATE | PL/1501 | +4.707 | +4.821 | 87.4 | 234.7 | 220.002 | 0.106942 | 0.0516264 | 0.000155801

# IfcPlate: PLT3*230.2 (44)
In: Undefined
Description: PLT3*230.2; Material: STEEL/450
Tekla Common - Phase: 200; Class: 3
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 230.2 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Length (mm) | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
4 x MULLION TOP PLATE | PL/1542 | +5.363 | +5.473 | 1.5 | 87.4 | 0.1 | 270 | 230.191 | 0.128666 | 0.0621522 | 0.000187335
4 x MULLION TOP PLATE | PL/1549 | +5.682 | +5.792 | 1.8 | 87.4 | 0.2 | 320 | 230.197 | 0.152239 | 0.0736635 | 0.000222031
4 x MULLION TOP PLATE | PL/1493 | +5.787 | +5.897 | 1.8 | 87.4 | 0.2 | 334 | 230.209 | 0.158848 | 0.0768905 | 0.000231758
4 x MULLION TOP PLATE | PL/1486 | +5.467 | +5.577 | 1.5 | 87.4 | 0.1 | 284 | 230.214 | 0.135279 | 0.0653813 | 0.000197068
4 x MULLION TOP PLATE | PL/1479 | +5.146 | +5.256 | 1.2 | 87.6 | 0.1 | 238 | 230.215 | 0.113593 | 0.0547918 | 0.00016515
4 x MULLION TOP PLATE | PL/1493 | +5.843 | +5.953 | 1.8 | 87.4 | 0.2 | 334 | 230.197 | 0.158839 | 0.0768864 | 0.000231746
4 x MULLION TOP PLATE | PL/1486 | +5.523 | +5.633 | 1.5 | 87.4 | 0.1 | 284 | 230.206 | 0.135274 | 0.0653791 | 0.000197061
4 x MULLION TOP PLATE | PL/1479 | +5.202 | +5.312 | 1.2 | 87.6 | 0.1 | 238 | 230.202 | 0.113586 | 0.0547885 | 0.00016514
4 x MULLION TOP PLATE | PL/1458 | +5.899 | +6.009 | 1.9 | 87.4 | 0.2 | 346 | 230.197 | 0.164496 | 0.0796488 | 0.000240072
4 x MULLION TOP PLATE | PL/1451 | +5.580 | +5.690 | 1.6 | 87.4 | 0.1 | 296 | 230.206 | 0.140931 | 0.0681416 | 0.000205388
4 x MULLION TOP PLATE | PL/1444 | +5.258 | +5.368 | 1.5 | 87.6 | 0.1 | 250 | 230.202 | 0.119243 | 0.0575509 | 0.000173466

# IfcPlate: PLT3*231.3 (8)
In: Undefined
Description: PLT3*231.3; Material: STEEL/450
Tekla Common - Phase: 200; Class: 3
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 231.3 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Length (mm) | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
4 x MULLION TOP PLATE | PL/1521 | +5.737 | +5.848 | 1.8 | 87.2 | 0.2 | 320 | 231.331 | 0.153027 | 0.0740266 | 0.000223428
4 x MULLION TOP PLATE | PL/1514 | +5.417 | +5.528 | 1.5 | 87.4 | 0.1 | 270 | 231.336 | 0.129338 | 0.0624612 | 0.000188521

# IfcPlate: PLT3*232 (52)
In: Undefined
Description: PLT3*232; Material: STEEL/450
Tekla Common - Phase: 200; Class: 3
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 232 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Length (mm) | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
4 x MULLION TOP PLATE | PL/1541 | +5.137 | +5.249 | 1.5 | 87.4 | 0.1 | 270 | 231.973 | 0.129587 | 0.0626333 | 0.000188889
4 x MULLION TOP PLATE | PL/1548 | +5.360 | +5.472 | 1.8 | 87.2 | 0.2 | 320 | 231.969 | 0.153322 | 0.0742307 | 0.000223864
4 x MULLION TOP PLATE | PL/1520 | +5.410 | +5.521 | 1.8 | 87.2 | 0.2 | 320 | 231.969 | 0.153322 | 0.0742305 | 0.000223864
4 x MULLION TOP PLATE | PL/1513 | +5.187 | +5.299 | 1.5 | 87.4 | 0.1 | 270 | 231.973 | 0.129587 | 0.0626332 | 0.000188889
4 x MULLION TOP PLATE | PL/1492 | +5.455 | +5.567 | 1.8 | 87.2 | 0.2 | 334 | 231.973 | 0.159971 | 0.0774794 | 0.000233662
4 x MULLION TOP PLATE | PL/1485 | +5.232 | +5.344 | 1.6 | 87.4 | 0.1 | 284 | 231.977 | 0.136236 | 0.0658819 | 0.000198687
4 x MULLION TOP PLATE | PL/1478 | +5.008 | +5.120 | 1.2 | 87.4 | 0.1 | 238 | 231.978 | 0.114397 | 0.0552113 | 0.000166506
4 x MULLION TOP PLATE | PL/1492 | +5.506 | +5.618 | 1.8 | 87.2 | 0.2 | 334 | 231.962 | 0.159964 | 0.0774758 | 0.000233651
4 x MULLION TOP PLATE | PL/1485 | +5.283 | +5.395 | 1.6 | 87.4 | 0.1 | 284 | 231.981 | 0.136238 | 0.0658831 | 0.00019869
4 x MULLION TOP PLATE | PL/1478 | +5.059 | +5.171 | 1.2 | 87.4 | 0.1 | 238 | 231.966 | 0.114391 | 0.0552084 | 0.000166498
4 x MULLION TOP PLATE | PL/1457 | +5.560 | +5.671 | 1.9 | 87.2 | 0.2 | 346 | 231.962 | 0.165661 | 0.0802594 | 0.000242046
4 x MULLION TOP PLATE | PL/1450 | +5.337 | +5.449 | 1.6 | 87.4 | 0.1 | 296 | 231.981 | 0.141935 | 0.0686669 | 0.000207085
4 x MULLION TOP PLATE | PL/1443 | +5.113 | +5.224 | 1.5 | 87.4 | 0.1 | 250 | 231.966 | 0.120088 | 0.057992 | 0.000174892

# IfcPlate: PLT3*232.6 (52)
In: Undefined
Description: PLT3*232.6; Material: STEEL/450
Tekla Common - Phase: 200; Class: 3
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 232.6 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Length (mm) | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
4 x MULLION TOP PLATE | PL/1540 | +5.046 | +5.159 | 1.5 | 87.4 | 0.1 | 270 | 232.608 | 0.129909 | 0.0628046 | 0.000189442
4 x MULLION TOP PLATE | PL/1547 | +5.230 | +5.342 | 1.8 | 87.2 | 0.2 | 320 | 232.615 | 0.153711 | 0.0744373 | 0.00022453
4 x MULLION TOP PLATE | PL/1519 | +5.278 | +5.390 | 1.8 | 87.2 | 0.2 | 320 | 232.614 | 0.15371 | 0.0744372 | 0.00022453
4 x MULLION TOP PLATE | PL/1512 | +5.094 | +5.207 | 1.5 | 87.4 | 0.1 | 270 | 232.618 | 0.129914 | 0.0628073 | 0.00018945
4 x MULLION TOP PLATE | PL/1491 | +5.321 | +5.434 | 1.8 | 87.2 | 0.2 | 334 | 232.626 | 0.160381 | 0.0776975 | 0.000234364
4 x MULLION TOP PLATE | PL/1484 | +5.138 | +5.250 | 1.6 | 87.4 | 0.1 | 284 | 232.619 | 0.136579 | 0.0660642 | 0.000199274
4 x MULLION TOP PLATE | PL/1477 | +4.953 | +5.065 | 1.2 | 87.4 | 0.1 | 238 | 232.628 | 0.114689 | 0.0553659 | 0.000167004
4 x MULLION TOP PLATE | PL/1491 | +5.370 | +5.483 | 1.8 | 87.2 | 0.2 | 334 | 232.614 | 0.160374 | 0.0776936 | 0.000234352
4 x MULLION TOP PLATE | PL/1484 | +5.186 | +5.299 | 1.6 | 87.4 | 0.1 | 284 | 232.622 | 0.13658 | 0.0660651 | 0.000199277
4 x MULLION TOP PLATE | PL/1477 | +5.002 | +5.114 | 1.2 | 87.4 | 0.1 | 238 | 232.605 | 0.114678 | 0.0553605 | 0.000166988
4 x MULLION TOP PLATE | PL/1456 | +5.423 | +5.535 | 1.9 | 87.2 | 0.2 | 346 | 232.614 | 0.166085 | 0.080485 | 0.000242772
4 x MULLION TOP PLATE | PL/1449 | +5.239 | +5.352 | 1.6 | 87.4 | 0.1 | 296 | 232.622 | 0.142292 | 0.0688566 | 0.000207697
4 x MULLION TOP PLATE | PL/1442 | +5.054 | +5.167 | 1.5 | 87.4 | 0.1 | 250 | 232.605 | 0.120389 | 0.0581518 | 0.000175407

# IfcPlate: PLT3*233.2 (52)
In: Undefined
Description: PLT3*233.2; Material: STEEL/450
Tekla Common - Phase: 200; Class: 3
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 233.2 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Length (mm) | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
4 x MULLION TOP PLATE | PL/1539 | +4.958 | +5.071 | 1.5 | 87.4 | 0.1 | 270 | 233.197 | 0.130206 | 0.0629646 | 0.000189953
4 x MULLION TOP PLATE | PL/1546 | +5.104 | +5.217 | 1.8 | 87.2 | 0.2 | 320 | 233.195 | 0.154056 | 0.074623 | 0.000225127
MULLION TOP PLATE | PL/1518 | +5.150 | +5.263 | 1.8 | 87.2 | 0.2 | 320 | 233.196 | 0.154056 | 0.0746233 | 0.000225127
4 x MULLION TOP PLATE | PL/1511 | +5.004 | +5.117 | 1.5 | 87.4 | 0.1 | 270 | 233.198 | 0.130206 | 0.062964 | 0.000189953
3 x MULLION TOP PLATE | PL/1518 | +5.150 | +5.263 | 1.8 | 87.2 | 0.2 | 320 | 233.196 | 0.154056 | 0.0746233 | 0.000225128
4 x MULLION TOP PLATE | PL/1476 | +4.899 | +5.012 | 1.2 | 87.4 | 0.1 | 238 | 233.199 | 0.114942 | 0.0555027 | 0.000167442
4 x MULLION TOP PLATE | PL/1490 | +5.191 | +5.304 | 1.8 | 87.2 | 0.2 | 334 | 233.202 | 0.160739 | 0.0778907 | 0.000234983
4 x MULLION TOP PLATE | PL/1483 | +5.046 | +5.159 | 1.6 | 87.4 | 0.1 | 284 | 233.204 | 0.136888 | 0.0662312 | 0.000199808
4 x MULLION TOP PLATE | PL/1490 | +5.238 | +5.351 | 1.8 | 87.2 | 0.2 | 334 | 233.193 | 0.160733 | 0.0778879 | 0.000234974
4 x MULLION TOP PLATE | PL/1483 | +5.092 | +5.205 | 1.6 | 87.4 | 0.1 | 284 | 233.2 | 0.136886 | 0.0662302 | 0.000199805
4 x MULLION TOP PLATE | PL/1476 | +4.946 | +5.059 | 1.2 | 87.4 | 0.1 | 238 | 233.2 | 0.114942 | 0.0555029 | 0.000167442
4 x MULLION TOP PLATE | PL/1455 | +5.290 | +5.403 | 1.9 | 87.2 | 0.2 | 346 | 233.193 | 0.166457 | 0.0806862 | 0.000243416
4 x MULLION TOP PLATE | PL/1448 | +5.145 | +5.258 | 1.6 | 87.2 | 0.1 | 296 | 233.2 | 0.14261 | 0.0690285 | 0.000208247
4 x MULLION TOP PLATE | PL/1441 | +4.998 | +5.111 | 1.5 | 87.4 | 0.1 | 250 | 233.2 | 0.120667 | 0.0583012 | 0.000175884

# IfcPlate: PLT3*233.7 (52)
In: Undefined
Description: PLT3*233.7; Material: STEEL/450
Tekla Common - Phase: 200; Class: 3
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 233.7 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Length (mm) | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
4 x MULLION TOP PLATE | PL/1538 | +4.872 | +4.985 | 1.5 | 87.4 | 0.1 | 270 | 233.727 | 0.130469 | 0.0631067 | 0.00019041
4 x MULLION TOP PLATE | PL/1545 | +4.980 | +5.094 | 1.8 | 87.2 | 0.2 | 320 | 233.73 | 0.15437 | 0.0747941 | 0.000225673
4 x MULLION TOP PLATE | PL/1517 | +5.024 | +5.138 | 1.8 | 87.2 | 0.2 | 320 | 233.724 | 0.154366 | 0.0747921 | 0.000225667
4 x MULLION TOP PLATE | PL/1510 | +4.916 | +5.029 | 1.5 | 87.4 | 0.1 | 270 | 233.73 | 0.130471 | 0.0631077 | 0.000190413
4 x MULLION TOP PLATE | PL/1489 | +5.064 | +5.178 | 1.8 | 87.2 | 0.2 | 334 | 233.733 | 0.161064 | 0.0780674 | 0.00023555
4 x MULLION TOP PLATE | PL/1482 | +4.956 | +5.069 | 1.6 | 87.2 | 0.1 | 284 | 233.73 | 0.137162 | 0.0663798 | 0.000200285
4 x MULLION TOP PLATE | PL/1475 | +4.846 | +4.960 | 1.2 | 87.4 | 0.1 | 238 | 233.738 | 0.115179 | 0.0556302 | 0.000167851
4 x MULLION TOP PLATE | PL/1489 | +5.109 | +5.223 | 1.8 | 87.2 | 0.2 | 334 | 233.742 | 0.16107 | 0.0780703 | 0.000235558
4 x MULLION TOP PLATE | PL/1482 | +5.001 | +5.115 | 1.6 | 87.2 | 0.1 | 284 | 233.743 | 0.13717 | 0.0663836 | 0.000200297
4 x MULLION TOP PLATE | PL/1475 | +4.892 | +5.005 | 1.2 | 87.4 | 0.1 | 238 | 233.736 | 0.115178 | 0.0556296 | 0.000167849
4 x MULLION TOP PLATE | PL/1454 | +5.161 | +5.275 | 1.9 | 87.2 | 0.2 | 346 | 233.742 | 0.166806 | 0.0808752 | 0.000244022
4 x MULLION TOP PLATE | PL/1447 | +5.053 | +5.166 | 1.6 | 87.2 | 0.1 | 296 | 233.743 | 0.142906 | 0.0691885 | 0.00020876
4 x MULLION TOP PLATE | PL/1440 | +4.943 | +5.057 | 1.5 | 87.4 | 0.1 | 250 | 233.736 | 0.120914 | 0.0584345 | 0.000176312

# IfcPlate: PLT3*234.4 (52)
In: Undefined
Description: PLT3*234.4; Material: STEEL/450
Tekla Common - Phase: 200; Class: 3
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 234.4 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Length (mm) | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
4 x MULLION TOP PLATE | PL/1537 | +4.759 | +4.873 | 1.5 | 87.2 | 0.1 | 270 | 234.37 | 0.130784 | 0.0632804 | 0.00019096
4 x MULLION TOP PLATE | PL/1544 | +4.819 | +4.933 | 1.8 | 87.2 | 0.2 | 320 | 234.368 | 0.154739 | 0.0749983 | 0.000226321
4 x MULLION TOP PLATE | PL/1516 | +4.860 | +4.974 | 1.8 | 87.2 | 0.2 | 320 | 234.376 | 0.154744 | 0.0750008 | 0.000226329
4 x MULLION TOP PLATE | PL/1509 | +4.800 | +4.914 | 1.5 | 87.2 | 0.1 | 270 | 234.368 | 0.130782 | 0.0632799 | 0.000190959
4 x MULLION TOP PLATE | PL/1488 | +4.898 | +5.012 | 1.9 | 87.2 | 0.2 | 334 | 234.374 | 0.161451 | 0.0782816 | 0.000236229
4 x MULLION TOP PLATE | PL/1481 | +4.838 | +4.952 | 1.6 | 87.2 | 0.1 | 284 | 234.376 | 0.137495 | 0.0665635 | 0.000200868
4 x MULLION TOP PLATE | PL/1474 | +4.777 | +4.892 | 1.2 | 87.4 | 0.1 | 238 | 234.378 | 0.115455 | 0.0557825 | 0.000168334
4 x MULLION TOP PLATE | PL/1488 | +4.939 | +5.054 | 1.9 | 87.2 | 0.2 | 334 | 234.363 | 0.161444 | 0.0782778 | 0.000236218
4 x MULLION TOP PLATE | PL/1481 | +4.879 | +4.994 | 1.6 | 87.2 | 0.1 | 284 | 234.38 | 0.137497 | 0.0665644 | 0.000200871
4 x MULLION TOP PLATE | PL/1474 | +4.819 | +4.933 | 1.2 | 87.4 | 0.1 | 238 | 234.376 | 0.115454 | 0.055782 | 0.000168333
4 x MULLION TOP PLATE | PL/1453 | +4.991 | +5.105 | 1.9 | 87 | 0.2 | 346 | 234.363 | 0.167193 | 0.0810902 | 0.000244705
4 x MULLION TOP PLATE | PL/1446 | +4.931 | +5.045 | 1.6 | 87.2 | 0.1 | 296 | 234.38 | 0.143247 | 0.069377 | 0.000209358
4 x MULLION TOP PLATE | PL/1439 | +4.870 | +4.985 | 1.5 | 87.4 | 0.1 | 250 | 234.376 | 0.121204 | 0.0585945 | 0.00017682

# IfcPlate: PLT3*234.7 (52)
In: Undefined
Description: PLT3*234.7; Material: STEEL/450
Tekla Common - Phase: 200; Class: 3
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 234.7 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Length (mm) | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
4 x MULLION TOP PLATE | PL/1536 | +4.703 | +4.817 | 1.5 | 87.2 | 0.1 | 270 | 234.657 | 0.130922 | 0.0633581 | 0.000191205
4 x MULLION TOP PLATE | PL/1543 | +4.739 | +4.853 | 1.8 | 87.2 | 0.2 | 320 | 234.66 | 0.154905 | 0.0750917 | 0.000226615
4 x MULLION TOP PLATE | PL/1515 | +4.779 | +4.893 | 1.8 | 87.2 | 0.2 | 320 | 234.669 | 0.154911 | 0.0750955 | 0.000226624
4 x MULLION TOP PLATE | PL/1508 | +4.743 | +4.857 | 1.5 | 87.2 | 0.1 | 270 | 234.667 | 0.130927 | 0.0633615 | 0.000191212
4 x MULLION TOP PLATE | PL/1487 | +4.815 | +4.930 | 1.9 | 87 | 0.2 | 334 | 234.675 | 0.161631 | 0.0783821 | 0.000236545
4 x MULLION TOP PLATE | PL/1480 | +4.779 | +4.894 | 1.6 | 87.2 | 0.1 | 284 | 234.673 | 0.137646 | 0.0666477 | 0.000201132
4 x MULLION TOP PLATE | PL/1473 | +4.743 | +4.858 | 1.2 | 87.4 | 0.1 | 238 | 234.679 | 0.115584 | 0.0558542 | 0.000168559
4 x MULLION TOP PLATE | PL/1487 | +4.855 | +4.970 | 1.9 | 87 | 0.2 | 334 | 234.666 | 0.161624 | 0.0783789 | 0.000236535
4 x MULLION TOP PLATE | PL/1480 | +4.819 | +4.934 | 1.6 | 87.2 | 0.1 | 284 | 234.668 | 0.137643 | 0.0666463 | 0.000201128
4 x MULLION TOP PLATE | PL/1473 | +4.783 | +4.898 | 1.2 | 87.4 | 0.1 | 238 | 234.669 | 0.115579 | 0.0558517 | 0.000168552
4 x MULLION TOP PLATE | PL/1452 | +4.906 | +5.021 | 1.9 | 87 | 0.2 | 346 | 234.666 | 0.16738 | 0.0811948 | 0.000245033
4 x MULLION TOP PLATE | PL/1445 | +4.870 | +4.985 | 1.6 | 87.2 | 0.1 | 296 | 234.668 | 0.143399 | 0.0694623 | 0.000209627
4 x MULLION TOP PLATE | PL/1438 | +4.834 | +4.949 | 1.5 | 87.4 | 0.1 | 250 | 234.669 | 0.121335 | 0.0586677 | 0.00017705
