Properties of the parts of a building model (IFC2X3), part 1 of 3

# File
Description: ViewDefinition[CoordinationView_V2.0, QuantityTakeOffAddOnView], Option [BaseQuantities:On], Option [GridExport:On], Option [Assemblies:On], Option [Bolts:On], Option [Rebars:On], Option [PourObjects:Off], Option [Welds:Off], Option [SurfaceTreatments:Off], Option [LocationBy:0], Option [ViewColors:Off], Option [SectionedSpine:Off], Option [PropertySets:On], Option [Export all:Off]
File name: Double C-SectionMulllion top plate.ifc
Time: 2026-04-16T07:02:18
Author: DESKTOP-BKNQL56\admin
Organization: Structural Designer
Written by: IFC Database Version: Work
Made in: Tekla Structures 2019 Service Pack 13, IFC Export Version: 4.0.0.0 Oct 18 2021

# IfcBuildingStorey, Undefined
In: Undefined
Elevation: 0 mm

# IfcBeam: C:200-24 (52)
In: Undefined
Description: C:200-24; Material: STEEL/G450
Tekla Common - Phase: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 110 m2; Height: 203 mm; Width: 76 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Finish | Bottom elevation | Top elevation | Class | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
MULLION | Z/813 | 9 deg | +0.000 | +4.752 | 2 | 33.7 | 3.7 | 4751.5 | 4751.51 | 3.70614 | 0.00441776 | 34.6794
MULLION | Z/812 | 5 deg | +0.000 | +4.737 | 2 | 33.6 | 3.7 | 4737 | 4737.03 | 3.69485 | 0.0044043 | 34.5738
MULLION | Z/811 | 3 deg | +0.000 | +4.730 | 2 | 33.5 | 3.7 | 4729.9 | 4729.86 | 3.68926 | 0.00439763 | 34.5214
MULLION | Z/816 | 25 deg | +0.000 | +4.814 | 2 | 34.1 | 3.8 | 4814.4 | 4814.39 | 3.75516 | 0.00447623 | 35.1384
MULLION | Z/815 | 18 deg | +0.000 | +4.786 | 2 | 33.9 | 3.7 | 4785.5 | 4785.52 | 3.73265 | 0.00444939 | 34.9277
MULLION | Z/814 | 15 deg | +0.000 | +4.774 | 2 | 33.9 | 3.7 | 4773.9 | 4773.88 | 3.72358 | 0.00443856 | 34.8427
MULLION | Z/783 | 9 deg | +0.000 | +4.795 | 2 | 34 | 3.7 | 4795.4 | 4795.39 | 3.74035 | 0.00445856 | 34.9997
MULLION | Z/782 | 5 deg | +0.000 | +4.778 | 2 | 33.9 | 3.7 | 4778.4 | 4778.4 | 3.7271 | 0.00444277 | 34.8757
MULLION | Z/781 | 3 deg | +0.000 | +4.770 | 2 | 33.9 | 3.7 | 4770 | 4770 | 3.72055 | 0.00443496 | 34.8144
MULLION | Z/786 | 25 deg | +0.000 | +4.869 | 2 | 34.5 | 3.8 | 4869.2 | 4869.17 | 3.79786 | 0.00452716 | 35.5382
MULLION | Z/785 | 18 deg | +0.000 | +4.835 | 2 | 34.3 | 3.8 | 4835.3 | 4835.29 | 3.77145 | 0.00449566 | 35.2909
MULLION | Z/784 | 15 deg | +0.000 | +4.822 | 2 | 34.2 | 3.8 | 4821.6 | 4821.64 | 3.76081 | 0.00448297 | 35.1913
MULLION | Z/753 | 9 deg | +0.000 | +4.835 | 2 | 34.3 | 3.8 | 4835.4 | 4835.37 | 3.77151 | 0.00449573 | 35.2915
MULLION | Z/752 | 5 deg | +0.000 | +4.816 | 2 | 34.1 | 3.8 | 4816.1 | 4816.08 | 3.75648 | 0.0044778 | 35.1507
MULLION | Z/751 | 3 deg | +0.000 | +4.807 | 2 | 34.1 | 3.7 | 4806.5 | 4806.53 | 3.74903 | 0.00446892 | 35.081
MULLION | Z/756 | 25 deg | +0.000 | +4.919 | 2 | 34.9 | 3.8 | 4919.2 | 4919.18 | 3.83685 | 0.00457366 | 35.9032
MULLION | Z/755 | 18 deg | +0.000 | +4.881 | 2 | 34.6 | 3.8 | 4880.7 | 4880.7 | 3.80685 | 0.00453788 | 35.6224
MULLION | Z/754 | 15 deg | +0.000 | +4.866 | 2 | 34.5 | 3.8 | 4866.2 | 4866.17 | 3.79553 | 0.00452437 | 35.5163
2 x RAFTER | Z/701 | 15 deg | +4.845 | +5.660 | 1 | 27.8 | 3.1 | 3927.1 | 3927.11 | 3.06343 | 0.00365127 | 28.6625
2 x RAFTER | Z/726 | 9 deg | +4.845 | +5.660 | 1 | 27.8 | 3.1 | 3927.1 | 3927.11 | 3.06343 | 0.00365127 | 28.6625
MULLION | Z/710 | 9 deg | +0.000 | +4.881 | 2 | 34.6 | 3.8 | 4880.7 | 4880.73 | 3.80688 | 0.00453791 | 35.6226
4 x RAFTER | Z/699 | 5 deg | +4.845 | +5.389 | 1 | 27.8 | 3.1 | 3927.1 | 3927.11 | 3.06343 | 0.00365127 | 28.6625
MULLION | Z/708 | 5 deg | +0.000 | +4.858 | 2 | 34.3 | 3.8 | 4857.9 | 4857.88 | 3.78906 | 0.00451666 | 35.4558
MULLION | Z/706 | 3 deg | +0.000 | +4.846 | 2 | 34.3 | 3.8 | 4846.5 | 4846.45 | 3.78015 | 0.00450604 | 35.3724
4 x RAFTER | Z/697 | 3 deg | +4.844 | +5.252 | 1 | 27.8 | 3.1 | 3927.1 | 3927.11 | 3.06343 | 0.00365127 | 28.6625
MULLION | Z/725 | 15 deg | +0.000 | +4.975 | 2 | 35.3 | 3.9 | 4975.2 | 4975.16 | 3.88049 | 0.0046257 | 36.3118
MULLION | Z/724 | 18 deg | +0.000 | +4.932 | 2 | 35 | 3.8 | 4931.6 | 4931.57 | 3.84651 | 0.00458518 | 35.9936
4 x RAFTER | Z/703 | 18 deg | +4.846 | +6.253 | 1 | 27.8 | 3.1 | 3927.1 | 3927.11 | 3.06343 | 0.00365127 | 28.6625
MULLION | Z/712 | 15 deg | +0.000 | +4.914 | 2 | 34.9 | 3.8 | 4914 | 4914.01 | 3.83282 | 0.00456885 | 35.8655
4 x RAFTER | Z/701 | 15 deg | +4.846 | +6.059 | 1 | 27.8 | 3.1 | 3927.1 | 3927.11 | 3.06343 | 0.00365127 | 28.6625
MULLION | Z/720 | 12 deg | +0.000 | +4.763 | 2 | 33.9 | 3.7 | 4762.6 | 4762.57 | 3.71476 | 0.00442805 | 34.7602
MULLION | Z/715 | 12 deg | +0.000 | +4.808 | 2 | 34.1 | 3.8 | 4808.4 | 4808.37 | 3.75046 | 0.00447063 | 35.0944
MULLION | Z/707 | 12 deg | +0.000 | +4.850 | 2 | 34.3 | 3.8 | 4850.1 | 4850.12 | 3.78301 | 0.00450945 | 35.3992
MULLION | Z/698 | 12 deg | +0.000 | +4.897 | 2 | 34.7 | 3.8 | 4896.9 | 4896.93 | 3.81951 | 0.00455297 | 35.7408
2 x RAFTER | Z/696 | 12 deg | +4.846 | +5.861 | 1 | 27.8 | 3.1 | 3927.1 | 3927.11 | 3.06344 | 0.00365127 | 28.6625
2 x RAFTER | Z/696 | 12 deg | +4.846 | +5.861 | 1 | 27.8 | 3.1 | 3927.1 | 3927.11 | 3.06343 | 0.00365127 | 28.6625

# IfcBeam: C:250-24 (52)
In: Undefined
Description: C:250-24; Material: STEEL/G450
Tekla Common - Phase: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 109.7 m2; Height: 254 mm; Width: 76 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Finish | Bottom elevation | Top elevation | Class | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
MULLION | Z/819 | 9 deg | +0.000 | +4.862 | 2 | 39 | 4.3 | 4862.4 | 4862.38 | 4.27905 | 0.00510433 | 40.069
MULLION | Z/818 | 5 deg | +0.000 | +4.798 | 2 | 38.5 | 4.3 | 4798.3 | 4798.27 | 4.22266 | 0.00503703 | 39.5407
MULLION | Z/817 | 3 deg | +0.000 | +4.767 | 2 | 38.2 | 4.3 | 4766.6 | 4766.55 | 4.19476 | 0.00500373 | 39.2793
MULLION | Z/822 | 25 deg | +0.000 | +5.141 | 2 | 41.2 | 4.5 | 5140.8 | 5140.81 | 4.52396 | 0.00539662 | 42.3634
MULLION | Z/821 | 18 deg | +0.000 | +5.013 | 2 | 40.2 | 4.5 | 5013 | 5012.96 | 4.4115 | 0.00526241 | 41.3099
MULLION | Z/820 | 15 deg | +0.000 | +4.961 | 2 | 39.8 | 4.5 | 4961.5 | 4961.45 | 4.36619 | 0.00520833 | 40.8854
MULLION | Z/789 | 9 deg | +0.000 | +4.906 | 2 | 39.4 | 4.3 | 4906.3 | 4906.26 | 4.31765 | 0.0051504 | 40.4306
MULLION | Z/788 | 5 deg | +0.000 | +4.840 | 2 | 38.8 | 4.3 | 4839.6 | 4839.64 | 4.25905 | 0.00508046 | 39.8816
MULLION | Z/787 | 3 deg | +0.000 | +4.807 | 2 | 38.6 | 4.3 | 4806.7 | 4806.68 | 4.23006 | 0.00504586 | 39.61
MULLION | Z/792 | 25 deg | +0.000 | +5.196 | 2 | 41.7 | 4.6 | 5195.6 | 5195.59 | 4.57214 | 0.00545412 | 42.8149
MULLION | Z/791 | 18 deg | +0.000 | +5.063 | 2 | 40.6 | 4.5 | 5062.7 | 5062.74 | 4.45529 | 0.00531466 | 41.7201
MULLION | Z/790 | 15 deg | +0.000 | +5.009 | 2 | 40.2 | 4.5 | 5009.2 | 5009.21 | 4.4082 | 0.00525847 | 41.279
MULLION | Z/759 | 9 deg | +0.000 | +4.946 | 2 | 39.7 | 4.5 | 4946.2 | 4946.24 | 4.35281 | 0.00519237 | 40.7601
4 x RAFTER | Z/747 | 9 deg | +4.807 | +5.667 | 1 | 31.2 | 3.4 | 3890.2 | 3890.2 | 3.42392 | 0.00408377 | 32.0576
MULLION | Z/758 | 5 deg | +0.000 | +4.877 | 2 | 39.1 | 4.3 | 4877.3 | 4877.32 | 4.29219 | 0.00512002 | 40.1921
4 x RAFTER | Z/746 | 5 deg | +4.807 | +5.399 | 1 | 31.2 | 3.4 | 3890.2 | 3890.2 | 3.42392 | 0.00408377 | 32.0576
MULLION | Z/757 | 3 deg | +0.000 | +4.843 | 2 | 39 | 4.3 | 4843.2 | 4843.21 | 4.26219 | 0.00508421 | 39.911
4 x RAFTER | Z/745 | 3 deg | +4.807 | +5.265 | 1 | 31.2 | 3.4 | 3890.2 | 3890.2 | 3.42392 | 0.00408377 | 32.0576
MULLION | Z/762 | 25 deg | +0.000 | +5.246 | 2 | 42.1 | 4.6 | 5245.6 | 5245.6 | 4.61613 | 0.00550662 | 43.227
MULLION | Z/761 | 18 deg | +0.000 | +5.108 | 2 | 41 | 4.5 | 5108.1 | 5108.14 | 4.49522 | 0.00536232 | 42.0942
4 x RAFTER | Z/749 | 18 deg | +4.807 | +6.251 | 1 | 31.2 | 3.4 | 3890.2 | 3890.2 | 3.42392 | 0.00408377 | 32.0576
MULLION | Z/760 | 15 deg | +0.000 | +5.054 | 2 | 40.5 | 4.5 | 5053.7 | 5053.73 | 4.44736 | 0.0053052 | 41.6458
4 x RAFTER | Z/748 | 15 deg | +4.807 | +6.059 | 1 | 31.2 | 3.4 | 3890.2 | 3890.2 | 3.42392 | 0.00408377 | 32.0576
MULLION | Z/729 | 9 deg | +0.000 | +4.992 | 2 | 40 | 4.5 | 4991.6 | 4991.6 | 4.39271 | 0.00523998 | 41.1339
MULLION | Z/728 | 5 deg | +0.000 | +4.919 | 2 | 39.4 | 4.3 | 4919.1 | 4919.12 | 4.32896 | 0.0051639 | 40.5366
MULLION | Z/727 | 3 deg | +0.000 | +4.883 | 2 | 39.2 | 4.3 | 4883.1 | 4883.13 | 4.2973 | 0.00512611 | 40.24
MULLION | Z/732 | 15 deg | +0.000 | +5.302 | 2 | 42.5 | 4.6 | 5301.6 | 5301.58 | 4.66537 | 0.00556539 | 43.6883
MULLION | Z/731 | 18 deg | +0.000 | +5.159 | 2 | 41.4 | 4.5 | 5159 | 5159.02 | 4.53997 | 0.00541573 | 42.5135
MULLION | Z/730 | 15 deg | +0.000 | +5.102 | 2 | 41 | 4.5 | 5101.6 | 5101.58 | 4.48945 | 0.00535543 | 42.0402
MULLION | Z/721 | 12 deg | +0.000 | +4.911 | 2 | 39.4 | 4.3 | 4911.4 | 4911.36 | 4.32213 | 0.00515575 | 40.4726
MULLION | Z/716 | 12 deg | +0.000 | +4.957 | 2 | 39.8 | 4.5 | 4957.2 | 4957.16 | 4.36242 | 0.00520383 | 40.8501
MULLION | Z/700 | 12 deg | +0.000 | +5.046 | 2 | 40.5 | 4.5 | 5045.7 | 5045.72 | 4.44031 | 0.0052968 | 41.5798
MULLION | Z/709 | 12 deg | +0.000 | +4.999 | 2 | 40.1 | 4.5 | 4998.9 | 4998.91 | 4.39914 | 0.00524766 | 41.1941
2 x RAFTER | Z/705 | 12 deg | +4.807 | +5.865 | 1 | 31.2 | 3.4 | 3890.2 | 3890.2 | 3.42392 | 0.00408378 | 32.0576
2 x RAFTER | Z/705 | 12 deg | +4.807 | +5.865 | 1 | 31.2 | 3.4 | 3890.2 | 3890.2 | 3.42392 | 0.00408377 | 32.0576

# IfcBeam: C:300-30 (52)
In: Undefined
Description: C:300-30; Material: STEEL/G450
Tekla Common - Phase: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.3 m2; Height: 300 mm; Width: 96 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Finish | Bottom elevation | Top elevation | Class | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
MULLION | Z/825 | 9 deg | +0.000 | +4.972 | 2 | 62.2 | 5.4 | 4971.7 | 4971.66 | 5.43231 | 0.00809883 | 63.5758
MULLION | Z/824 | 5 deg | +0.000 | +4.859 | 2 | 60.8 | 5.4 | 4858.6 | 4858.64 | 5.30889 | 0.00791472 | 62.1306
MULLION | Z/823 | 3 deg | +0.000 | +4.803 | 2 | 60.1 | 5.2 | 4802.7 | 4802.71 | 5.24782 | 0.00782361 | 61.4154
MULLION | Z/828 | 25 deg | +0.000 | +5.463 | 2 | 68.3 | 6 | 5462.6 | 5462.56 | 5.96837 | 0.00889851 | 69.8533
MULLION | Z/827 | 18 deg | +0.000 | +5.237 | 2 | 65.5 | 5.7 | 5237.2 | 5237.15 | 5.72223 | 0.00853132 | 66.9708
MULLION | Z/826 | 15 deg | +0.000 | +5.146 | 2 | 64.4 | 5.7 | 5146.3 | 5146.33 | 5.62305 | 0.00838337 | 65.8095
MULLION | Z/795 | 9 deg | +0.000 | +5.016 | 2 | 62.7 | 5.4 | 5015.5 | 5015.54 | 5.48023 | 0.00817031 | 64.137
4 x RAFTER | Z/777 | 9 deg | +4.772 | +5.672 | 1 | 48.2 | 4.3 | 3856.9 | 3856.9 | 4.21499 | 0.00628289 | 49.3207
MULLION | Z/794 | 5 deg | +0.000 | +4.900 | 2 | 61.3 | 5.4 | 4900 | 4900.01 | 5.35407 | 0.00798212 | 62.6596
4 x RAFTER | Z/776 | 5 deg | +4.772 | +5.407 | 1 | 48.2 | 4.3 | 3856.9 | 3856.9 | 4.21499 | 0.00628289 | 49.3207
MULLION | Z/793 | 3 deg | +0.000 | +4.843 | 2 | 60.6 | 5.4 | 4842.8 | 4842.84 | 5.29164 | 0.00788899 | 61.9285
4 x RAFTER | Z/775 | 3 deg | +4.772 | +5.274 | 1 | 48.2 | 4.3 | 3856.9 | 3856.9 | 4.21499 | 0.00628289 | 49.3207
MULLION | Z/798 | 25 deg | +0.000 | +5.517 | 2 | 69 | 6 | 5517.3 | 5517.34 | 6.02819 | 0.00898775 | 70.5538
MULLION | Z/797 | 18 deg | +0.000 | +5.287 | 2 | 66.1 | 5.8 | 5286.9 | 5286.93 | 5.77659 | 0.00861241 | 67.6074
4 x RAFTER | Z/779 | 18 deg | +4.772 | +6.250 | 1 | 48.2 | 4.3 | 3856.9 | 3856.9 | 4.21499 | 0.00628289 | 49.3207
MULLION | Z/796 | 15 deg | +0.000 | +5.194 | 2 | 65 | 5.7 | 5194.1 | 5194.09 | 5.6752 | 0.00846117 | 66.4202
4 x RAFTER | Z/778 | 15 deg | +4.772 | +6.060 | 1 | 48.2 | 4.3 | 3856.9 | 3856.9 | 4.21499 | 0.00628289 | 49.3207
MULLION | Z/765 | 9 deg | +0.000 | +5.056 | 2 | 63.2 | 5.4 | 5055.5 | 5055.53 | 5.5239 | 0.00823546 | 64.6483
MULLION | Z/764 | 5 deg | +0.000 | +4.938 | 2 | 61.7 | 5.4 | 4937.7 | 4937.69 | 5.39522 | 0.0080435 | 63.1415
MULLION | Z/763 | 3 deg | +0.000 | +4.879 | 2 | 61 | 5.4 | 4879.4 | 4879.38 | 5.33154 | 0.00794851 | 62.3958
MULLION | Z/768 | 25 deg | +0.000 | +5.567 | 2 | 69.6 | 6.1 | 5567.4 | 5567.35 | 6.0828 | 0.00906921 | 71.1933
MULLION | Z/767 | 18 deg | +0.000 | +5.332 | 2 | 66.7 | 5.8 | 5332.3 | 5332.34 | 5.82617 | 0.00868638 | 68.1881
MULLION | Z/766 | 15 deg | +0.000 | +5.239 | 2 | 65.5 | 5.7 | 5238.6 | 5238.62 | 5.72383 | 0.00853371 | 66.9896
MULLION | Z/735 | 9 deg | +0.000 | +5.101 | 2 | 63.8 | 5.7 | 5100.9 | 5100.89 | 5.57343 | 0.00830935 | 65.2284
MULLION | Z/734 | 5 deg | +0.000 | +4.979 | 2 | 62.3 | 5.4 | 4979.5 | 4979.49 | 5.44086 | 0.00811159 | 63.676
MULLION | Z/733 | 3 deg | +0.000 | +4.919 | 2 | 61.5 | 5.4 | 4919.2 | 4919.3 | 5.37513 | 0.00801354 | 62.9063
MULLION | Z/738 | 15 deg | +0.000 | +5.623 | 2 | 70.3 | 6.1 | 5623.3 | 5623.33 | 6.14393 | 0.0091604 | 71.9092
MULLION | Z/737 | 18 deg | +0.000 | +5.383 | 2 | 67.3 | 5.8 | 5383.2 | 5383.21 | 5.88172 | 0.00876925 | 68.8386
MULLION | Z/736 | 15 deg | +0.000 | +5.286 | 2 | 66.1 | 5.8 | 5286.5 | 5286.46 | 5.77607 | 0.00861164 | 67.6014
MULLION | Z/722 | 12 deg | +0.000 | +5.058 | 2 | 63.3 | 5.4 | 5058 | 5058.02 | 5.52662 | 0.00823951 | 64.6802
MULLION | Z/711 | 12 deg | +0.000 | +5.146 | 2 | 64.3 | 5.7 | 5145.6 | 5145.57 | 5.62222 | 0.00838213 | 65.7997
MULLION | Z/702 | 12 deg | +0.000 | +5.192 | 2 | 65 | 5.7 | 5192.4 | 5192.39 | 5.67335 | 0.0084584 | 66.3985
MULLION | Z/717 | 12 deg | +0.000 | +5.104 | 2 | 63.8 | 5.7 | 5103.8 | 5103.82 | 5.57663 | 0.00831412 | 65.2659
2 x RAFTER | Z/714 | 12 deg | +4.772 | +5.868 | 1 | 48.2 | 4.3 | 3856.9 | 3856.9 | 4.215 | 0.00628289 | 49.3207
2 x RAFTER | Z/714 | 12 deg | +4.772 | +5.868 | 1 | 48.2 | 4.3 | 3856.9 | 3856.9 | 4.21499 | 0.00628289 | 49.3207

# IfcBeam: C:350-30 (52)
In: Undefined
Description: C:350-30; Material: STEEL/G450
Tekla Common - Phase: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.2 m2; Height: 350 mm; Width: 125 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Finish | Bottom elevation | Top elevation | Class | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
MULLION | Z/831 | 9 deg | +0.000 | +5.080 | 2 | 76 | 6.6 | 5080.2 | 5080.23 | 6.61835 | 0.00987597 | 77.5263
4 x RAFTER | Z/807 | 9 deg | +4.734 | +5.678 | 1 | 57.1 | 5 | 3820.7 | 3820.71 | 4.97845 | 0.00742746 | 58.3056
MULLION | Z/830 | 5 deg | +0.000 | +4.919 | 2 | 73.6 | 6.4 | 4918.6 | 4918.61 | 6.40792 | 0.00956178 | 75.06
4 x RAFTER | Z/806 | 5 deg | +4.734 | +5.416 | 1 | 57.1 | 5 | 3820.7 | 3820.71 | 4.97845 | 0.00742746 | 58.3056
MULLION | Z/829 | 3 deg | +0.000 | +4.839 | 2 | 72.4 | 6.4 | 4838.6 | 4838.64 | 6.3038 | 0.00940632 | 73.8396
4 x RAFTER | Z/805 | 3 deg | +4.734 | +5.284 | 1 | 57.1 | 5 | 3820.7 | 3820.71 | 4.97845 | 0.00742746 | 58.3056
MULLION | Z/834 | 25 deg | +0.000 | +5.782 | 2 | 86.5 | 7.5 | 5782.2 | 5782.21 | 7.53233 | 0.0112406 | 88.2388
MULLION | Z/833 | 18 deg | +0.000 | +5.460 | 2 | 81.6 | 7.1 | 5459.9 | 5459.89 | 7.11266 | 0.010614 | 83.3201
4 x RAFTER | Z/809 | 18 deg | +4.734 | +6.248 | 1 | 57.1 | 5 | 3820.7 | 3820.71 | 4.97845 | 0.00742746 | 58.3056
MULLION | Z/832 | 15 deg | +0.000 | +5.330 | 2 | 79.7 | 6.9 | 5330 | 5330.01 | 6.94356 | 0.0103615 | 81.3381
4 x RAFTER | Z/808 | 15 deg | +4.734 | +6.061 | 1 | 57.1 | 5 | 3820.7 | 3820.71 | 4.97845 | 0.00742746 | 58.3056
MULLION | Z/801 | 9 deg | +0.000 | +5.124 | 2 | 76.6 | 6.6 | 5124.1 | 5124.12 | 6.67549 | 0.00996129 | 78.1961
MULLION | Z/800 | 5 deg | +0.000 | +4.960 | 2 | 74.2 | 6.4 | 4960 | 4959.98 | 6.46178 | 0.0096422 | 75.6913
MULLION | Z/799 | 3 deg | +0.000 | +4.879 | 2 | 73 | 6.4 | 4878.8 | 4878.77 | 6.35605 | 0.00948433 | 74.452
MULLION | Z/804 | 25 deg | +0.000 | +5.837 | 2 | 87.3 | 7.6 | 5837 | 5837 | 7.60366 | 0.0113471 | 89.075
MULLION | Z/803 | 18 deg | +0.000 | +5.510 | 2 | 82.4 | 7.1 | 5509.7 | 5509.67 | 7.17748 | 0.0107108 | 84.0798
MULLION | Z/802 | 15 deg | +0.000 | +5.378 | 2 | 80.4 | 6.9 | 5377.8 | 5377.77 | 7.00574 | 0.0104544 | 82.0669
MULLION | Z/771 | 9 deg | +0.000 | +5.164 | 2 | 77.2 | 6.6 | 5164.1 | 5164.1 | 6.72755 | 0.010039 | 78.8062
MULLION | Z/770 | 5 deg | +0.000 | +4.998 | 2 | 74.7 | 6.4 | 4997.7 | 4997.66 | 6.51084 | 0.00971545 | 76.2663
MULLION | Z/769 | 3 deg | +0.000 | +4.915 | 2 | 73.5 | 6.4 | 4915.3 | 4915.3 | 6.40361 | 0.00955534 | 75.0094
MULLION | Z/774 | 25 deg | +0.000 | +5.887 | 2 | 88 | 7.6 | 5887 | 5887.01 | 7.66878 | 0.0114443 | 89.8381
MULLION | Z/773 | 18 deg | +0.000 | +5.555 | 2 | 83.1 | 7.1 | 5555.1 | 5555.07 | 7.23659 | 0.0107991 | 84.7726
MULLION | Z/772 | 15 deg | +0.000 | +5.422 | 2 | 81.1 | 7.1 | 5422.3 | 5422.3 | 7.06372 | 0.010541 | 82.7465
MULLION | Z/741 | 9 deg | +0.000 | +5.209 | 2 | 77.9 | 6.9 | 5209.5 | 5209.46 | 6.7866 | 0.0101272 | 79.4984
MULLION | Z/740 | 5 deg | +0.000 | +5.039 | 2 | 75.4 | 6.6 | 5039.5 | 5039.47 | 6.56528 | 0.00979673 | 76.9043
MULLION | Z/739 | 3 deg | +0.000 | +4.955 | 2 | 74.2 | 6.4 | 4955.2 | 4955.22 | 6.45558 | 0.00963295 | 75.6186
MULLION | Z/744 | 15 deg | +0.000 | +5.943 | 2 | 88.9 | 7.6 | 5943 | 5942.99 | 7.74166 | 0.0115532 | 90.6924
MULLION | Z/743 | 18 deg | +0.000 | +5.606 | 2 | 83.8 | 7.3 | 5606 | 5605.95 | 7.30283 | 0.010898 | 85.549
MULLION | Z/742 | 15 deg | +0.000 | +5.470 | 2 | 81.8 | 7.1 | 5470.1 | 5470.14 | 7.12601 | 0.010634 | 83.4765
MULLION | Z/718 | 12 deg | +0.000 | +5.250 | 2 | 78.5 | 6.9 | 5249.5 | 5249.53 | 6.83878 | 0.0102051 | 80.1099
MULLION | Z/713 | 12 deg | +0.000 | +5.291 | 2 | 79.1 | 6.9 | 5291.3 | 5291.28 | 6.89313 | 0.0102862 | 80.747
MULLION | Z/704 | 12 deg | +0.000 | +5.338 | 2 | 79.8 | 6.9 | 5338.1 | 5338.1 | 6.95409 | 0.0103773 | 81.4615
MULLION | Z/723 | 12 deg | +0.000 | +5.204 | 2 | 77.9 | 6.9 | 5203.7 | 5203.73 | 6.77914 | 0.0101161 | 79.411
4 x RAFTER | Z/719 | 12 deg | +4.734 | +5.871 | 1 | 57.1 | 5 | 3820.7 | 3820.71 | 4.97845 | 0.00742746 | 58.3056

# IfcColumn: C:200-24 (28)
In: Undefined
Description: C:200-24; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Phase: 1; Class: 2
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 110 m2; Height: 203 mm; Width: 76 mm
Pset_ColumnCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Finish | Top elevation | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
MULLION | Z/813 | 9 deg | +4.752 | 33.7 | 3.7 | 4751.5 | 4751.51 | 3.70614 | 0.00441776 | 34.6794
MULLION | Z/812 | 5 deg | +4.737 | 33.6 | 3.7 | 4737 | 4737.03 | 3.69485 | 0.0044043 | 34.5738
MULLION | Z/811 | 3 deg | +4.730 | 33.5 | 3.7 | 4729.9 | 4729.86 | 3.68926 | 0.00439763 | 34.5214
MULLION | Z/816 | 25 deg | +4.814 | 34.1 | 3.8 | 4814.4 | 4814.39 | 3.75516 | 0.00447623 | 35.1384
MULLION | Z/815 | 18 deg | +4.786 | 33.9 | 3.7 | 4785.5 | 4785.52 | 3.73265 | 0.00444939 | 34.9277
MULLION | Z/783 | 9 deg | +4.795 | 34 | 3.7 | 4795.4 | 4795.39 | 3.74035 | 0.00445856 | 34.9997
MULLION | Z/782 | 5 deg | +4.778 | 33.9 | 3.7 | 4778.4 | 4778.4 | 3.7271 | 0.00444277 | 34.8757
MULLION | Z/781 | 3 deg | +4.770 | 33.9 | 3.7 | 4770 | 4770 | 3.72055 | 0.00443496 | 34.8144
MULLION | Z/786 | 25 deg | +4.869 | 34.5 | 3.8 | 4869.2 | 4869.17 | 3.79786 | 0.00452716 | 35.5382
MULLION | Z/785 | 18 deg | +4.835 | 34.3 | 3.8 | 4835.3 | 4835.29 | 3.77145 | 0.00449566 | 35.2909
MULLION | Z/753 | 9 deg | +4.835 | 34.3 | 3.8 | 4835.4 | 4835.37 | 3.77151 | 0.00449573 | 35.2915
MULLION | Z/752 | 5 deg | +4.816 | 34.1 | 3.8 | 4816.1 | 4816.08 | 3.75648 | 0.0044778 | 35.1507
MULLION | Z/751 | 3 deg | +4.807 | 34.1 | 3.7 | 4806.5 | 4806.53 | 3.74903 | 0.00446892 | 35.081
MULLION | Z/756 | 25 deg | +4.919 | 34.9 | 3.8 | 4919.2 | 4919.18 | 3.83685 | 0.00457366 | 35.9032
MULLION | Z/755 | 18 deg | +4.881 | 34.6 | 3.8 | 4880.7 | 4880.7 | 3.80685 | 0.00453788 | 35.6224
MULLION | Z/710 | 9 deg | +4.881 | 34.6 | 3.8 | 4880.7 | 4880.73 | 3.80688 | 0.00453791 | 35.6226
MULLION | Z/708 | 5 deg | +4.858 | 34.3 | 3.8 | 4857.9 | 4857.88 | 3.78906 | 0.00451666 | 35.4558
MULLION | Z/706 | 3 deg | +4.846 | 34.3 | 3.8 | 4846.5 | 4846.45 | 3.78015 | 0.00450604 | 35.3724
MULLION | Z/725 | 15 deg | +4.975 | 35.3 | 3.9 | 4975.2 | 4975.16 | 3.88049 | 0.0046257 | 36.3118
MULLION | Z/724 | 18 deg | +4.932 | 35 | 3.8 | 4931.6 | 4931.57 | 3.84651 | 0.00458518 | 35.9936
MULLION | Z/814 | 15 deg | +4.774 | 33.9 | 3.7 | 4773.9 | 4773.88 | 3.72358 | 0.00443856 | 34.8427
MULLION | Z/784 | 15 deg | +4.822 | 34.2 | 3.8 | 4821.6 | 4821.64 | 3.76081 | 0.00448297 | 35.1913
MULLION | Z/754 | 15 deg | +4.866 | 34.5 | 3.8 | 4866.2 | 4866.17 | 3.79553 | 0.00452437 | 35.5163
MULLION | Z/712 | 15 deg | +4.914 | 34.9 | 3.8 | 4914 | 4914.01 | 3.83282 | 0.00456885 | 35.8655
MULLION | Z/720 | 12 deg | +4.763 | 33.9 | 3.7 | 4762.6 | 4762.57 | 3.71476 | 0.00442805 | 34.7602
MULLION | Z/715 | 12 deg | +4.808 | 34.1 | 3.8 | 4808.4 | 4808.37 | 3.75046 | 0.00447063 | 35.0944
MULLION | Z/707 | 12 deg | +4.850 | 34.3 | 3.8 | 4850.1 | 4850.12 | 3.78301 | 0.00450945 | 35.3992
MULLION | Z/698 | 12 deg | +4.897 | 34.7 | 3.8 | 4896.9 | 4896.93 | 3.81951 | 0.00455297 | 35.7408

# IfcColumn: C:250-24 (28)
In: Undefined
Description: C:250-24; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Phase: 1; Class: 2
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 109.7 m2; Height: 254 mm; Width: 76 mm
Pset_ColumnCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Finish | Top elevation | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
MULLION | Z/819 | 9 deg | +4.862 | 39 | 4.3 | 4862.4 | 4862.38 | 4.27905 | 0.00510433 | 40.069
MULLION | Z/818 | 5 deg | +4.798 | 38.5 | 4.3 | 4798.3 | 4798.27 | 4.22266 | 0.00503703 | 39.5407
MULLION | Z/817 | 3 deg | +4.767 | 38.2 | 4.3 | 4766.6 | 4766.55 | 4.19476 | 0.00500373 | 39.2793
MULLION | Z/822 | 25 deg | +5.141 | 41.2 | 4.5 | 5140.8 | 5140.81 | 4.52396 | 0.00539662 | 42.3634
MULLION | Z/821 | 18 deg | +5.013 | 40.2 | 4.5 | 5013 | 5012.96 | 4.4115 | 0.00526241 | 41.3099
MULLION | Z/789 | 9 deg | +4.906 | 39.4 | 4.3 | 4906.3 | 4906.26 | 4.31765 | 0.0051504 | 40.4306
MULLION | Z/788 | 5 deg | +4.840 | 38.8 | 4.3 | 4839.6 | 4839.64 | 4.25905 | 0.00508046 | 39.8816
MULLION | Z/787 | 3 deg | +4.807 | 38.6 | 4.3 | 4806.7 | 4806.68 | 4.23006 | 0.00504586 | 39.61
MULLION | Z/792 | 25 deg | +5.196 | 41.7 | 4.6 | 5195.6 | 5195.59 | 4.57214 | 0.00545412 | 42.8149
MULLION | Z/791 | 18 deg | +5.063 | 40.6 | 4.5 | 5062.7 | 5062.74 | 4.45529 | 0.00531466 | 41.7201
MULLION | Z/759 | 9 deg | +4.946 | 39.7 | 4.5 | 4946.2 | 4946.24 | 4.35281 | 0.00519237 | 40.7601
MULLION | Z/758 | 5 deg | +4.877 | 39.1 | 4.3 | 4877.3 | 4877.32 | 4.29219 | 0.00512002 | 40.1921
MULLION | Z/757 | 3 deg | +4.843 | 39 | 4.3 | 4843.2 | 4843.21 | 4.26219 | 0.00508421 | 39.911
MULLION | Z/762 | 25 deg | +5.246 | 42.1 | 4.6 | 5245.6 | 5245.6 | 4.61613 | 0.00550662 | 43.227
MULLION | Z/761 | 18 deg | +5.108 | 41 | 4.5 | 5108.1 | 5108.14 | 4.49522 | 0.00536232 | 42.0942
MULLION | Z/729 | 9 deg | +4.992 | 40 | 4.5 | 4991.6 | 4991.6 | 4.39271 | 0.00523998 | 41.1339
MULLION | Z/728 | 5 deg | +4.919 | 39.4 | 4.3 | 4919.1 | 4919.12 | 4.32896 | 0.0051639 | 40.5366
MULLION | Z/727 | 3 deg | +4.883 | 39.2 | 4.3 | 4883.1 | 4883.13 | 4.2973 | 0.00512611 | 40.24
MULLION | Z/732 | 15 deg | +5.302 | 42.5 | 4.6 | 5301.6 | 5301.58 | 4.66537 | 0.00556539 | 43.6883
MULLION | Z/731 | 18 deg | +5.159 | 41.4 | 4.5 | 5159 | 5159.02 | 4.53997 | 0.00541573 | 42.5135
MULLION | Z/820 | 15 deg | +4.961 | 39.8 | 4.5 | 4961.5 | 4961.45 | 4.36619 | 0.00520833 | 40.8854
MULLION | Z/790 | 15 deg | +5.009 | 40.2 | 4.5 | 5009.2 | 5009.21 | 4.4082 | 0.00525847 | 41.279
MULLION | Z/730 | 15 deg | +5.102 | 41 | 4.5 | 5101.6 | 5101.58 | 4.48945 | 0.00535543 | 42.0402
MULLION | Z/760 | 15 deg | +5.054 | 40.5 | 4.5 | 5053.7 | 5053.73 | 4.44736 | 0.0053052 | 41.6458
MULLION | Z/721 | 12 deg | +4.911 | 39.4 | 4.3 | 4911.4 | 4911.36 | 4.32213 | 0.00515575 | 40.4726
MULLION | Z/716 | 12 deg | +4.957 | 39.8 | 4.5 | 4957.2 | 4957.16 | 4.36242 | 0.00520383 | 40.8501
MULLION | Z/700 | 12 deg | +5.046 | 40.5 | 4.5 | 5045.7 | 5045.72 | 4.44031 | 0.0052968 | 41.5798
MULLION | Z/709 | 12 deg | +4.999 | 40.1 | 4.5 | 4998.9 | 4998.91 | 4.39914 | 0.00524766 | 41.1941

# IfcColumn: C:300-30 (28)
In: Undefined
Description: C:300-30; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Phase: 1; Class: 2
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.3 m2; Height: 300 mm; Width: 96 mm
Pset_ColumnCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Finish | Top elevation | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
MULLION | Z/825 | 9 deg | +4.972 | 62.2 | 5.4 | 4971.7 | 4971.66 | 5.43231 | 0.00809883 | 63.5758
MULLION | Z/824 | 5 deg | +4.859 | 60.8 | 5.4 | 4858.6 | 4858.64 | 5.30889 | 0.00791472 | 62.1306
MULLION | Z/823 | 3 deg | +4.803 | 60.1 | 5.2 | 4802.7 | 4802.71 | 5.24782 | 0.00782361 | 61.4154
MULLION | Z/828 | 25 deg | +5.463 | 68.3 | 6 | 5462.6 | 5462.56 | 5.96837 | 0.00889851 | 69.8533
MULLION | Z/827 | 18 deg | +5.237 | 65.5 | 5.7 | 5237.2 | 5237.15 | 5.72223 | 0.00853132 | 66.9708
MULLION | Z/795 | 9 deg | +5.016 | 62.7 | 5.4 | 5015.5 | 5015.54 | 5.48023 | 0.00817031 | 64.137
MULLION | Z/794 | 5 deg | +4.900 | 61.3 | 5.4 | 4900 | 4900.01 | 5.35407 | 0.00798212 | 62.6596
MULLION | Z/793 | 3 deg | +4.843 | 60.6 | 5.4 | 4842.8 | 4842.84 | 5.29164 | 0.00788899 | 61.9285
MULLION | Z/798 | 25 deg | +5.517 | 69 | 6 | 5517.3 | 5517.34 | 6.02819 | 0.00898775 | 70.5538
MULLION | Z/797 | 18 deg | +5.287 | 66.1 | 5.8 | 5286.9 | 5286.93 | 5.77659 | 0.00861241 | 67.6074
MULLION | Z/765 | 9 deg | +5.056 | 63.2 | 5.4 | 5055.5 | 5055.53 | 5.5239 | 0.00823546 | 64.6483
MULLION | Z/764 | 5 deg | +4.938 | 61.7 | 5.4 | 4937.7 | 4937.69 | 5.39522 | 0.0080435 | 63.1415
MULLION | Z/763 | 3 deg | +4.879 | 61 | 5.4 | 4879.4 | 4879.38 | 5.33154 | 0.00794851 | 62.3958
MULLION | Z/768 | 25 deg | +5.567 | 69.6 | 6.1 | 5567.4 | 5567.35 | 6.0828 | 0.00906921 | 71.1933
MULLION | Z/767 | 18 deg | +5.332 | 66.7 | 5.8 | 5332.3 | 5332.34 | 5.82617 | 0.00868638 | 68.1881
MULLION | Z/735 | 9 deg | +5.101 | 63.8 | 5.7 | 5100.9 | 5100.89 | 5.57343 | 0.00830935 | 65.2284
MULLION | Z/734 | 5 deg | +4.979 | 62.3 | 5.4 | 4979.5 | 4979.49 | 5.44086 | 0.00811159 | 63.676
MULLION | Z/733 | 3 deg | +4.919 | 61.5 | 5.4 | 4919.2 | 4919.3 | 5.37513 | 0.00801354 | 62.9063
MULLION | Z/738 | 15 deg | +5.623 | 70.3 | 6.1 | 5623.3 | 5623.33 | 6.14393 | 0.0091604 | 71.9092
MULLION | Z/737 | 18 deg | +5.383 | 67.3 | 5.8 | 5383.2 | 5383.21 | 5.88172 | 0.00876925 | 68.8386
MULLION | Z/826 | 15 deg | +5.146 | 64.4 | 5.7 | 5146.3 | 5146.33 | 5.62305 | 0.00838337 | 65.8095
MULLION | Z/766 | 15 deg | +5.239 | 65.5 | 5.7 | 5238.6 | 5238.62 | 5.72383 | 0.00853371 | 66.9896
MULLION | Z/736 | 15 deg | +5.286 | 66.1 | 5.8 | 5286.5 | 5286.46 | 5.77607 | 0.00861164 | 67.6014
MULLION | Z/796 | 15 deg | +5.194 | 65 | 5.7 | 5194.1 | 5194.09 | 5.6752 | 0.00846117 | 66.4202
MULLION | Z/722 | 12 deg | +5.058 | 63.3 | 5.4 | 5058 | 5058.02 | 5.52662 | 0.00823951 | 64.6802
MULLION | Z/711 | 12 deg | +5.146 | 64.3 | 5.7 | 5145.6 | 5145.57 | 5.62222 | 0.00838213 | 65.7997
MULLION | Z/702 | 12 deg | +5.192 | 65 | 5.7 | 5192.4 | 5192.39 | 5.67335 | 0.0084584 | 66.3985
MULLION | Z/717 | 12 deg | +5.104 | 63.8 | 5.7 | 5103.8 | 5103.82 | 5.57663 | 0.00831412 | 65.2659

# IfcColumn: C:350-30 (28)
In: Undefined
Description: C:350-30; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Phase: 1; Class: 2
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.2 m2; Height: 350 mm; Width: 125 mm
Pset_ColumnCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Finish | Top elevation | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
MULLION | Z/831 | 9 deg | +5.080 | 76 | 6.6 | 5080.2 | 5080.23 | 6.61835 | 0.00987597 | 77.5263
MULLION | Z/830 | 5 deg | +4.919 | 73.6 | 6.4 | 4918.6 | 4918.61 | 6.40792 | 0.00956178 | 75.06
MULLION | Z/829 | 3 deg | +4.839 | 72.4 | 6.4 | 4838.6 | 4838.64 | 6.3038 | 0.00940632 | 73.8396
MULLION | Z/834 | 25 deg | +5.782 | 86.5 | 7.5 | 5782.2 | 5782.21 | 7.53233 | 0.0112406 | 88.2388
MULLION | Z/833 | 18 deg | +5.460 | 81.6 | 7.1 | 5459.9 | 5459.89 | 7.11266 | 0.010614 | 83.3201
MULLION | Z/801 | 9 deg | +5.124 | 76.6 | 6.6 | 5124.1 | 5124.12 | 6.67549 | 0.00996129 | 78.1961
MULLION | Z/800 | 5 deg | +4.960 | 74.2 | 6.4 | 4960 | 4959.98 | 6.46178 | 0.0096422 | 75.6913
MULLION | Z/799 | 3 deg | +4.879 | 73 | 6.4 | 4878.8 | 4878.77 | 6.35605 | 0.00948433 | 74.452
MULLION | Z/804 | 25 deg | +5.837 | 87.3 | 7.6 | 5837 | 5837 | 7.60366 | 0.0113471 | 89.075
MULLION | Z/803 | 18 deg | +5.510 | 82.4 | 7.1 | 5509.7 | 5509.67 | 7.17748 | 0.0107108 | 84.0798
MULLION | Z/771 | 9 deg | +5.164 | 77.2 | 6.6 | 5164.1 | 5164.1 | 6.72755 | 0.010039 | 78.8062
MULLION | Z/770 | 5 deg | +4.998 | 74.7 | 6.4 | 4997.7 | 4997.66 | 6.51084 | 0.00971545 | 76.2663
MULLION | Z/769 | 3 deg | +4.915 | 73.5 | 6.4 | 4915.3 | 4915.3 | 6.40361 | 0.00955534 | 75.0094
MULLION | Z/774 | 25 deg | +5.887 | 88 | 7.6 | 5887 | 5887.01 | 7.66878 | 0.0114443 | 89.8381
MULLION | Z/773 | 18 deg | +5.555 | 83.1 | 7.1 | 5555.1 | 5555.07 | 7.23659 | 0.0107991 | 84.7726
MULLION | Z/741 | 9 deg | +5.209 | 77.9 | 6.9 | 5209.5 | 5209.46 | 6.7866 | 0.0101272 | 79.4984
MULLION | Z/740 | 5 deg | +5.039 | 75.4 | 6.6 | 5039.5 | 5039.47 | 6.56528 | 0.00979673 | 76.9043
MULLION | Z/739 | 3 deg | +4.955 | 74.2 | 6.4 | 4955.2 | 4955.22 | 6.45558 | 0.00963295 | 75.6186
MULLION | Z/744 | 15 deg | +5.943 | 88.9 | 7.6 | 5943 | 5942.99 | 7.74166 | 0.0115532 | 90.6924
MULLION | Z/743 | 18 deg | +5.606 | 83.8 | 7.3 | 5606 | 5605.95 | 7.30283 | 0.010898 | 85.549
MULLION | Z/802 | 15 deg | +5.378 | 80.4 | 6.9 | 5377.8 | 5377.77 | 7.00574 | 0.0104544 | 82.0669
MULLION | Z/772 | 15 deg | +5.422 | 81.1 | 7.1 | 5422.3 | 5422.3 | 7.06372 | 0.010541 | 82.7465
MULLION | Z/742 | 15 deg | +5.470 | 81.8 | 7.1 | 5470.1 | 5470.14 | 7.12601 | 0.010634 | 83.4765
MULLION | Z/832 | 15 deg | +5.330 | 79.7 | 6.9 | 5330 | 5330.01 | 6.94356 | 0.0103615 | 81.3381
MULLION | Z/718 | 12 deg | +5.250 | 78.5 | 6.9 | 5249.5 | 5249.53 | 6.83878 | 0.0102051 | 80.1099
MULLION | Z/713 | 12 deg | +5.291 | 79.1 | 6.9 | 5291.3 | 5291.28 | 6.89313 | 0.0102862 | 80.747
MULLION | Z/704 | 12 deg | +5.338 | 79.8 | 6.9 | 5338.1 | 5338.1 | 6.95409 | 0.0103773 | 81.4615
MULLION | Z/723 | 12 deg | +5.204 | 77.9 | 6.9 | 5203.7 | 5203.73 | 6.77914 | 0.0101161 | 79.411

# IfcElementAssembly (784)
In: Undefined
PredefinedType: RIGID_FRAME
Name | ASSEMBLY_POSITION_CODE = Assembly/Cast unit position code | ASSEMBLY_POS = Assembly/Cast unit Mark | Assembly/Cast unit weight (kg) | Assembly/Cast unit bottom elevation | Assembly/Cast unit top elevation | Width (mm)
MULLION TOP PLATE | C350SD/9deg | PL/542 | 1.5 | +4.587 | +4.765 | 177.768
MULLION TOP PLATE | C350SD/9deg-9deg | PL/554 | 1.5 | +4.587 | +4.793 | 178.618
MULLION TOP PLATE | C350SD/9deg-9deg | PL/572 | 1.8 | +4.697 | +4.876 | 177.768
MULLION TOP PLATE | C350SD/9deg-9deg | PL/571 | 1.8 | +4.697 | +4.904 | 178.618
MULLION TOP PLATE | C350SD/9deg-9deg | PL/600 | 2.2 | +4.807 | +4.985 | 177.773
MULLION TOP PLATE | C350SD/9deg-9deg | PL/599 | 2.2 | +4.807 | +5.013 | 178.717
2 x MULLION | C350SD/9deg-9deg | Z/825 | 62.2 | +0.000 | +4.972 | 96
2 x MULLION | C350SD/9deg-9deg | Z/819 | 39 | +0.000 | +4.862 | 76
2 x MULLION | C350SD/9deg-9deg | Z/813 | 33.7 | +0.000 | +4.752 | 76
MULLION TOP PLATE | C350SD/9deg-9deg | PL/628 | 2.6 | +4.915 | +5.094 | 177.776
MULLION TOP PLATE | C350SD/9deg-9deg | PL/627 | 2.6 | +4.915 | +5.122 | 178.715
2 x MULLION | C350SD/9deg-9deg | Z/831 | 76 | +0.000 | +5.080 | 125
4 x RAFTER | C350SD/9deg-9deg | Z/807 | 57.1 | +4.734 | +5.678 | 125
MULLION TOP PLATE | C350SD/5deg | PL/544 | 1.5 | +4.572 | +4.751 | 179.301
MULLION TOP PLATE | C350SD/5deg-5deg | PL/552 | 1.5 | +4.572 | +4.767 | 179.777
MULLION TOP PLATE | C350SD/5deg-5deg | PL/568 | 1.8 | +4.633 | +4.813 | 179.303
MULLION TOP PLATE | C350SD/5deg-5deg | PL/567 | 1.8 | +4.633 | +4.828 | 179.779
MULLION TOP PLATE | C350SD/5deg-5deg | PL/596 | 2.2 | +4.694 | +4.873 | 179.301
MULLION TOP PLATE | C350SD/5deg-5deg | PL/595 | 2.2 | +4.694 | +4.889 | 179.829
2 x MULLION | C350SD/5deg-5deg | Z/824 | 60.8 | +0.000 | +4.859 | 96
2 x MULLION | C350SD/5deg-5deg | Z/818 | 38.5 | +0.000 | +4.798 | 76
2 x MULLION | C350SD/5deg-5deg | Z/812 | 33.6 | +0.000 | +4.737 | 76
MULLION TOP PLATE | C350SD/5deg-5deg | PL/624 | 2.6 | +4.754 | +4.933 | 179.305
MULLION TOP PLATE | C350SD/5deg-5deg | PL/623 | 2.6 | +4.754 | +4.949 | 179.828
2 x MULLION | C350SD/5deg-5deg | Z/830 | 73.6 | +0.000 | +4.919 | 125
4 x RAFTER | C350SD/5deg-5deg | Z/806 | 57.1 | +4.734 | +5.416 | 125
MULLION TOP PLATE | C350SD/3deg | PL/546 | 1.5 | +4.565 | +4.744 | 179.745
MULLION TOP PLATE | C350SD/3deg-3deg | PL/550 | 1.5 | +4.565 | +4.754 | 180.033
MULLION TOP PLATE | C350SD/3deg-3deg | PL/564 | 1.8 | +4.602 | +4.781 | 179.741
MULLION TOP PLATE | C350SD/3deg-3deg | PL/563 | 1.8 | +4.602 | +4.790 | 180.029
MULLION TOP PLATE | C350SD/3deg-3deg | PL/592 | 2.2 | +4.638 | +4.817 | 179.743
MULLION TOP PLATE | C350SD/3deg-3deg | PL/591 | 2.2 | +4.638 | +4.827 | 180.062
2 x MULLION | C350SD/3deg-3deg | Z/823 | 60.1 | +0.000 | +4.803 | 96
2 x MULLION | C350SD/3deg-3deg | Z/817 | 38.2 | +0.000 | +4.767 | 76
2 x MULLION | C350SD/3deg-3deg | Z/811 | 33.5 | +0.000 | +4.730 | 76
MULLION TOP PLATE | C350SD/3deg-3deg | PL/620 | 2.6 | +4.674 | +4.853 | 179.739
MULLION TOP PLATE | C350SD/3deg-3deg | PL/619 | 2.6 | +4.674 | +4.863 | 180.053
2 x MULLION | C350SD/3deg-3deg | Z/829 | 72.4 | +0.000 | +4.839 | 125
4 x RAFTER | C350SD/3deg-3deg | Z/805 | 57.1 | +4.734 | +5.284 | 125
MULLION TOP PLATE | C350SD/25deg | PL/534 | 1.5 | +4.649 | +4.824 | 163.124
MULLION TOP PLATE | C350SD/25deg-25deg | PL/548 | 1.5 | +4.649 | +4.902 | 165.411
MULLION TOP PLATE | C350SD/25deg-25deg | PL/588 | 1.8 | +4.976 | +5.151 | 163.12
MULLION TOP PLATE | C350SD/25deg-25deg | PL/587 | 1.8 | +4.976 | +5.228 | 165.408
MULLION TOP PLATE | C350SD/25deg-25deg | PL/616 | 2.1 | +5.298 | +5.473 | 163.123
MULLION TOP PLATE | C350SD/25deg-25deg | PL/615 | 2.2 | +5.298 | +5.550 | 165.664
2 x MULLION | C350SD/25deg-25deg | Z/828 | 68.3 | +0.000 | +5.463 | 96
2 x MULLION | C350SD/25deg-25deg | Z/822 | 41.2 | +0.000 | +5.141 | 76
2 x MULLION | C350SD/25deg-25deg | Z/816 | 34.1 | +0.000 | +4.814 | 76
MULLION TOP PLATE | C350SD/25deg-25deg | PL/644 | 2.5 | +5.617 | +5.792 | 163.127
MULLION TOP PLATE | C350SD/25deg-25deg | PL/643 | 2.6 | +5.617 | +5.870 | 165.663
2 x MULLION | C350SD/25deg-25deg | Z/834 | 86.5 | +0.000 | +5.782 | 125
4 x RAFTER | C350SD/25deg-25deg | Z/810 | 57.1 | +4.734 | +6.666 | 125
MULLION TOP PLATE | C350SD/18deg | PL/536 | 1.5 | +4.621 | +4.797 | 171.175
MULLION TOP PLATE | C350SD/18deg-18deg | PL/560 | 1.5 | +4.621 | +4.853 | 172.848
MULLION TOP PLATE | C350SD/18deg-18deg | PL/584 | 1.8 | +4.848 | +5.025 | 171.179
MULLION TOP PLATE | C350SD/18deg-18deg | PL/583 | 1.8 | +4.848 | +5.081 | 172.852
MULLION TOP PLATE | C350SD/18deg-18deg | PL/612 | 2.2 | +5.072 | +5.249 | 171.184
MULLION TOP PLATE | C350SD/18deg-18deg | PL/611 | 2.2 | +5.072 | +5.305 | 173.043
2 x MULLION | C350SD/18deg-18deg | Z/827 | 65.5 | +0.000 | +5.237 | 96
2 x MULLION | C350SD/18deg-18deg | Z/821 | 40.2 | +0.000 | +5.013 | 76
2 x MULLION | C350SD/18deg-18deg | Z/815 | 33.9 | +0.000 | +4.786 | 76
MULLION TOP PLATE | C350SD/18deg-18deg | PL/640 | 2.5 | +5.295 | +5.472 | 171.177
MULLION TOP PLATE | C350SD/18deg-18deg | PL/639 | 2.6 | +5.295 | +5.528 | 173.031
2 x MULLION | C350SD/18deg-18deg | Z/833 | 81.6 | +0.000 | +5.460 | 125
4 x RAFTER | C350SD/18deg-18deg | Z/809 | 57.1 | +4.734 | +6.248 | 125
MULLION TOP PLATE | C350SD/15deg-15deg | PL/580 | 1.8 | +4.796 | +4.974 | 173.851
2 x MULLION | C350SD/15deg-15deg | Z/820 | 39.8 | +0.000 | +4.961 | 76
MULLION TOP PLATE | C350SD/15deg-15deg | PL/579 | 1.8 | +4.796 | +5.021 | 175.254
MULLION TOP PLATE | C350SD/15deg-15deg | PL/608 | 2.2 | +4.981 | +5.159 | 173.857
2 x MULLION | C350SD/15deg-15deg | Z/826 | 64.4 | +0.000 | +5.146 | 96
MULLION TOP PLATE | C350SD/15deg-15deg | PL/607 | 2.2 | +4.981 | +5.206 | 163.145
MULLION TOP PLATE | C350SD/15deg | PL/538 | 1.5 | +4.609 | +4.786 | 163.164
MULLION TOP PLATE | C350SD/15deg-15deg | PL/558 | 1.5 | +4.609 | +4.833 | 163.153
2 x MULLION | C350SD/15deg-15deg | Z/814 | 33.9 | +0.000 | +4.774 | 76
MULLION TOP PLATE | C350SD/15deg-15deg | PL/636 | 2.6 | +5.165 | +5.342 | 173.856
MULLION TOP PLATE | C350SD/15deg-15deg | PL/635 | 2.6 | +5.165 | +5.389 | 175.409
2 x MULLION | C350SD/15deg-15deg | Z/832 | 79.7 | +0.000 | +5.330 | 125
4 x RAFTER | C350SD/15deg-15deg | Z/808 | 57.1 | +4.734 | +6.061 | 125
MULLION TOP PLATE | C350SD/9deg | PL/541 | 1.5 | +4.587 | +4.765 | 177.768
MULLION TOP PLATE | C350SD/9deg-9deg | PL/553 | 1.5 | +4.587 | +4.793 | 178.618
MULLION TOP PLATE | C350SD/9deg-9deg | PL/569 | 1.8 | +4.697 | +4.876 | 177.768
MULLION TOP PLATE | C350SD/9deg-9deg | PL/570 | 1.8 | +4.697 | +4.904 | 178.618
MULLION TOP PLATE | C350SD/9deg-9deg | PL/597 | 2.2 | +4.807 | +4.985 | 177.773
MULLION TOP PLATE | C350SD/9deg-9deg | PL/598 | 2.2 | +4.807 | +5.013 | 178.717
MULLION TOP PLATE | C350SD/9deg-9deg | PL/625 | 2.6 | +4.915 | +5.094 | 177.776
MULLION TOP PLATE | C350SD/9deg-9deg | PL/626 | 2.6 | +4.915 | +5.122 | 178.715
MULLION TOP PLATE | C350SD/5deg | PL/543 | 1.5 | +4.572 | +4.751 | 179.301
MULLION TOP PLATE | C350SD/5deg-5deg | PL/551 | 1.5 | +4.572 | +4.767 | 179.777
MULLION TOP PLATE | C350SD/5deg-5deg | PL/565 | 1.8 | +4.633 | +4.813 | 179.303
MULLION TOP PLATE | C350SD/5deg-5deg | PL/566 | 1.8 | +4.633 | +4.828 | 179.779
MULLION TOP PLATE | C350SD/5deg-5deg | PL/593 | 2.2 | +4.694 | +4.873 | 179.301
MULLION TOP PLATE | C350SD/5deg-5deg | PL/594 | 2.2 | +4.694 | +4.889 | 179.829
MULLION TOP PLATE | C350SD/5deg-5deg | PL/621 | 2.6 | +4.754 | +4.933 | 179.305
MULLION TOP PLATE | C350SD/5deg-5deg | PL/622 | 2.6 | +4.754 | +4.949 | 179.828
MULLION TOP PLATE | C350SD/3deg | PL/545 | 1.5 | +4.565 | +4.744 | 179.745
MULLION TOP PLATE | C350SD/3deg-3deg | PL/549 | 1.5 | +4.565 | +4.754 | 180.033
MULLION TOP PLATE | C350SD/3deg-3deg | PL/561 | 1.8 | +4.602 | +4.781 | 179.741
MULLION TOP PLATE | C350SD/3deg-3deg | PL/562 | 1.8 | +4.602 | +4.790 | 180.029
MULLION TOP PLATE | C350SD/3deg-3deg | PL/589 | 2.2 | +4.638 | +4.817 | 179.743
MULLION TOP PLATE | C350SD/3deg-3deg | PL/590 | 2.2 | +4.638 | +4.827 | 180.062
MULLION TOP PLATE | C350SD/3deg-3deg | PL/617 | 2.6 | +4.674 | +4.853 | 179.739
MULLION TOP PLATE | C350SD/3deg-3deg | PL/618 | 2.6 | +4.674 | +4.863 | 180.053
MULLION TOP PLATE | C350SD/25deg | PL/533 | 1.5 | +4.649 | +4.824 | 163.124
MULLION TOP PLATE | C350SD/25deg-25deg | PL/547 | 1.5 | +4.649 | +4.902 | 165.411
MULLION TOP PLATE | C350SD/25deg-25deg | PL/585 | 1.8 | +4.976 | +5.151 | 163.12
MULLION TOP PLATE | C350SD/25deg-25deg | PL/586 | 1.8 | +4.976 | +5.228 | 165.408
MULLION TOP PLATE | C350SD/25deg-25deg | PL/613 | 2.1 | +5.298 | +5.473 | 163.123
MULLION TOP PLATE | C350SD/25deg-25deg | PL/614 | 2.2 | +5.298 | +5.550 | 165.664
MULLION TOP PLATE | C350SD/25deg-25deg | PL/641 | 2.5 | +5.617 | +5.792 | 163.127
MULLION TOP PLATE | C350SD/25deg-25deg | PL/642 | 2.6 | +5.617 | +5.870 | 165.663
MULLION TOP PLATE | C350SD/18deg | PL/535 | 1.5 | +4.621 | +4.797 | 171.175
MULLION TOP PLATE | C350SD/18deg-18deg | PL/559 | 1.5 | +4.621 | +4.853 | 172.848
MULLION TOP PLATE | C350SD/18deg-18deg | PL/581 | 1.8 | +4.848 | +5.025 | 171.179
MULLION TOP PLATE | C350SD/18deg-18deg | PL/582 | 1.8 | +4.848 | +5.081 | 172.852
MULLION TOP PLATE | C350SD/18deg-18deg | PL/609 | 2.2 | +5.072 | +5.249 | 171.184
MULLION TOP PLATE | C350SD/18deg-18deg | PL/610 | 2.2 | +5.072 | +5.305 | 173.043
MULLION TOP PLATE | C350SD/18deg-18deg | PL/637 | 2.5 | +5.295 | +5.472 | 171.177
MULLION TOP PLATE | C350SD/18deg-18deg | PL/638 | 2.6 | +5.295 | +5.528 | 173.031
MULLION TOP PLATE | C300SD/9deg-9deg | PL/487 | 2.2 | +4.851 | +5.057 | 178.719
MULLION TOP PLATE | C300SD/9deg-9deg | PL/431 | 1.5 | +4.630 | +4.837 | 178.62
MULLION TOP PLATE | C300SD/9deg-9deg | PL/459 | 1.8 | +4.741 | +4.948 | 178.619
MULLION TOP PLATE | C300SD/9deg-9deg | PL/515 | 2.6 | +4.959 | +5.166 | 178.712
MULLION TOP PLATE | C300SD/9deg-9deg | PL/516 | 2.6 | +4.959 | +5.138 | 177.773
MULLION TOP PLATE | C300SD/9deg | PL/432 | 1.5 | +4.630 | +4.809 | 177.775
MULLION TOP PLATE | C300SD/9deg-9deg | PL/460 | 1.8 | +4.741 | +4.920 | 177.774
2 x MULLION | C300SD/9deg-9deg | Z/801 | 76.6 | +0.000 | +5.124 | 125
2 x MULLION | C300SD/9deg-9deg | Z/789 | 39.4 | +0.000 | +4.906 | 76
2 x MULLION | C300SD/9deg-9deg | Z/783 | 34 | +0.000 | +4.795 | 76
MULLION TOP PLATE | C300SD/9deg-9deg | PL/488 | 2.2 | +4.851 | +5.029 | 177.78
2 x MULLION | C300SD/9deg-9deg | Z/795 | 62.7 | +0.000 | +5.016 | 96
4 x RAFTER | C300SD/9deg-9deg | Z/777 | 48.2 | +4.772 | +5.672 | 96
MULLION TOP PLATE | C300SD/5deg-5deg | PL/483 | 2.2 | +4.735 | +4.930 | 179.831
MULLION TOP PLATE | C300SD/5deg-5deg | PL/427 | 1.5 | +4.613 | +4.808 | 179.779
MULLION TOP PLATE | C300SD/5deg-5deg | PL/455 | 1.8 | +4.675 | +4.869 | 179.781
MULLION TOP PLATE | C300SD/5deg-5deg | PL/511 | 2.6 | +4.795 | +4.990 | 179.835
MULLION TOP PLATE | C300SD/5deg-5deg | PL/512 | 2.6 | +4.795 | +4.974 | 179.312
MULLION TOP PLATE | C300SD/5deg | PL/428 | 1.5 | +4.613 | +4.793 | 179.308
MULLION TOP PLATE | C300SD/5deg-5deg | PL/456 | 1.8 | +4.675 | +4.854 | 179.31
2 x MULLION | C300SD/5deg-5deg | Z/800 | 74.2 | +0.000 | +4.960 | 125
2 x MULLION | C300SD/5deg-5deg | Z/788 | 38.8 | +0.000 | +4.840 | 76
2 x MULLION | C300SD/5deg-5deg | Z/782 | 33.9 | +0.000 | +4.778 | 76
MULLION TOP PLATE | C300SD/5deg-5deg | PL/484 | 2.2 | +4.735 | +4.914 | 179.308
2 x MULLION | C300SD/5deg-5deg | Z/794 | 61.3 | +0.000 | +4.900 | 96
4 x RAFTER | C300SD/5deg-5deg | Z/776 | 48.2 | +4.772 | +5.407 | 96
MULLION TOP PLATE | C300SD/3deg-3deg | PL/479 | 2.2 | +4.678 | +4.867 | 167.928
MULLION TOP PLATE | C300SD/3deg-3deg | PL/423 | 1.5 | +4.605 | +4.794 | 180.023
MULLION TOP PLATE | C300SD/3deg-3deg | PL/451 | 1.8 | +4.642 | +4.831 | 180.029
MULLION TOP PLATE | C300SD/3deg-3deg | PL/507 | 2.6 | +4.714 | +4.903 | 167.922
MULLION TOP PLATE | C300SD/3deg-3deg | PL/508 | 2.6 | +4.714 | +4.893 | 167.941
MULLION TOP PLATE | C300SD/3deg | PL/424 | 1.5 | +4.605 | +4.785 | 179.74
MULLION TOP PLATE | C300SD/3deg-3deg | PL/452 | 1.8 | +4.642 | +4.821 | 179.746
2 x MULLION | C300SD/3deg-3deg | Z/799 | 73 | +0.000 | +4.879 | 125
2 x MULLION | C300SD/3deg-3deg | Z/787 | 38.6 | +0.000 | +4.807 | 76
2 x MULLION | C300SD/3deg-3deg | Z/781 | 33.9 | +0.000 | +4.770 | 76
MULLION TOP PLATE | C300SD/3deg-3deg | PL/480 | 2.2 | +4.678 | +4.857 | 167.934
2 x MULLION | C300SD/3deg-3deg | Z/793 | 60.6 | +0.000 | +4.843 | 96
4 x RAFTER | C300SD/3deg-3deg | Z/775 | 48.2 | +4.772 | +5.274 | 96
MULLION TOP PLATE | C300SD/25deg-25deg | PL/503 | 2.2 | +5.352 | +5.605 | 165.665
MULLION TOP PLATE | C300SD/25deg-25deg | PL/447 | 1.5 | +4.704 | +4.956 | 165.413
MULLION TOP PLATE | C300SD/25deg-25deg | PL/475 | 1.8 | +5.031 | +5.283 | 165.409
MULLION TOP PLATE | C300SD/25deg-25deg | PL/531 | 2.6 | +5.672 | +5.925 | 165.66
MULLION TOP PLATE | C300SD/25deg-25deg | PL/532 | 2.5 | +5.672 | +5.848 | 163.124
MULLION TOP PLATE | C300SD/25deg | PL/448 | 1.5 | +4.704 | +4.880 | 163.131
MULLION TOP PLATE | C300SD/25deg-25deg | PL/476 | 1.8 | +5.031 | +5.206 | 163.127
2 x MULLION | C300SD/25deg-25deg | Z/804 | 87.3 | +0.000 | +5.837 | 125
2 x MULLION | C300SD/25deg-25deg | Z/792 | 41.7 | +0.000 | +5.196 | 76
2 x MULLION | C300SD/25deg-25deg | Z/786 | 34.5 | +0.000 | +4.869 | 76
MULLION TOP PLATE | C300SD/25deg-25deg | PL/504 | 2.1 | +5.352 | +5.528 | 163.13
2 x MULLION | C300SD/25deg-25deg | Z/798 | 69 | +0.000 | +5.517 | 96
4 x RAFTER | C300SD/25deg-25deg | Z/780 | 48.2 | +4.772 | +6.674 | 96
MULLION TOP PLATE | C300SD/18deg-18deg | PL/499 | 2.2 | +5.122 | +5.355 | 173.04
MULLION TOP PLATE | C300SD/18deg-18deg | PL/443 | 1.5 | +4.670 | +4.903 | 172.855
MULLION TOP PLATE | C300SD/18deg-18deg | PL/471 | 1.8 | +4.898 | +5.130 | 172.849
MULLION TOP PLATE | C300SD/18deg-18deg | PL/527 | 2.6 | +5.345 | +5.578 | 173.033
MULLION TOP PLATE | C300SD/18deg-18deg | PL/528 | 2.5 | +5.345 | +5.521 | 171.179
MULLION TOP PLATE | C300SD/18deg | PL/444 | 1.5 | +4.670 | +4.847 | 171.186
MULLION TOP PLATE | C300SD/18deg-18deg | PL/472 | 1.8 | +4.898 | +5.075 | 171.181
2 x MULLION | C300SD/18deg-18deg | Z/803 | 82.4 | +0.000 | +5.510 | 125
2 x MULLION | C300SD/18deg-18deg | Z/791 | 40.6 | +0.000 | +5.063 | 76
2 x MULLION | C300SD/18deg-18deg | Z/785 | 34.3 | +0.000 | +4.835 | 76
MULLION TOP PLATE | C300SD/18deg-18deg | PL/500 | 2.2 | +5.122 | +5.299 | 171.186
2 x MULLION | C300SD/18deg-18deg | Z/797 | 66.1 | +0.000 | +5.287 | 96
4 x RAFTER | C300SD/18deg-18deg | Z/779 | 48.2 | +4.772 | +6.250 | 96
MULLION TOP PLATE | C300SD/15deg-15deg | PL/495 | 2.2 | +5.029 | +5.253 | 175.415
2 x MULLION | C300SD/15deg-15deg | Z/796 | 65 | +0.000 | +5.194 | 96
MULLION TOP PLATE | C300SD/15deg-15deg | PL/439 | 1.5 | +4.657 | +4.881 | 175.259
MULLION TOP PLATE | C300SD/15deg-15deg | PL/467 | 1.8 | +4.844 | +5.068 | 175.254
MULLION TOP PLATE | C300SD/15deg-15deg | PL/523 | 2.6 | +5.213 | +5.437 | 175.414
MULLION TOP PLATE | C300SD/15deg-15deg | PL/524 | 2.6 | +5.213 | +5.390 | 173.861
MULLION TOP PLATE | C300SD/15deg | PL/440 | 1.5 | +4.657 | +4.834 | 173.861
MULLION TOP PLATE | C300SD/15deg-15deg | PL/468 | 1.8 | +4.844 | +5.022 | 173.857
2 x MULLION | C300SD/15deg-15deg | Z/802 | 80.4 | +0.000 | +5.378 | 125
2 x MULLION | C300SD/15deg-15deg | Z/790 | 40.2 | +0.000 | +5.009 | 76
2 x MULLION | C300SD/15deg-15deg | Z/784 | 34.2 | +0.000 | +4.822 | 76
MULLION TOP PLATE | C300SD/15deg-15deg | PL/496 | 2.2 | +5.029 | +5.207 | 173.862
4 x RAFTER | C300SD/15deg-15deg | Z/778 | 48.2 | +4.772 | +6.060 | 96
MULLION TOP PLATE | C300SD/9deg-9deg | PL/486 | 2.2 | +4.851 | +5.057 | 178.719
MULLION TOP PLATE | C300SD/9deg-9deg | PL/430 | 1.5 | +4.630 | +4.837 | 178.62
MULLION TOP PLATE | C300SD/9deg-9deg | PL/458 | 1.8 | +4.741 | +4.948 | 178.619
MULLION TOP PLATE | C300SD/9deg-9deg | PL/514 | 2.6 | +4.959 | +5.166 | 178.712
MULLION TOP PLATE | C300SD/9deg-9deg | PL/513 | 2.6 | +4.959 | +5.138 | 177.773
MULLION TOP PLATE | C300SD/9deg | PL/429 | 1.5 | +4.630 | +4.809 | 177.775
MULLION TOP PLATE | C300SD/9deg-9deg | PL/457 | 1.8 | +4.741 | +4.920 | 177.774
MULLION TOP PLATE | C300SD/9deg-9deg | PL/485 | 2.2 | +4.851 | +5.029 | 177.78
MULLION TOP PLATE | C300SD/5deg-5deg | PL/482 | 2.2 | +4.735 | +4.930 | 179.831
MULLION TOP PLATE | C300SD/5deg-5deg | PL/426 | 1.5 | +4.613 | +4.808 | 179.779
MULLION TOP PLATE | C300SD/5deg-5deg | PL/454 | 1.8 | +4.675 | +4.869 | 179.781
MULLION TOP PLATE | C300SD/5deg-5deg | PL/510 | 2.6 | +4.795 | +4.990 | 179.835
MULLION TOP PLATE | C300SD/5deg-5deg | PL/509 | 2.6 | +4.795 | +4.974 | 179.312
MULLION TOP PLATE | C300SD/5deg | PL/425 | 1.5 | +4.613 | +4.793 | 179.308
MULLION TOP PLATE | C300SD/5deg-5deg | PL/453 | 1.8 | +4.675 | +4.854 | 179.31
MULLION TOP PLATE | C300SD/5deg-5deg | PL/481 | 2.2 | +4.735 | +4.914 | 179.308
MULLION TOP PLATE | C300SD/3deg-3deg | PL/478 | 2.2 | +4.678 | +4.867 | 167.928
MULLION TOP PLATE | C300SD/3deg-3deg | PL/422 | 1.5 | +4.605 | +4.794 | 180.023
MULLION TOP PLATE | C300SD/3deg-3deg | PL/450 | 1.8 | +4.642 | +4.831 | 180.029
MULLION TOP PLATE | C300SD/3deg-3deg | PL/506 | 2.6 | +4.714 | +4.903 | 167.922
MULLION TOP PLATE | C300SD/3deg-3deg | PL/505 | 2.6 | +4.714 | +4.893 | 167.941
MULLION TOP PLATE | C300SD/3deg | PL/421 | 1.5 | +4.605 | +4.785 | 179.74
MULLION TOP PLATE | C300SD/3deg-3deg | PL/449 | 1.8 | +4.642 | +4.821 | 179.746
MULLION TOP PLATE | C300SD/3deg-3deg | PL/477 | 2.2 | +4.678 | +4.857 | 167.934
MULLION TOP PLATE | C300SD/25deg-25deg | PL/502 | 2.2 | +5.352 | +5.605 | 165.665
MULLION TOP PLATE | C300SD/25deg-25deg | PL/446 | 1.5 | +4.704 | +4.956 | 165.413
MULLION TOP PLATE | C300SD/25deg-25deg | PL/474 | 1.8 | +5.031 | +5.283 | 165.409
MULLION TOP PLATE | C300SD/25deg-25deg | PL/530 | 2.6 | +5.672 | +5.925 | 165.66
MULLION TOP PLATE | C300SD/25deg-25deg | PL/529 | 2.5 | +5.672 | +5.848 | 163.124
MULLION TOP PLATE | C300SD/25deg | PL/445 | 1.5 | +4.704 | +4.880 | 163.131
MULLION TOP PLATE | C300SD/25deg-25deg | PL/473 | 1.8 | +5.031 | +5.206 | 163.127
MULLION TOP PLATE | C300SD/25deg-25deg | PL/501 | 2.1 | +5.352 | +5.528 | 163.13
MULLION TOP PLATE | C300SD/18deg-18deg | PL/498 | 2.2 | +5.122 | +5.355 | 173.04
MULLION TOP PLATE | C300SD/18deg-18deg | PL/442 | 1.5 | +4.670 | +4.903 | 172.855
MULLION TOP PLATE | C300SD/18deg-18deg | PL/470 | 1.8 | +4.898 | +5.130 | 172.849
MULLION TOP PLATE | C300SD/18deg-18deg | PL/526 | 2.6 | +5.345 | +5.578 | 173.033
MULLION TOP PLATE | C300SD/18deg-18deg | PL/525 | 2.5 | +5.345 | +5.521 | 171.179
MULLION TOP PLATE | C300SD/18deg | PL/441 | 1.5 | +4.670 | +4.847 | 171.186
MULLION TOP PLATE | C300SD/18deg-18deg | PL/469 | 1.8 | +4.898 | +5.075 | 171.181
MULLION TOP PLATE | C300SD/18deg-18deg | PL/497 | 2.2 | +5.122 | +5.299 | 171.186
MULLION TOP PLATE | C250SD/9deg-9deg | PL/403 | 2.6 | +4.999 | +5.206 | 178.721
MULLION TOP PLATE | C250SD/9deg-9deg | PL/404 | 2.6 | +4.999 | +5.178 | 177.782
MULLION TOP PLATE | C250SD/9deg-9deg | PL/375 | 2.2 | +4.891 | +5.097 | 178.718
MULLION TOP PLATE | C250SD/9deg-9deg | PL/376 | 2.2 | +4.891 | +5.069 | 177.779
MULLION TOP PLATE | C250SD/9deg-9deg | PL/319 | 1.5 | +4.670 | +4.877 | 178.629
MULLION TOP PLATE | C250SD/9deg-9deg | PL/347 | 1.8 | +4.781 | +4.988 | 178.628
MULLION TOP PLATE | C250SD/9deg-9deg | PL/348 | 1.8 | +4.781 | +4.960 | 177.783
MULLION TOP PLATE | C250SD/9deg | PL/320 | 1.5 | +4.670 | +4.849 | 177.784
2 x MULLION | C250SD/9deg-9deg | Z/771 | 77.2 | +0.000 | +5.164 | 125
2 x MULLION | C250SD/9deg-9deg | Z/765 | 63.2 | +0.000 | +5.056 | 96
2 x MULLION | C250SD/9deg-9deg | Z/753 | 34.3 | +0.000 | +4.835 | 76
2 x MULLION | C250SD/9deg-9deg | Z/759 | 39.7 | +0.000 | +4.946 | 76
4 x RAFTER | C250SD/9deg-9deg | Z/747 | 31.2 | +4.807 | +5.667 | 76
MULLION TOP PLATE | C250SD/5deg-5deg | PL/399 | 2.6 | +4.833 | +5.028 | 179.836
MULLION TOP PLATE | C250SD/5deg-5deg | PL/400 | 2.6 | +4.833 | +5.012 | 179.313
MULLION TOP PLATE | C250SD/5deg-5deg | PL/371 | 2.2 | +4.773 | +4.968 | 179.832
MULLION TOP PLATE | C250SD/5deg-5deg | PL/372 | 2.2 | +4.773 | +4.952 | 179.309
MULLION TOP PLATE | C250SD/5deg-5deg | PL/315 | 1.5 | +4.651 | +4.846 | 179.779
MULLION TOP PLATE | C250SD/5deg-5deg | PL/343 | 1.8 | +4.712 | +4.907 | 179.782
MULLION TOP PLATE | C250SD/5deg-5deg | PL/344 | 1.8 | +4.712 | +4.892 | 179.311
MULLION TOP PLATE | C250SD/5deg | PL/316 | 1.5 | +4.651 | +4.830 | 179.308
2 x MULLION | C250SD/5deg-5deg | Z/770 | 74.7 | +0.000 | +4.998 | 125
2 x MULLION | C250SD/5deg-5deg | Z/764 | 61.7 | +0.000 | +4.938 | 96
2 x MULLION | C250SD/5deg-5deg | Z/752 | 34.1 | +0.000 | +4.816 | 76
2 x MULLION | C250SD/5deg-5deg | Z/758 | 39.1 | +0.000 | +4.877 | 76
4 x RAFTER | C250SD/5deg-5deg | Z/746 | 31.2 | +4.807 | +5.399 | 76
MULLION TOP PLATE | C250SD/3deg-3deg | PL/395 | 2.6 | +4.750 | +4.939 | 180.066
MULLION TOP PLATE | C250SD/3deg-3deg | PL/396 | 2.6 | +4.750 | +4.930 | 179.752
MULLION TOP PLATE | C250SD/3deg-3deg | PL/367 | 2.2 | +4.714 | +4.903 | 180.06
MULLION TOP PLATE | C250SD/3deg-3deg | PL/368 | 2.2 | +4.714 | +4.894 | 179.746
MULLION TOP PLATE | C250SD/3deg-3deg | PL/311 | 1.5 | +4.642 | +4.830 | 180.031
MULLION TOP PLATE | C250SD/3deg-3deg | PL/339 | 1.8 | +4.678 | +4.867 | 180.037
MULLION TOP PLATE | C250SD/3deg-3deg | PL/340 | 1.8 | +4.678 | +4.858 | 179.754
MULLION TOP PLATE | C250SD/3deg | PL/312 | 1.5 | +4.642 | +4.821 | 179.748
2 x MULLION | C250SD/3deg-3deg | Z/769 | 73.5 | +0.000 | +4.915 | 125
2 x MULLION | C250SD/3deg-3deg | Z/763 | 61 | +0.000 | +4.879 | 96
2 x MULLION | C250SD/3deg-3deg | Z/751 | 34.1 | +0.000 | +4.807 | 76
2 x MULLION | C250SD/3deg-3deg | Z/757 | 39 | +0.000 | +4.843 | 76
4 x RAFTER | C250SD/3deg-3deg | Z/745 | 31.2 | +4.807 | +5.265 | 76
MULLION TOP PLATE | C250SD/25deg-25deg | PL/419 | 2.6 | +5.722 | +5.975 | 165.666
MULLION TOP PLATE | C250SD/25deg-25deg | PL/420 | 2.5 | +5.722 | +5.897 | 163.13
MULLION TOP PLATE | C250SD/25deg-25deg | PL/391 | 2.2 | +5.402 | +5.655 | 165.671
MULLION TOP PLATE | C250SD/25deg-25deg | PL/392 | 2.1 | +5.402 | +5.577 | 163.135
MULLION TOP PLATE | C250SD/25deg-25deg | PL/335 | 1.5 | +4.754 | +5.006 | 165.418
MULLION TOP PLATE | C250SD/25deg-25deg | PL/363 | 1.8 | +5.081 | +5.333 | 165.415
MULLION TOP PLATE | C250SD/25deg-25deg | PL/364 | 1.8 | +5.081 | +5.256 | 163.133
MULLION TOP PLATE | C250SD/25deg | PL/336 | 1.3 | +4.754 | +4.929 | 163.136
2 x MULLION | C250SD/25deg-25deg | Z/774 | 88 | +0.000 | +5.887 | 125
2 x MULLION | C250SD/25deg-25deg | Z/768 | 69.6 | +0.000 | +5.567 | 96
2 x MULLION | C250SD/25deg-25deg | Z/756 | 34.9 | +0.000 | +4.919 | 76
2 x MULLION | C250SD/25deg-25deg | Z/762 | 42.1 | +0.000 | +5.246 | 76
4 x RAFTER | C250SD/25deg-25deg | Z/750 | 31.2 | +4.807 | +6.682 | 76
MULLION TOP PLATE | C250SD/18deg-18deg | PL/415 | 2.6 | +5.390 | +5.623 | 173.044
MULLION TOP PLATE | C250SD/18deg-18deg | PL/416 | 2.5 | +5.390 | +5.567 | 171.19
MULLION TOP PLATE | C250SD/18deg-18deg | PL/387 | 2.2 | +5.167 | +5.400 | 173.041
MULLION TOP PLATE | C250SD/18deg-18deg | PL/388 | 2.2 | +5.167 | +5.344 | 171.187
MULLION TOP PLATE | C250SD/18deg-18deg | PL/331 | 1.5 | +4.716 | +4.948 | 172.857
MULLION TOP PLATE | C250SD/18deg-18deg | PL/359 | 1.8 | +4.943 | +5.176 | 172.861
MULLION TOP PLATE | C250SD/18deg-18deg | PL/360 | 1.8 | +4.943 | +5.120 | 171.192
MULLION TOP PLATE | C250SD/18deg | PL/332 | 1.5 | +4.716 | +4.893 | 171.188
2 x MULLION | C250SD/18deg-18deg | Z/773 | 83.1 | +0.000 | +5.555 | 125
2 x MULLION | C250SD/18deg-18deg | Z/767 | 66.7 | +0.000 | +5.332 | 96
2 x MULLION | C250SD/18deg-18deg | Z/755 | 34.6 | +0.000 | +4.881 | 76
2 x MULLION | C250SD/18deg-18deg | Z/761 | 41 | +0.000 | +5.108 | 76
4 x RAFTER | C250SD/18deg-18deg | Z/749 | 31.2 | +4.807 | +6.251 | 76
MULLION TOP PLATE | C250SD/15deg-15deg | PL/411 | 2.6 | +5.257 | +5.481 | 174.474
MULLION TOP PLATE | C250SD/15deg-15deg | PL/412 | 2.5 | +5.257 | +5.434 | 172.921
MULLION TOP PLATE | C250SD/15deg-15deg | PL/383 | 2.2 | +5.074 | +5.297 | 174.475
MULLION TOP PLATE | C250SD/15deg-15deg | PL/384 | 2.1 | +5.074 | +5.250 | 172.922
MULLION TOP PLATE | C250SD/15deg-15deg | PL/327 | 1.5 | +4.701 | +4.924 | 174.319
MULLION TOP PLATE | C250SD/15deg-15deg | PL/355 | 1.8 | +4.889 | +5.112 | 174.324
MULLION TOP PLATE | C250SD/15deg-15deg | PL/356 | 1.8 | +4.889 | +5.065 | 172.926
MULLION TOP PLATE | C250SD/15deg | PL/328 | 1.5 | +4.701 | +4.878 | 172.921
2 x MULLION | C250SD/15deg-15deg | Z/772 | 81.1 | +0.000 | +5.422 | 125
2 x MULLION | C250SD/15deg-15deg | Z/766 | 65.5 | +0.000 | +5.239 | 96
2 x MULLION | C250SD/15deg-15deg | Z/754 | 34.5 | +0.000 | +4.866 | 76
2 x MULLION | C250SD/15deg-15deg | Z/760 | 40.5 | +0.000 | +5.054 | 76
4 x RAFTER | C250SD/15deg-15deg | Z/748 | 31.2 | +4.807 | +6.059 | 76
MULLION TOP PLATE | C250SD/9deg-9deg | PL/402 | 2.6 | +4.999 | +5.206 | 178.721
MULLION TOP PLATE | C250SD/9deg-9deg | PL/401 | 2.6 | +4.999 | +5.178 | 177.782
MULLION TOP PLATE | C250SD/9deg-9deg | PL/374 | 2.2 | +4.891 | +5.097 | 178.718
MULLION TOP PLATE | C250SD/9deg-9deg | PL/373 | 2.2 | +4.891 | +5.069 | 177.779
MULLION TOP PLATE | C250SD/9deg-9deg | PL/318 | 1.5 | +4.670 | +4.877 | 178.629
MULLION TOP PLATE | C250SD/9deg-9deg | PL/346 | 1.8 | +4.781 | +4.988 | 178.628
MULLION TOP PLATE | C250SD/9deg-9deg | PL/345 | 1.8 | +4.781 | +4.960 | 177.783
MULLION TOP PLATE | C250SD/9deg | PL/317 | 1.5 | +4.670 | +4.849 | 177.784
MULLION TOP PLATE | C250SD/5deg-5deg | PL/398 | 2.6 | +4.833 | +5.028 | 179.836
MULLION TOP PLATE | C250SD/5deg-5deg | PL/397 | 2.6 | +4.833 | +5.012 | 179.313
MULLION TOP PLATE | C250SD/5deg-5deg | PL/370 | 2.2 | +4.773 | +4.968 | 179.832
MULLION TOP PLATE | C250SD/5deg-5deg | PL/369 | 2.2 | +4.773 | +4.952 | 179.309
MULLION TOP PLATE | C250SD/5deg-5deg | PL/314 | 1.5 | +4.651 | +4.846 | 179.779
MULLION TOP PLATE | C250SD/5deg-5deg | PL/342 | 1.8 | +4.712 | +4.907 | 179.782
MULLION TOP PLATE | C250SD/5deg-5deg | PL/341 | 1.8 | +4.712 | +4.892 | 179.311
MULLION TOP PLATE | C250SD/5deg | PL/313 | 1.5 | +4.651 | +4.830 | 179.308
MULLION TOP PLATE | C250SD/3deg-3deg | PL/394 | 2.6 | +4.750 | +4.939 | 180.066
MULLION TOP PLATE | C250SD/3deg-3deg | PL/393 | 2.6 | +4.750 | +4.930 | 179.752
MULLION TOP PLATE | C250SD/3deg-3deg | PL/366 | 2.2 | +4.714 | +4.903 | 180.06
MULLION TOP PLATE | C250SD/3deg-3deg | PL/365 | 2.2 | +4.714 | +4.894 | 179.746
MULLION TOP PLATE | C250SD/3deg-3deg | PL/310 | 1.5 | +4.642 | +4.830 | 180.031
MULLION TOP PLATE | C250SD/3deg-3deg | PL/338 | 1.8 | +4.678 | +4.867 | 180.037
MULLION TOP PLATE | C250SD/3deg-3deg | PL/337 | 1.8 | +4.678 | +4.858 | 179.754
MULLION TOP PLATE | C250SD/3deg | PL/309 | 1.5 | +4.642 | +4.821 | 179.748
MULLION TOP PLATE | C250SD/25deg-25deg | PL/418 | 2.6 | +5.722 | +5.975 | 165.666
MULLION TOP PLATE | C250SD/25deg-25deg | PL/417 | 2.5 | +5.722 | +5.897 | 163.13
MULLION TOP PLATE | C250SD/25deg-25deg | PL/390 | 2.2 | +5.402 | +5.655 | 165.671
MULLION TOP PLATE | C250SD/25deg-25deg | PL/389 | 2.1 | +5.402 | +5.577 | 163.135
MULLION TOP PLATE | C250SD/25deg-25deg | PL/334 | 1.5 | +4.754 | +5.006 | 165.418
MULLION TOP PLATE | C250SD/25deg-25deg | PL/362 | 1.8 | +5.081 | +5.333 | 165.415
MULLION TOP PLATE | C250SD/25deg-25deg | PL/361 | 1.8 | +5.081 | +5.256 | 163.133
MULLION TOP PLATE | C250SD/25deg | PL/333 | 1.3 | +4.754 | +4.929 | 163.136
MULLION TOP PLATE | C250SD/18deg-18deg | PL/414 | 2.6 | +5.390 | +5.623 | 173.044
MULLION TOP PLATE | C250SD/18deg-18deg | PL/413 | 2.5 | +5.390 | +5.567 | 171.19
MULLION TOP PLATE | C250SD/18deg-18deg | PL/386 | 2.2 | +5.167 | +5.400 | 173.041
MULLION TOP PLATE | C250SD/18deg-18deg | PL/385 | 2.2 | +5.167 | +5.344 | 171.187
MULLION TOP PLATE | C250SD/18deg-18deg | PL/330 | 1.5 | +4.716 | +4.948 | 172.857
MULLION TOP PLATE | C250SD/18deg-18deg | PL/358 | 1.8 | +4.943 | +5.176 | 172.861
MULLION TOP PLATE | C250SD/18deg-18deg | PL/357 | 1.8 | +4.943 | +5.120 | 171.192
MULLION TOP PLATE | C250SD/18deg | PL/329 | 1.5 | +4.716 | +4.893 | 171.188
2 x MULLION | C200SD/9deg-9deg | Z/710 | 34.6 | +0.000 | +4.881 | 76
MULLION TOP PLATE | C200SD/9deg-9deg | PL/403 | 2.6 | +5.044 | +5.251 | 178.72
MULLION TOP PLATE | C200SD/9deg-9deg | PL/404 | 2.6 | +5.044 | +5.223 | 177.781
MULLION TOP PLATE | C200SD/9deg-9deg | PL/375 | 2.2 | +4.936 | +5.143 | 178.716
MULLION TOP PLATE | C200SD/9deg-9deg | PL/376 | 2.2 | +4.936 | +5.115 | 177.778
MULLION TOP PLATE | C200SD/9deg-9deg | PL/348 | 1.8 | +4.827 | +5.005 | 177.781
MULLION TOP PLATE | C200SD/9deg-9deg | PL/347 | 1.8 | +4.827 | +5.033 | 178.626
MULLION TOP PLATE | C200SD/9deg | PL/320 | 1.5 | +4.716 | +4.894 | 177.781
MULLION TOP PLATE | C200SD/9deg-9deg | PL/319 | 1.5 | +4.716 | +4.922 | 178.626
2 x MULLION | C200SD/9deg-9deg | Z/741 | 77.9 | +0.000 | +5.209 | 125
2 x MULLION | C200SD/9deg-9deg | Z/735 | 63.8 | +0.000 | +5.101 | 96
2 x MULLION | C200SD/9deg-9deg | Z/729 | 40 | +0.000 | +4.992 | 76
2 x RAFTER | C200SD/9deg-9deg | Z/701 | 27.8 | +4.845 | +5.660 | 76
2 x RAFTER | C200SD/9deg-9deg | Z/726 | 27.8 | +4.845 | +5.660 | 76
