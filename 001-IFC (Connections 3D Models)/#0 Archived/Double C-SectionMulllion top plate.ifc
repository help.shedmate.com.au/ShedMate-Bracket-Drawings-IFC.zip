Properties of the parts of a building model (IFC2X3), part 2 of 3

# IfcElementAssembly (784)
Name | ASSEMBLY_POSITION_CODE = Assembly/Cast unit position code | ASSEMBLY_POS = Assembly/Cast unit Mark | Assembly/Cast unit weight (kg) | Assembly/Cast unit bottom elevation | Assembly/Cast unit top elevation | Width (mm)
2 x MULLION | C200SD/5deg-5deg | Z/708 | 34.3 | +0.000 | +4.858 | 76
MULLION TOP PLATE | C200SD/5deg-5deg | PL/399 | 2.6 | +4.874 | +5.069 | 179.828
MULLION TOP PLATE | C200SD/5deg-5deg | PL/400 | 2.6 | +4.874 | +5.054 | 179.305
MULLION TOP PLATE | C200SD/5deg-5deg | PL/371 | 2.2 | +4.814 | +5.009 | 179.834
MULLION TOP PLATE | C200SD/5deg-5deg | PL/372 | 2.2 | +4.814 | +4.994 | 179.311
MULLION TOP PLATE | C200SD/5deg-5deg | PL/344 | 1.8 | +4.754 | +4.933 | 179.312
MULLION TOP PLATE | C200SD/5deg-5deg | PL/343 | 1.8 | +4.754 | +4.949 | 179.783
MULLION TOP PLATE | C200SD/5deg | PL/316 | 1.5 | +4.693 | +4.872 | 179.309
MULLION TOP PLATE | C200SD/5deg-5deg | PL/315 | 1.5 | +4.693 | +4.888 | 179.78
2 x MULLION | C200SD/5deg-5deg | Z/740 | 75.4 | +0.000 | +5.039 | 125
2 x MULLION | C200SD/5deg-5deg | Z/734 | 62.3 | +0.000 | +4.979 | 96
2 x MULLION | C200SD/5deg-5deg | Z/728 | 39.4 | +0.000 | +4.919 | 76
4 x RAFTER | C200SD/5deg-5deg | Z/699 | 27.8 | +4.845 | +5.389 | 76
MULLION TOP PLATE | C200SD/3deg-3deg | PL/395 | 2.6 | +4.790 | +4.979 | 180.065
MULLION TOP PLATE | C200SD/3deg-3deg | PL/396 | 2.6 | +4.790 | +4.970 | 179.751
MULLION TOP PLATE | C200SD/3deg-3deg | PL/367 | 2.2 | +4.754 | +4.943 | 180.058
MULLION TOP PLATE | C200SD/3deg-3deg | PL/368 | 2.2 | +4.754 | +4.934 | 179.744
MULLION TOP PLATE | C200SD/3deg-3deg | PL/340 | 1.8 | +4.718 | +4.898 | 179.752
MULLION TOP PLATE | C200SD/3deg-3deg | PL/339 | 1.8 | +4.718 | +4.907 | 180.034
2 x MULLION | C200SD/3deg-3deg | Z/739 | 74.2 | +0.000 | +4.955 | 125
2 x MULLION | C200SD/3deg-3deg | Z/733 | 61.5 | +0.000 | +4.919 | 96
2 x MULLION | C200SD/3deg-3deg | Z/727 | 39.2 | +0.000 | +4.883 | 76
MULLION TOP PLATE | C200SD/3deg | PL/312 | 1.5 | +4.681 | +4.861 | 179.745
MULLION TOP PLATE | C200SD/3deg-3deg | PL/311 | 1.5 | +4.681 | +4.870 | 180.028
2 x MULLION | C200SD/3deg-3deg | Z/706 | 34.3 | +0.000 | +4.846 | 76
4 x RAFTER | C200SD/3deg-3deg | Z/697 | 27.8 | +4.844 | +5.252 | 76
MULLION TOP PLATE | C200SD/25deg-25deg | PL/419 | 2.6 | +5.778 | +6.031 | 165.664
MULLION TOP PLATE | C200SD/25deg-25deg | PL/420 | 2.5 | +5.778 | +5.953 | 163.128
MULLION TOP PLATE | C200SD/25deg-25deg | PL/391 | 2.2 | +5.458 | +5.711 | 165.668
MULLION TOP PLATE | C200SD/25deg-25deg | PL/392 | 2.1 | +5.458 | +5.633 | 163.132
MULLION TOP PLATE | C200SD/25deg-25deg | PL/364 | 1.8 | +5.137 | +5.312 | 163.129
MULLION TOP PLATE | C200SD/25deg-25deg | PL/363 | 1.8 | +5.137 | +5.389 | 165.411
2 x MULLION | C200SD/25deg-25deg | Z/744 | 88.9 | +0.000 | +5.943 | 125
2 x MULLION | C200SD/25deg-25deg | Z/738 | 70.3 | +0.000 | +5.623 | 96
2 x MULLION | C200SD/25deg-25deg | Z/732 | 42.5 | +0.000 | +5.302 | 76
MULLION TOP PLATE | C200SD/25deg | PL/336 | 1.3 | +4.810 | +4.985 | 163.132
MULLION TOP PLATE | C200SD/25deg-25deg | PL/335 | 1.5 | +4.810 | +5.062 | 165.414
2 x MULLION | C200SD/25deg-25deg | Z/725 | 35.3 | +0.000 | +4.975 | 76
4 x RAFTER | C200SD/25deg-25deg | Z/701 | 27.8 | +4.846 | +6.690 | 76
MULLION TOP PLATE | C200SD/18deg-18deg | PL/415 | 2.6 | +5.441 | +5.674 | 173.037
MULLION TOP PLATE | C200SD/18deg-18deg | PL/416 | 2.5 | +5.441 | +5.618 | 171.183
MULLION TOP PLATE | C200SD/18deg-18deg | PL/387 | 2.2 | +5.218 | +5.451 | 173.043
MULLION TOP PLATE | C200SD/18deg-18deg | PL/388 | 2.2 | +5.218 | +5.395 | 171.189
MULLION TOP PLATE | C200SD/18deg-18deg | PL/360 | 1.8 | +4.994 | +5.171 | 171.184
MULLION TOP PLATE | C200SD/18deg-18deg | PL/359 | 1.8 | +4.994 | +5.227 | 172.852
2 x MULLION | C200SD/18deg-18deg | Z/743 | 83.8 | +0.000 | +5.606 | 125
2 x MULLION | C200SD/18deg-18deg | Z/737 | 67.3 | +0.000 | +5.383 | 96
2 x MULLION | C200SD/18deg-18deg | Z/731 | 41.4 | +0.000 | +5.159 | 76
MULLION TOP PLATE | C200SD/18deg | PL/332 | 1.5 | +4.767 | +4.943 | 171.188
MULLION TOP PLATE | C200SD/18deg-18deg | PL/331 | 1.5 | +4.767 | +4.999 | 172.857
2 x MULLION | C200SD/18deg-18deg | Z/724 | 35 | +0.000 | +4.932 | 76
4 x RAFTER | C200SD/18deg-18deg | Z/703 | 27.8 | +4.846 | +6.253 | 76
MULLION TOP PLATE | C200SD/15deg-15deg | PL/411 | 2.6 | +5.305 | +5.529 | 175.416
2 x MULLION | C200SD/15deg-15deg | Z/742 | 81.8 | +0.000 | +5.470 | 125
MULLION TOP PLATE | C200SD/15deg-15deg | PL/412 | 2.6 | +5.305 | +5.483 | 173.863
MULLION TOP PLATE | C200SD/15deg-15deg | PL/383 | 2.2 | +5.121 | +5.346 | 175.416
2 x MULLION | C200SD/15deg-15deg | Z/736 | 66.1 | +0.000 | +5.286 | 96
MULLION TOP PLATE | C200SD/15deg-15deg | PL/384 | 2.2 | +5.121 | +5.299 | 173.863
MULLION TOP PLATE | C200SD/15deg-15deg | PL/356 | 1.8 | +4.937 | +5.114 | 173.857
2 x MULLION | C200SD/15deg-15deg | Z/730 | 41 | +0.000 | +5.102 | 76
MULLION TOP PLATE | C200SD/15deg-15deg | PL/355 | 1.8 | +4.937 | +5.161 | 175.255
MULLION TOP PLATE | C200SD/15deg | PL/328 | 1.5 | +4.749 | +4.926 | 173.862
MULLION TOP PLATE | C200SD/15deg-15deg | PL/327 | 1.5 | +4.749 | +4.973 | 175.259
2 x MULLION | C200SD/15deg-15deg | Z/712 | 34.9 | +0.000 | +4.914 | 76
4 x RAFTER | C200SD/15deg-15deg | Z/701 | 27.8 | +4.846 | +6.059 | 76
MULLION TOP PLATE | C200SD/9deg-9deg | PL/402 | 2.6 | +5.044 | +5.251 | 178.72
MULLION TOP PLATE | C200SD/9deg-9deg | PL/401 | 2.6 | +5.044 | +5.223 | 177.781
MULLION TOP PLATE | C200SD/9deg-9deg | PL/374 | 2.2 | +4.936 | +5.143 | 178.716
MULLION TOP PLATE | C200SD/9deg-9deg | PL/373 | 2.2 | +4.936 | +5.115 | 177.778
MULLION TOP PLATE | C200SD/9deg-9deg | PL/345 | 1.8 | +4.827 | +5.005 | 177.781
MULLION TOP PLATE | C200SD/9deg-9deg | PL/346 | 1.8 | +4.827 | +5.033 | 178.626
MULLION TOP PLATE | C200SD/9deg | PL/317 | 1.5 | +4.716 | +4.894 | 177.781
MULLION TOP PLATE | C200SD/9deg-9deg | PL/318 | 1.5 | +4.716 | +4.922 | 178.626
MULLION TOP PLATE | C200SD/5deg-5deg | PL/398 | 2.6 | +4.874 | +5.069 | 179.828
MULLION TOP PLATE | C200SD/5deg-5deg | PL/397 | 2.6 | +4.874 | +5.054 | 179.305
MULLION TOP PLATE | C200SD/5deg-5deg | PL/370 | 2.2 | +4.814 | +5.009 | 179.834
MULLION TOP PLATE | C200SD/5deg-5deg | PL/369 | 2.2 | +4.814 | +4.994 | 179.311
MULLION TOP PLATE | C200SD/5deg-5deg | PL/341 | 1.8 | +4.754 | +4.933 | 179.312
MULLION TOP PLATE | C200SD/5deg-5deg | PL/342 | 1.8 | +4.754 | +4.949 | 179.783
MULLION TOP PLATE | C200SD/5deg | PL/313 | 1.5 | +4.693 | +4.872 | 179.309
MULLION TOP PLATE | C200SD/5deg-5deg | PL/314 | 1.5 | +4.693 | +4.888 | 179.78
MULLION TOP PLATE | C200SD/3deg-3deg | PL/394 | 2.6 | +4.790 | +4.979 | 180.065
MULLION TOP PLATE | C200SD/3deg-3deg | PL/393 | 2.6 | +4.790 | +4.970 | 179.751
MULLION TOP PLATE | C200SD/3deg-3deg | PL/366 | 2.2 | +4.754 | +4.943 | 180.058
MULLION TOP PLATE | C200SD/3deg-3deg | PL/365 | 2.2 | +4.754 | +4.934 | 179.744
MULLION TOP PLATE | C200SD/3deg-3deg | PL/337 | 1.8 | +4.718 | +4.898 | 179.752
MULLION TOP PLATE | C200SD/3deg-3deg | PL/338 | 1.8 | +4.718 | +4.907 | 180.034
MULLION TOP PLATE | C200SD/3deg | PL/309 | 1.5 | +4.681 | +4.861 | 179.745
MULLION TOP PLATE | C200SD/3deg-3deg | PL/310 | 1.5 | +4.681 | +4.870 | 180.028
MULLION TOP PLATE | C200SD/25deg-25deg | PL/418 | 2.6 | +5.778 | +6.031 | 165.664
MULLION TOP PLATE | C200SD/25deg-25deg | PL/417 | 2.5 | +5.778 | +5.953 | 163.128
MULLION TOP PLATE | C200SD/25deg-25deg | PL/390 | 2.2 | +5.458 | +5.711 | 165.668
MULLION TOP PLATE | C200SD/25deg-25deg | PL/389 | 2.1 | +5.458 | +5.633 | 163.132
MULLION TOP PLATE | C200SD/25deg-25deg | PL/361 | 1.8 | +5.137 | +5.312 | 163.129
MULLION TOP PLATE | C200SD/25deg-25deg | PL/362 | 1.8 | +5.137 | +5.389 | 165.411
MULLION TOP PLATE | C200SD/25deg | PL/333 | 1.3 | +4.810 | +4.985 | 163.132
MULLION TOP PLATE | C200SD/25deg-25deg | PL/334 | 1.5 | +4.810 | +5.062 | 165.414
MULLION TOP PLATE | C200SD/18deg-18deg | PL/414 | 2.6 | +5.441 | +5.674 | 173.037
MULLION TOP PLATE | C200SD/18deg-18deg | PL/413 | 2.5 | +5.441 | +5.618 | 171.183
MULLION TOP PLATE | C200SD/18deg-18deg | PL/386 | 2.2 | +5.218 | +5.451 | 173.043
MULLION TOP PLATE | C200SD/18deg-18deg | PL/385 | 2.2 | +5.218 | +5.395 | 171.189
MULLION TOP PLATE | C200SD/18deg-18deg | PL/357 | 1.8 | +4.994 | +5.171 | 171.184
MULLION TOP PLATE | C200SD/18deg-18deg | PL/358 | 1.8 | +4.994 | +5.227 | 172.852
MULLION TOP PLATE | C200SD/18deg | PL/329 | 1.5 | +4.767 | +4.943 | 171.188
MULLION TOP PLATE | C200SD/18deg-18deg | PL/330 | 1.5 | +4.767 | +4.999 | 172.857
MULLION TOP PLATE | C350SD/15deg-15deg | PL/577 | 1.8 | +4.796 | +4.974 | 173.851
MULLION TOP PLATE | C350SD/15deg-15deg | PL/578 | 1.8 | +4.796 | +5.021 | 175.254
MULLION TOP PLATE | C350SD/15deg-15deg | PL/605 | 2.2 | +4.981 | +5.159 | 173.857
MULLION TOP PLATE | C300SD/15deg-15deg | PL/494 | 2.2 | +5.029 | +5.253 | 175.415
MULLION TOP PLATE | C250SD/15deg-15deg | PL/410 | 2.6 | +5.257 | +5.481 | 174.474
MULLION TOP PLATE | C250SD/15deg-15deg | PL/409 | 2.5 | +5.257 | +5.434 | 172.921
MULLION TOP PLATE | C250SD/15deg-15deg | PL/382 | 2.2 | +5.074 | +5.297 | 174.475
MULLION TOP PLATE | C250SD/15deg-15deg | PL/381 | 2.1 | +5.074 | +5.250 | 172.922
MULLION TOP PLATE | C250SD/15deg-15deg | PL/326 | 1.5 | +4.701 | +4.924 | 174.319
MULLION TOP PLATE | C250SD/15deg-15deg | PL/354 | 1.8 | +4.889 | +5.112 | 174.324
MULLION TOP PLATE | C250SD/15deg-15deg | PL/353 | 1.8 | +4.889 | +5.065 | 172.926
MULLION TOP PLATE | C250SD/15deg | PL/325 | 1.5 | +4.701 | +4.878 | 172.921
MULLION TOP PLATE | C200SD/15deg-15deg | PL/410 | 2.6 | +5.305 | +5.529 | 175.416
MULLION TOP PLATE | C200SD/15deg-15deg | PL/409 | 2.6 | +5.305 | +5.483 | 173.863
MULLION TOP PLATE | C200SD/15deg-15deg | PL/382 | 2.2 | +5.121 | +5.346 | 175.416
MULLION TOP PLATE | C200SD/15deg-15deg | PL/381 | 2.2 | +5.121 | +5.299 | 173.863
MULLION TOP PLATE | C200SD/15deg-15deg | PL/353 | 1.8 | +4.937 | +5.114 | 173.857
MULLION TOP PLATE | C200SD/15deg-15deg | PL/354 | 1.8 | +4.937 | +5.161 | 175.255
MULLION TOP PLATE | C300SD/15deg-15deg | PL/438 | 1.5 | +4.657 | +4.881 | 175.259
MULLION TOP PLATE | C300SD/15deg-15deg | PL/466 | 1.8 | +4.844 | +5.068 | 175.254
MULLION TOP PLATE | C300SD/15deg-15deg | PL/522 | 2.6 | +5.213 | +5.437 | 175.414
MULLION TOP PLATE | C300SD/15deg-15deg | PL/521 | 2.6 | +5.213 | +5.390 | 173.861
MULLION TOP PLATE | C300SD/15deg | PL/437 | 1.5 | +4.657 | +4.834 | 173.861
MULLION TOP PLATE | C300SD/15deg-15deg | PL/465 | 1.8 | +4.844 | +5.022 | 173.857
MULLION TOP PLATE | C350SD/15deg-15deg | PL/606 | 2.2 | +4.981 | +5.206 | 163.145
MULLION TOP PLATE | C350SD/15deg | PL/537 | 1.5 | +4.609 | +4.786 | 163.164
MULLION TOP PLATE | C350SD/15deg-15deg | PL/557 | 1.5 | +4.609 | +4.833 | 163.153
MULLION TOP PLATE | C350SD/15deg-15deg | PL/633 | 2.6 | +5.165 | +5.342 | 173.856
MULLION TOP PLATE | C350SD/15deg-15deg | PL/634 | 2.6 | +5.165 | +5.389 | 175.409
MULLION TOP PLATE | C300SD/15deg-15deg | PL/493 | 2.2 | +5.029 | +5.207 | 173.862
MULLION TOP PLATE | C200SD/15deg | PL/325 | 1.5 | +4.749 | +4.926 | 173.862
MULLION TOP PLATE | C200SD/15deg-15deg | PL/326 | 1.5 | +4.749 | +4.973 | 175.259
MULLION TOP PLATE | C300SD/12deg-12deg | PL/435 | 1.5 | +4.643 | +4.859 | 177.181
MULLION TOP PLATE | C300SD/12deg-12deg | PL/463 | 1.8 | +4.792 | +5.008 | 177.181
MULLION TOP PLATE | C300SD/12deg-12deg | PL/519 | 2.6 | +5.085 | +5.300 | 177.308
MULLION TOP PLATE | C300SD/12deg-12deg | PL/520 | 2.6 | +5.085 | +5.263 | 176.061
MULLION TOP PLATE | C300SD/12deg | PL/436 | 1.5 | +4.643 | +4.821 | 176.058
MULLION TOP PLATE | C300SD/12deg-12deg | PL/464 | 1.8 | +4.792 | +4.970 | 176.058
MULLION TOP PLATE | C250SD/12deg-12deg | PL/352 | 1.8 | +4.834 | +5.012 | 165.02
MULLION TOP PLATE | C250SD/12deg-12deg | PL/351 | 1.8 | +4.834 | +5.049 | 165.02
MULLION TOP PLATE | C250SD/12deg-12deg | PL/407 | 2.6 | +5.126 | +5.342 | 165.02
MULLION TOP PLATE | C250SD/12deg-12deg | PL/408 | 2.6 | +5.126 | +5.304 | 165.02
MULLION TOP PLATE | C350SD/12deg-12deg | PL/603 | 2.2 | +4.893 | +5.109 | 165.018
MULLION TOP PLATE | C350SD/12deg-12deg | PL/604 | 2.2 | +4.893 | +5.071 | 165.021
MULLION TOP PLATE | C250SD/12deg-12deg | PL/379 | 2.2 | +4.981 | +5.196 | 165.02
MULLION TOP PLATE | C250SD/12deg-12deg | PL/380 | 2.2 | +4.981 | +5.159 | 165.02
MULLION TOP PLATE | C350SD/12deg-12deg | PL/575 | 1.8 | +4.746 | +4.962 | 165.018
MULLION TOP PLATE | C350SD/12deg-12deg | PL/576 | 1.8 | +4.746 | +4.924 | 165.021
MULLION TOP PLATE | C350SD/12deg | PL/540 | 1.5 | +4.598 | +4.776 | 165.021
MULLION TOP PLATE | C350SD/12deg-12deg | PL/556 | 1.5 | +4.598 | +4.813 | 165.018
MULLION TOP PLATE | C250SD/12deg | PL/324 | 1.5 | +4.685 | +4.863 | 165.02
MULLION TOP PLATE | C250SD/12deg-12deg | PL/323 | 1.5 | +4.685 | +4.901 | 165.02
2 x MULLION | C350SD/12deg-12deg | Z/722 | 63.3 | +0.000 | +5.058 | 96
2 x MULLION | C350SD/12deg-12deg | Z/721 | 39.4 | +0.000 | +4.911 | 76
2 x MULLION | C350SD/12deg-12deg | Z/720 | 33.9 | +0.000 | +4.763 | 76
2 x MULLION | C300SD/12deg-12deg | Z/718 | 78.5 | +0.000 | +5.250 | 125
2 x MULLION | C300SD/12deg-12deg | Z/716 | 39.8 | +0.000 | +4.957 | 76
2 x MULLION | C300SD/12deg-12deg | Z/715 | 34.1 | +0.000 | +4.808 | 76
2 x MULLION | C250SD/12deg-12deg | Z/713 | 79.1 | +0.000 | +5.291 | 125
2 x MULLION | C250SD/12deg-12deg | Z/711 | 64.3 | +0.000 | +5.146 | 96
2 x MULLION | C250SD/12deg-12deg | Z/707 | 34.3 | +0.000 | +4.850 | 76
MULLION TOP PLATE | C200SD/12deg-12deg | PL/407 | 2.6 | +5.173 | +5.389 | 165.011
MULLION TOP PLATE | C200SD/12deg-12deg | PL/408 | 2.6 | +5.173 | +5.351 | 165.017
MULLION TOP PLATE | C200SD/12deg-12deg | PL/379 | 2.2 | +5.027 | +5.243 | 165.015
MULLION TOP PLATE | C200SD/12deg-12deg | PL/380 | 2.2 | +5.027 | +5.205 | 165.022
MULLION TOP PLATE | C200SD/12deg-12deg | PL/351 | 1.8 | +4.881 | +5.096 | 165.014
MULLION TOP PLATE | C200SD/12deg-12deg | PL/352 | 1.8 | +4.881 | +5.059 | 165.017
2 x MULLION | C200SD/12deg-12deg | Z/704 | 79.8 | +0.000 | +5.338 | 125
2 x MULLION | C200SD/12deg-12deg | Z/702 | 65 | +0.000 | +5.192 | 96
2 x MULLION | C200SD/12deg-12deg | Z/700 | 40.5 | +0.000 | +5.046 | 76
MULLION TOP PLATE | C350SD/12deg-12deg | PL/632 | 2.6 | +5.039 | +5.217 | 176.056
MULLION TOP PLATE | C350SD/12deg-12deg | PL/631 | 2.6 | +5.039 | +5.254 | 177.304
MULLION TOP PLATE | C300SD/12deg-12deg | PL/492 | 2.2 | +4.939 | +5.117 | 176.063
MULLION TOP PLATE | C300SD/12deg-12deg | PL/491 | 2.2 | +4.939 | +5.154 | 165.02
MULLION TOP PLATE | C200SD/12deg | PL/324 | 1.5 | +4.732 | +4.910 | 176.064
MULLION TOP PLATE | C200SD/12deg-12deg | PL/323 | 1.5 | +4.732 | +4.947 | 177.187
2 x MULLION | C350SD/12deg-12deg | Z/723 | 77.9 | +0.000 | +5.204 | 125
2 x MULLION | C300SD/12deg-12deg | Z/717 | 63.8 | +0.000 | +5.104 | 96
2 x MULLION | C250SD/12deg-12deg | Z/709 | 40.1 | +0.000 | +4.999 | 76
2 x MULLION | C200SD/12deg-12deg | Z/698 | 34.7 | +0.000 | +4.897 | 76
MULLION TOP PLATE | C350SD/12deg-12deg | PL/555 | 1.5 | +4.598 | +4.813 | 165.018
MULLION TOP PLATE | C350SD/12deg-12deg | PL/574 | 1.8 | +4.746 | +4.962 | 165.018
MULLION TOP PLATE | C350SD/12deg-12deg | PL/602 | 2.2 | +4.893 | +5.109 | 165.018
MULLION TOP PLATE | C350SD/12deg | PL/539 | 1.5 | +4.598 | +4.776 | 165.021
MULLION TOP PLATE | C350SD/12deg-12deg | PL/573 | 1.8 | +4.746 | +4.924 | 165.021
MULLION TOP PLATE | C350SD/12deg-12deg | PL/601 | 2.2 | +4.893 | +5.071 | 165.021
MULLION TOP PLATE | C300SD/12deg-12deg | PL/434 | 1.5 | +4.643 | +4.859 | 177.181
MULLION TOP PLATE | C300SD/12deg-12deg | PL/462 | 1.8 | +4.792 | +5.008 | 177.181
MULLION TOP PLATE | C300SD/12deg-12deg | PL/518 | 2.6 | +5.085 | +5.300 | 177.308
MULLION TOP PLATE | C300SD/12deg-12deg | PL/517 | 2.6 | +5.085 | +5.263 | 176.061
MULLION TOP PLATE | C300SD/12deg | PL/433 | 1.5 | +4.643 | +4.821 | 176.058
MULLION TOP PLATE | C300SD/12deg-12deg | PL/461 | 1.8 | +4.792 | +4.970 | 176.058
MULLION TOP PLATE | C250SD/12deg-12deg | PL/406 | 2.6 | +5.126 | +5.342 | 165.02
MULLION TOP PLATE | C250SD/12deg-12deg | PL/378 | 2.2 | +4.981 | +5.196 | 165.02
MULLION TOP PLATE | C250SD/12deg-12deg | PL/322 | 1.5 | +4.685 | +4.901 | 165.02
MULLION TOP PLATE | C250SD/12deg-12deg | PL/405 | 2.6 | +5.126 | +5.304 | 165.02
MULLION TOP PLATE | C250SD/12deg-12deg | PL/377 | 2.2 | +4.981 | +5.159 | 165.02
MULLION TOP PLATE | C250SD/12deg | PL/321 | 1.5 | +4.685 | +4.863 | 165.02
MULLION TOP PLATE | C250SD/12deg-12deg | PL/349 | 1.8 | +4.834 | +5.012 | 165.02
MULLION TOP PLATE | C250SD/12deg-12deg | PL/350 | 1.8 | +4.834 | +5.049 | 165.02
MULLION TOP PLATE | C200SD/12deg-12deg | PL/405 | 2.6 | +5.173 | +5.351 | 165.017
MULLION TOP PLATE | C200SD/12deg-12deg | PL/406 | 2.6 | +5.173 | +5.389 | 165.011
MULLION TOP PLATE | C200SD/12deg-12deg | PL/377 | 2.2 | +5.027 | +5.205 | 165.022
MULLION TOP PLATE | C200SD/12deg-12deg | PL/378 | 2.2 | +5.027 | +5.243 | 165.015
MULLION TOP PLATE | C200SD/12deg-12deg | PL/349 | 1.8 | +4.881 | +5.059 | 165.017
MULLION TOP PLATE | C200SD/12deg-12deg | PL/350 | 1.8 | +4.881 | +5.096 | 165.014
MULLION TOP PLATE | C350SD/12deg-12deg | PL/629 | 2.6 | +5.039 | +5.217 | 176.056
MULLION TOP PLATE | C350SD/12deg-12deg | PL/630 | 2.6 | +5.039 | +5.254 | 177.304
MULLION TOP PLATE | C300SD/12deg-12deg | PL/489 | 2.2 | +4.939 | +5.117 | 176.063
MULLION TOP PLATE | C300SD/12deg-12deg | PL/490 | 2.2 | +4.939 | +5.154 | 165.02
MULLION TOP PLATE | C200SD/12deg | PL/321 | 1.5 | +4.732 | +4.910 | 176.064
MULLION TOP PLATE | C200SD/12deg-12deg | PL/322 | 1.5 | +4.732 | +4.947 | 177.187
4 x RAFTER | C350SD/12deg-12deg | Z/719 | 57.1 | +4.734 | +5.871 | 125
4 x RAFTER | C300SD/12deg-12deg | Z/714 | 48.2 | +4.772 | +5.868 | 96
4 x RAFTER | C200SD/12deg-12deg | Z/696 | 27.8 | +4.846 | +5.861 | 76
4 x RAFTER | C250SD/12deg-12deg | Z/705 | 31.2 | +4.807 | +5.865 | 76

# IfcMechanicalFastener: Bolt assembly (1120)
In: Undefined
NominalDiameter: 12 mm; Material: 8.8S
Tekla Bolt - Washer diameter: 12 mm; Washer type: HARD; Washer name: WASHERM12-HARD; Nut type: 8.8-HEX; Nut name: NUTM12-8.8-HEX; Slotted hole y: 0 mm; Slotted hole x: 14 mm; Bolt hole diameter: 14 mm; Location: Site; Bolt size: 12 mm; Bolt standard: 8.8S
Name | NominalLength (mm) = Bolt length (mm) | Washer count = Nut count = Bolt count | Bolt Name
896 x Bolt assembly | 30 | 2 | BOLTM12*30
224 x Bolt assembly | 35 | 4 | BOLTM12*35

# IfcMember: C:200-24 (4)
In: Undefined
Description: C:200-24; Material: STEEL/G450
Tekla Quantity - Weight: 27.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 110 m2; Net surface area: 3.1 m2; Height: 203 mm; Width: 76 mm; Length: 3927.1 mm
Tekla Common - Finish: 15 deg; Bottom elevation: +4.846; Top elevation: +6.690; Phase: 1; Class: 1
Pset_MemberCommon - LoadBearing: no; Reference: Z/701
BaseQuantities - Length: 3927.11 mm; OuterSurfaceArea: 3.06343 m2; GrossSurfaceArea: 0 m2; CrossSectionArea: 0.000903 m2; NetVolume: 0.00365127 m3; GrossVolume: 0.00354618 m3; NetWeight: 28.6625 kg; GrossWeight: 27.8375 kg

# IfcMember: C:250-24 (4)
In: Undefined
Description: C:250-24; Material: STEEL/G450
Tekla Quantity - Weight: 31.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 109.7 m2; Net surface area: 3.4 m2; Height: 254 mm; Width: 76 mm; Length: 3890.2 mm
Tekla Common - Finish: 25 deg; Bottom elevation: +4.807; Top elevation: +6.682; Phase: 1; Class: 1
Pset_MemberCommon - LoadBearing: no; Reference: Z/750
BaseQuantities - Length: 3890.2 mm; OuterSurfaceArea: 3.42392 m2; GrossSurfaceArea: 0 m2; CrossSectionArea: 0.001022 m2; NetVolume: 0.00408377 m3; GrossVolume: 0.00397578 m3; NetWeight: 32.0576 kg; GrossWeight: 31.2099 kg

# IfcMember: C:300-30 (4)
In: Undefined
Description: C:300-30; Material: STEEL/G450
Tekla Quantity - Weight: 48.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.3 m2; Net surface area: 4.3 m2; Height: 300 mm; Width: 96 mm; Length: 3856.9 mm
Tekla Common - Finish: 25 deg; Bottom elevation: +4.772; Top elevation: +6.674; Phase: 1; Class: 1
Pset_MemberCommon - LoadBearing: no; Reference: Z/780
BaseQuantities - Length: 3856.9 mm; OuterSurfaceArea: 4.21499 m2; GrossSurfaceArea: 0 m2; CrossSectionArea: 0.001593 m2; NetVolume: 0.00628289 m3; GrossVolume: 0.00614404 m3; NetWeight: 49.3207 kg; GrossWeight: 48.2307 kg

# IfcMember: C:350-30 (4)
In: Undefined
Description: C:350-30; Material: STEEL/G450
Tekla Quantity - Weight: 57.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.2 m2; Net surface area: 5 m2; Height: 350 mm; Width: 125 mm; Length: 3820.7 mm
Tekla Common - Finish: 25 deg; Bottom elevation: +4.734; Top elevation: +6.666; Phase: 1; Class: 1
Pset_MemberCommon - LoadBearing: no; Reference: Z/810
BaseQuantities - Length: 3820.71 mm; OuterSurfaceArea: 4.97845 m2; GrossSurfaceArea: 0 m2; CrossSectionArea: 0.001905 m2; NetVolume: 0.00742746 m3; GrossVolume: 0.00727846 m3; NetWeight: 58.3056 kg; GrossWeight: 57.1359 kg

# IfcPlate: PLT3*0, MULLION TOP PLATE
In: Undefined
Description: PLT3*0; Material: STEEL/450
Default - ASSEMBLY_POS: PL/550
Tekla Common - Bottom elevation: +4.565; Top elevation: +4.754; Phase: 1; Class: 3
Tekla Quantity - Weight: 1.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.3 m2; Net surface area: 0.1 m2; Height: 0 mm; Width: 0 mm; Length: 207 mm
Pset_PlateCommon - LoadBearing: no; Reference: PL/550
BaseQuantities - Width: 0 mm; NetArea: 0.131745 m2; GrossArea: 0 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000192352 m3; GrossVolume: 0.000193222 m3

# IfcPlate: PLT3*170 (84)
In: Undefined
Description: PLT3*170; Material: STEEL/450
Tekla Common - Phase: 1; Class: 3
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.1 m2; Height: 170 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Length (mm) | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
MULLION TOP PLATE | PL/431 | +4.630 | +4.837 | 1.5 | 87.3 | 341.9 | 170.001 | 0.120004 | 0.0581318 | 0.000175123
MULLION TOP PLATE | PL/432 | +4.630 | +4.809 | 1.5 | 87.3 | 338.7 | 170.001 | 0.118998 | 0.057583 | 0.000173435
MULLION TOP PLATE | PL/427 | +4.613 | +4.808 | 1.5 | 87.3 | 341.1 | 170.001 | 0.119751 | 0.0579948 | 0.000174712
MULLION TOP PLATE | PL/428 | +4.613 | +4.793 | 1.5 | 87.3 | 339.4 | 170.001 | 0.119196 | 0.0576917 | 0.00017378
MULLION TOP PLATE | PL/423 | +4.605 | +4.794 | 1.5 | 87.3 | 340.7 | 170.001 | 0.119615 | 0.0579216 | 0.00017449
MULLION TOP PLATE | PL/424 | +4.605 | +4.785 | 1.5 | 87.3 | 339.6 | 170.001 | 0.119282 | 0.0577399 | 0.000173931
MULLION TOP PLATE | PL/447 | +4.704 | +4.956 | 1.5 | 87.2 | 345.1 | 170.001 | 0.120988 | 0.058669 | 0.00017672
MULLION TOP PLATE | PL/448 | +4.704 | +4.880 | 1.5 | 87.5 | 336.3 | 170.001 | 0.118278 | 0.0571756 | 0.000172243
MULLION TOP PLATE | PL/443 | +4.670 | +4.903 | 1.5 | 87.3 | 343.7 | 170.001 | 0.120541 | 0.0584265 | 0.00017599
MULLION TOP PLATE | PL/444 | +4.670 | +4.847 | 1.5 | 87.5 | 337 | 170.001 | 0.118437 | 0.0572842 | 0.000172476
MULLION TOP PLATE | PL/439 | +4.657 | +4.881 | 1.5 | 87.3 | 343.1 | 170.001 | 0.120366 | 0.0583301 | 0.000175709
MULLION TOP PLATE | PL/440 | +4.657 | +4.834 | 1.5 | 87.5 | 337.6 | 170.001 | 0.11864 | 0.0573917 | 0.000172823
MULLION TOP PLATE | PL/430 | +4.630 | +4.837 | 1.5 | 87.3 | 341.9 | 170.001 | 0.120004 | 0.0581318 | 0.000175123
MULLION TOP PLATE | PL/429 | +4.630 | +4.809 | 1.5 | 87.3 | 338.7 | 170.001 | 0.118998 | 0.057583 | 0.000173435
MULLION TOP PLATE | PL/426 | +4.613 | +4.808 | 1.5 | 87.3 | 341.1 | 170.001 | 0.119751 | 0.0579948 | 0.000174712
MULLION TOP PLATE | PL/425 | +4.613 | +4.793 | 1.5 | 87.3 | 339.4 | 170.001 | 0.119196 | 0.0576917 | 0.00017378
MULLION TOP PLATE | PL/422 | +4.605 | +4.794 | 1.5 | 87.3 | 340.7 | 170.001 | 0.119615 | 0.0579216 | 0.00017449
MULLION TOP PLATE | PL/421 | +4.605 | +4.785 | 1.5 | 87.3 | 339.6 | 170.001 | 0.119282 | 0.0577399 | 0.000173931
MULLION TOP PLATE | PL/446 | +4.704 | +4.956 | 1.5 | 87.2 | 345.1 | 170.001 | 0.120988 | 0.058669 | 0.00017672
MULLION TOP PLATE | PL/445 | +4.704 | +4.880 | 1.5 | 87.5 | 336.3 | 170.001 | 0.118278 | 0.0571756 | 0.000172243
MULLION TOP PLATE | PL/442 | +4.670 | +4.903 | 1.5 | 87.3 | 343.7 | 170.001 | 0.120541 | 0.0584265 | 0.00017599
MULLION TOP PLATE | PL/441 | +4.670 | +4.847 | 1.5 | 87.5 | 337 | 170.001 | 0.118437 | 0.0572842 | 0.000172476
MULLION TOP PLATE | PL/319 | +4.670 | +4.877 | 1.5 | 87.3 | 341.9 | 170.001 | 0.120008 | 0.0581338 | 0.000175129
MULLION TOP PLATE | PL/320 | +4.670 | +4.849 | 1.5 | 87.3 | 338.7 | 170.001 | 0.119001 | 0.0575846 | 0.00017344
MULLION TOP PLATE | PL/315 | +4.651 | +4.846 | 1.5 | 87.3 | 341.1 | 170.001 | 0.11975 | 0.0579941 | 0.00017471
MULLION TOP PLATE | PL/316 | +4.651 | +4.830 | 1.5 | 87.3 | 339.4 | 170.001 | 0.119196 | 0.0576915 | 0.000173779
MULLION TOP PLATE | PL/311 | +4.642 | +4.830 | 1.5 | 87.3 | 340.7 | 170.001 | 0.119617 | 0.0579222 | 0.000174492
MULLION TOP PLATE | PL/312 | +4.642 | +4.821 | 1.5 | 87.3 | 339.7 | 170.001 | 0.119288 | 0.0577427 | 0.00017394
MULLION TOP PLATE | PL/335 | +4.754 | +5.006 | 1.5 | 87.2 | 345 | 170.001 | 0.120936 | 0.0586461 | 0.000176621
MULLION TOP PLATE | PL/336 | +4.754 | +4.929 | 1.3 | 87.5 | 335.2 | 170.001 | 0.11786 | 0.0569849 | 0.000171508
MULLION TOP PLATE | PL/331 | +4.716 | +4.948 | 1.5 | 87.3 | 343.7 | 170.001 | 0.120542 | 0.058427 | 0.000175992
MULLION TOP PLATE | PL/332 | +4.716 | +4.893 | 1.5 | 87.5 | 337 | 170.001 | 0.118438 | 0.0572849 | 0.000172478
MULLION TOP PLATE | PL/327 | +4.701 | +4.924 | 1.5 | 87.3 | 342.1 | 170.001 | 0.120029 | 0.0581645 | 0.000175212
MULLION TOP PLATE | PL/328 | +4.701 | +4.878 | 1.5 | 87.5 | 336.6 | 170.001 | 0.118309 | 0.0572287 | 0.000172334
MULLION TOP PLATE | PL/318 | +4.670 | +4.877 | 1.5 | 87.3 | 341.9 | 170.001 | 0.120008 | 0.0581338 | 0.000175129
MULLION TOP PLATE | PL/317 | +4.670 | +4.849 | 1.5 | 87.3 | 338.7 | 170.001 | 0.119001 | 0.0575846 | 0.00017344
MULLION TOP PLATE | PL/314 | +4.651 | +4.846 | 1.5 | 87.3 | 341.1 | 170.001 | 0.11975 | 0.0579941 | 0.00017471
MULLION TOP PLATE | PL/313 | +4.651 | +4.830 | 1.5 | 87.3 | 339.4 | 170.001 | 0.119196 | 0.0576915 | 0.000173779
MULLION TOP PLATE | PL/310 | +4.642 | +4.830 | 1.5 | 87.3 | 340.7 | 170.001 | 0.119617 | 0.0579222 | 0.000174492
MULLION TOP PLATE | PL/309 | +4.642 | +4.821 | 1.5 | 87.3 | 339.7 | 170.001 | 0.119288 | 0.0577427 | 0.00017394
MULLION TOP PLATE | PL/334 | +4.754 | +5.006 | 1.5 | 87.2 | 345 | 170.001 | 0.120936 | 0.0586461 | 0.000176621
MULLION TOP PLATE | PL/333 | +4.754 | +4.929 | 1.3 | 87.5 | 335.2 | 170.001 | 0.11786 | 0.0569849 | 0.000171508
MULLION TOP PLATE | PL/330 | +4.716 | +4.948 | 1.5 | 87.3 | 343.7 | 170.001 | 0.120542 | 0.058427 | 0.000175992
MULLION TOP PLATE | PL/329 | +4.716 | +4.893 | 1.5 | 87.5 | 337 | 170.001 | 0.118438 | 0.0572849 | 0.000172478
MULLION TOP PLATE | PL/320 | +4.716 | +4.894 | 1.5 | 87.3 | 338.7 | 170.001 | 0.119 | 0.0575843 | 0.000173439
MULLION TOP PLATE | PL/319 | +4.716 | +4.922 | 1.5 | 87.3 | 341.9 | 170.001 | 0.12001 | 0.0581349 | 0.000175132
MULLION TOP PLATE | PL/316 | +4.693 | +4.872 | 1.5 | 87.3 | 339.4 | 170.001 | 0.119195 | 0.0576913 | 0.000173778
MULLION TOP PLATE | PL/315 | +4.693 | +4.888 | 1.5 | 87.3 | 341.1 | 170.001 | 0.119751 | 0.0579945 | 0.000174711
MULLION TOP PLATE | PL/312 | +4.681 | +4.861 | 1.5 | 87.3 | 339.7 | 170.001 | 0.119288 | 0.0577427 | 0.00017394
MULLION TOP PLATE | PL/311 | +4.681 | +4.870 | 1.5 | 87.3 | 340.7 | 170.001 | 0.119618 | 0.0579227 | 0.000174494
MULLION TOP PLATE | PL/336 | +4.810 | +4.985 | 1.3 | 87.5 | 335.2 | 170.001 | 0.117859 | 0.0569843 | 0.000171506
MULLION TOP PLATE | PL/335 | +4.810 | +5.062 | 1.5 | 87.2 | 345 | 170.001 | 0.120934 | 0.0586451 | 0.000176618
MULLION TOP PLATE | PL/332 | +4.767 | +4.943 | 1.5 | 87.5 | 337 | 170.001 | 0.118438 | 0.0572847 | 0.000172477
MULLION TOP PLATE | PL/331 | +4.767 | +4.999 | 1.5 | 87.3 | 343.7 | 170.001 | 0.120543 | 0.0584274 | 0.000175993
MULLION TOP PLATE | PL/328 | +4.749 | +4.926 | 1.5 | 87.5 | 337.6 | 170.001 | 0.118644 | 0.0573933 | 0.000172827
MULLION TOP PLATE | PL/327 | +4.749 | +4.973 | 1.5 | 87.3 | 343.1 | 170.001 | 0.120368 | 0.0583309 | 0.000175712
MULLION TOP PLATE | PL/317 | +4.716 | +4.894 | 1.5 | 87.3 | 338.7 | 170.001 | 0.119 | 0.0575843 | 0.000173439
MULLION TOP PLATE | PL/318 | +4.716 | +4.922 | 1.5 | 87.3 | 341.9 | 170.001 | 0.12001 | 0.0581349 | 0.000175132
MULLION TOP PLATE | PL/313 | +4.693 | +4.872 | 1.5 | 87.3 | 339.4 | 170.001 | 0.119195 | 0.0576913 | 0.000173778
MULLION TOP PLATE | PL/314 | +4.693 | +4.888 | 1.5 | 87.3 | 341.1 | 170.001 | 0.119751 | 0.0579945 | 0.000174711
MULLION TOP PLATE | PL/309 | +4.681 | +4.861 | 1.5 | 87.3 | 339.7 | 170.001 | 0.119288 | 0.0577427 | 0.00017394
MULLION TOP PLATE | PL/310 | +4.681 | +4.870 | 1.5 | 87.3 | 340.7 | 170.001 | 0.119618 | 0.0579227 | 0.000174494
MULLION TOP PLATE | PL/333 | +4.810 | +4.985 | 1.3 | 87.5 | 335.2 | 170.001 | 0.117859 | 0.0569843 | 0.000171506
MULLION TOP PLATE | PL/334 | +4.810 | +5.062 | 1.5 | 87.2 | 345 | 170.001 | 0.120934 | 0.0586451 | 0.000176618
MULLION TOP PLATE | PL/329 | +4.767 | +4.943 | 1.5 | 87.5 | 337 | 170.001 | 0.118438 | 0.0572847 | 0.000172477
MULLION TOP PLATE | PL/330 | +4.767 | +4.999 | 1.5 | 87.3 | 343.7 | 170.001 | 0.120543 | 0.0584274 | 0.000175993
MULLION TOP PLATE | PL/326 | +4.701 | +4.924 | 1.5 | 87.3 | 342.1 | 170.001 | 0.120029 | 0.0581645 | 0.000175212
MULLION TOP PLATE | PL/325 | +4.701 | +4.878 | 1.5 | 87.5 | 336.6 | 170.001 | 0.118309 | 0.0572287 | 0.000172334
MULLION TOP PLATE | PL/438 | +4.657 | +4.881 | 1.5 | 87.3 | 343.1 | 170.001 | 0.120366 | 0.0583301 | 0.000175709
MULLION TOP PLATE | PL/437 | +4.657 | +4.834 | 1.5 | 87.5 | 337.6 | 170.001 | 0.11864 | 0.0573917 | 0.000172823
MULLION TOP PLATE | PL/325 | +4.749 | +4.926 | 1.5 | 87.5 | 337.6 | 170.001 | 0.118644 | 0.0573933 | 0.000172827
MULLION TOP PLATE | PL/326 | +4.749 | +4.973 | 1.5 | 87.3 | 343.1 | 170.001 | 0.120368 | 0.0583309 | 0.000175712
MULLION TOP PLATE | PL/435 | +4.643 | +4.859 | 1.5 | 87.3 | 342.5 | 170.001 | 0.120191 | 0.0582337 | 0.000175426
MULLION TOP PLATE | PL/436 | +4.643 | +4.821 | 1.5 | 87.3 | 338.2 | 170.001 | 0.118828 | 0.0574915 | 0.000173143
MULLION TOP PLATE | PL/324 | +4.685 | +4.863 | 1.5 | 87.3 | 338.2 | 170.007 | 0.11883 | 0.0574946 | 0.000173146
MULLION TOP PLATE | PL/323 | +4.685 | +4.901 | 1.5 | 87.3 | 342.6 | 170.007 | 0.120192 | 0.0582366 | 0.000175428
MULLION TOP PLATE | PL/324 | +4.732 | +4.910 | 1.5 | 87.3 | 338.2 | 170.001 | 0.11883 | 0.0574927 | 0.000173146
MULLION TOP PLATE | PL/323 | +4.732 | +4.947 | 1.5 | 87.3 | 342.6 | 170.001 | 0.120194 | 0.0582352 | 0.00017543
MULLION TOP PLATE | PL/434 | +4.643 | +4.859 | 1.5 | 87.3 | 342.5 | 170.001 | 0.120191 | 0.0582337 | 0.000175426
MULLION TOP PLATE | PL/433 | +4.643 | +4.821 | 1.5 | 87.3 | 338.2 | 170.001 | 0.118828 | 0.0574915 | 0.000173143
MULLION TOP PLATE | PL/321 | +4.685 | +4.863 | 1.5 | 87.3 | 338.2 | 170.007 | 0.11883 | 0.0574946 | 0.000173146
MULLION TOP PLATE | PL/322 | +4.685 | +4.901 | 1.5 | 87.3 | 342.6 | 170.007 | 0.120192 | 0.0582366 | 0.000175428
MULLION TOP PLATE | PL/321 | +4.732 | +4.910 | 1.5 | 87.3 | 338.2 | 170.001 | 0.11883 | 0.0574927 | 0.000173146
MULLION TOP PLATE | PL/322 | +4.732 | +4.947 | 1.5 | 87.3 | 342.6 | 170.001 | 0.120194 | 0.0582352 | 0.00017543

# IfcPlate: PLT3*207 (27)
In: Undefined
Description: PLT3*207; Material: STEEL/450
Tekla Common - Phase: 1; Class: 3
Tekla Quantity - Weight: 1.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.1 m2; Height: 207 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Area per tons (m2) | Length (mm) | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) | GrossVolume (m3)
MULLION TOP PLATE | PL/542 | +4.587 | +4.765 | 87.3 | 338.7 | 207 | 0.13101 | 0.0701085 | 0.00019112 | 0.000191958
MULLION TOP PLATE | PL/554 | +4.587 | +4.793 | 87.2 | 341.9 | 207 | 0.132169 | 0.0707831 | 0.000193035 | 0.000193964
MULLION TOP PLATE | PL/544 | +4.572 | +4.751 | 87.3 | 339.4 | 207 | 0.131253 | 0.0702462 | 0.000191531 | 0.000192377
MULLION TOP PLATE | PL/552 | +4.572 | +4.767 | 87.2 | 341.1 | 207 | 0.131885 | 0.0706151 | 0.000192578 | 0.000193474
MULLION TOP PLATE | PL/546 | +4.565 | +4.744 | 87.3 | 339.7 | 207 | 0.131368 | 0.0703087 | 0.000191726 | 0.000192567
MULLION TOP PLATE | PL/534 | +4.649 | +4.824 | 87.5 | 335.2 | 207 | 0.129725 | 0.0693845 | 0.000188955 | 0.000189732
MULLION TOP PLATE | PL/548 | +4.649 | +4.902 | 87.2 | 345 | 207 | 0.133215 | 0.0714076 | 0.000194688 | 0.000195735
MULLION TOP PLATE | PL/536 | +4.621 | +4.797 | 87.3 | 337 | 207 | 0.130377 | 0.0697497 | 0.000190045 | 0.000190855
MULLION TOP PLATE | PL/560 | +4.621 | +4.853 | 87.2 | 343.7 | 207 | 0.13277 | 0.0711408 | 0.000193992 | 0.000194988
MULLION TOP PLATE | PL/538 | +4.609 | +4.786 | 87.3 | 337.6 | 207.003 | 0.130617 | 0.0698858 | 0.000190448 | 0.0001913
MULLION TOP PLATE | PL/558 | +4.609 | +4.833 | 87.2 | 343.1 | 207.003 | 0.132578 | 0.0710276 | 0.000193688 | 0.000194678
MULLION TOP PLATE | PL/541 | +4.587 | +4.765 | 87.3 | 338.7 | 207 | 0.13101 | 0.0701085 | 0.00019112 | 0.000191958
MULLION TOP PLATE | PL/553 | +4.587 | +4.793 | 87.2 | 341.9 | 207 | 0.132169 | 0.0707831 | 0.000193035 | 0.000193964
MULLION TOP PLATE | PL/543 | +4.572 | +4.751 | 87.3 | 339.4 | 207 | 0.131253 | 0.0702462 | 0.000191531 | 0.000192377
MULLION TOP PLATE | PL/551 | +4.572 | +4.767 | 87.2 | 341.1 | 207 | 0.131885 | 0.0706151 | 0.000192578 | 0.000193474
MULLION TOP PLATE | PL/545 | +4.565 | +4.744 | 87.3 | 339.7 | 207 | 0.131368 | 0.0703087 | 0.000191726 | 0.000192567
MULLION TOP PLATE | PL/549 | +4.565 | +4.754 | 87.3 | 340.7 | 207 | 0.131745 | 0.0705292 | 0.000192352 | 0.000193222
MULLION TOP PLATE | PL/533 | +4.649 | +4.824 | 87.5 | 335.2 | 207 | 0.129725 | 0.0693845 | 0.000188955 | 0.000189732
MULLION TOP PLATE | PL/547 | +4.649 | +4.902 | 87.2 | 345 | 207 | 0.133215 | 0.0714076 | 0.000194688 | 0.000195735
MULLION TOP PLATE | PL/535 | +4.621 | +4.797 | 87.3 | 337 | 207 | 0.130377 | 0.0697497 | 0.000190045 | 0.000190855
MULLION TOP PLATE | PL/559 | +4.621 | +4.853 | 87.2 | 343.7 | 207 | 0.13277 | 0.0711408 | 0.000193992 | 0.000194988
MULLION TOP PLATE | PL/537 | +4.609 | +4.786 | 87.3 | 337.6 | 207.003 | 0.130617 | 0.0698858 | 0.000190448 | 0.0001913
MULLION TOP PLATE | PL/557 | +4.609 | +4.833 | 87.2 | 343.1 | 207.003 | 0.132578 | 0.0710276 | 0.000193688 | 0.000194678
MULLION TOP PLATE | PL/540 | +4.598 | +4.776 | 87.3 | 338.2 | 207.003 | 0.130827 | 0.070005 | 0.000190806 | 0.000191664
MULLION TOP PLATE | PL/556 | +4.598 | +4.813 | 87.2 | 342.5 | 207.003 | 0.132379 | 0.0709088 | 0.000193372 | 0.000194339
MULLION TOP PLATE | PL/539 | +4.598 | +4.776 | 87.3 | 338.2 | 207.003 | 0.130827 | 0.070005 | 0.000190806 | 0.000191664
MULLION TOP PLATE | PL/555 | +4.598 | +4.813 | 87.2 | 342.5 | 207.003 | 0.132379 | 0.0709088 | 0.000193372 | 0.000194339

# IfcPlate: PLT3*220 (112)
In: Undefined
Description: PLT3*220; Material: STEEL/450
Tekla Common - Phase: 1; Class: 3
Tekla Quantity - Weight: 1.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.2 m2; Height: 220 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Area per tons (m2) | Length (mm) | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
MULLION TOP PLATE | PL/572 | +4.697 | +4.876 | 87.2 | 338.7 | 220.002 | 0.153394 | 0.0745181 | 0.000224441
MULLION TOP PLATE | PL/571 | +4.697 | +4.904 | 87 | 341.9 | 220.002 | 0.154693 | 0.0752298 | 0.000226631
MULLION TOP PLATE | PL/568 | +4.633 | +4.813 | 87 | 339.4 | 220.002 | 0.153653 | 0.0746603 | 0.000224892
MULLION TOP PLATE | PL/567 | +4.633 | +4.828 | 87 | 341.1 | 220.002 | 0.154368 | 0.0750522 | 0.000226098
MULLION TOP PLATE | PL/564 | +4.602 | +4.781 | 87 | 339.7 | 220.002 | 0.153768 | 0.0747246 | 0.000225094
MULLION TOP PLATE | PL/563 | +4.602 | +4.790 | 87 | 340.7 | 220.002 | 0.154193 | 0.0749579 | 0.000225812
MULLION TOP PLATE | PL/588 | +4.976 | +5.151 | 87.2 | 335.2 | 220.002 | 0.151923 | 0.073741 | 0.000221938
MULLION TOP PLATE | PL/587 | +4.976 | +5.228 | 86.8 | 345 | 220.002 | 0.15589 | 0.0758929 | 0.000228561
MULLION TOP PLATE | PL/584 | +4.848 | +5.025 | 87.2 | 337 | 220.002 | 0.15267 | 0.0741307 | 0.000223198
MULLION TOP PLATE | PL/583 | +4.848 | +5.081 | 86.8 | 343.7 | 220.002 | 0.155382 | 0.0756092 | 0.000227747
MULLION TOP PLATE | PL/580 | +4.796 | +4.974 | 87.2 | 337.6 | 220.002 | 0.152937 | 0.0742721 | 0.000223653
MULLION TOP PLATE | PL/579 | +4.796 | +5.021 | 86.8 | 343.1 | 220.002 | 0.155159 | 0.0754855 | 0.000227387
MULLION TOP PLATE | PL/569 | +4.697 | +4.876 | 87.2 | 338.7 | 220.002 | 0.153394 | 0.0745181 | 0.000224441
MULLION TOP PLATE | PL/570 | +4.697 | +4.904 | 87 | 341.9 | 220.002 | 0.154693 | 0.0752298 | 0.000226631
MULLION TOP PLATE | PL/565 | +4.633 | +4.813 | 87 | 339.4 | 220.002 | 0.153653 | 0.0746603 | 0.000224892
MULLION TOP PLATE | PL/566 | +4.633 | +4.828 | 87 | 341.1 | 220.002 | 0.154368 | 0.0750522 | 0.000226098
MULLION TOP PLATE | PL/561 | +4.602 | +4.781 | 87 | 339.7 | 220.002 | 0.153768 | 0.0747246 | 0.000225094
MULLION TOP PLATE | PL/562 | +4.602 | +4.790 | 87 | 340.7 | 220.002 | 0.154193 | 0.0749579 | 0.000225812
MULLION TOP PLATE | PL/585 | +4.976 | +5.151 | 87.2 | 335.2 | 220.002 | 0.151923 | 0.073741 | 0.000221938
MULLION TOP PLATE | PL/586 | +4.976 | +5.228 | 86.8 | 345 | 220.002 | 0.15589 | 0.0758929 | 0.000228561
MULLION TOP PLATE | PL/581 | +4.848 | +5.025 | 87.2 | 337 | 220.002 | 0.15267 | 0.0741307 | 0.000223198
MULLION TOP PLATE | PL/582 | +4.848 | +5.081 | 86.8 | 343.7 | 220.002 | 0.155382 | 0.0756092 | 0.000227747
MULLION TOP PLATE | PL/459 | +4.741 | +4.948 | 87 | 341.9 | 220.002 | 0.154695 | 0.0752303 | 0.000226632
MULLION TOP PLATE | PL/460 | +4.741 | +4.920 | 87.2 | 338.7 | 220.002 | 0.153396 | 0.0745189 | 0.000224444
MULLION TOP PLATE | PL/455 | +4.675 | +4.869 | 87 | 341.1 | 220.002 | 0.154367 | 0.0750519 | 0.000226097
MULLION TOP PLATE | PL/456 | +4.675 | +4.854 | 87 | 339.4 | 220.002 | 0.153656 | 0.0746621 | 0.000224897
MULLION TOP PLATE | PL/451 | +4.642 | +4.831 | 87 | 340.7 | 220.002 | 0.154194 | 0.0749586 | 0.000225814
MULLION TOP PLATE | PL/452 | +4.642 | +4.821 | 87 | 339.7 | 220.002 | 0.153768 | 0.0747245 | 0.000225094
MULLION TOP PLATE | PL/475 | +5.031 | +5.283 | 86.8 | 345.1 | 220.002 | 0.155962 | 0.0759249 | 0.000228697
MULLION TOP PLATE | PL/476 | +5.031 | +5.206 | 87.2 | 336.3 | 220.002 | 0.152472 | 0.0739928 | 0.000222905
MULLION TOP PLATE | PL/471 | +4.898 | +5.130 | 86.8 | 343.7 | 220.002 | 0.155381 | 0.0756088 | 0.000227746
MULLION TOP PLATE | PL/472 | +4.898 | +5.075 | 87.2 | 337 | 220.002 | 0.152674 | 0.0741328 | 0.000223204
MULLION TOP PLATE | PL/467 | +4.844 | +5.068 | 86.8 | 343.1 | 220.002 | 0.15516 | 0.0754864 | 0.000227389
MULLION TOP PLATE | PL/468 | +4.844 | +5.022 | 87.2 | 337.6 | 220.002 | 0.152937 | 0.074272 | 0.000223653
MULLION TOP PLATE | PL/458 | +4.741 | +4.948 | 87 | 341.9 | 220.002 | 0.154695 | 0.0752303 | 0.000226632
MULLION TOP PLATE | PL/457 | +4.741 | +4.920 | 87.2 | 338.7 | 220.002 | 0.153396 | 0.0745189 | 0.000224444
MULLION TOP PLATE | PL/454 | +4.675 | +4.869 | 87 | 341.1 | 220.002 | 0.154367 | 0.0750519 | 0.000226097
MULLION TOP PLATE | PL/453 | +4.675 | +4.854 | 87 | 339.4 | 220.002 | 0.153656 | 0.0746621 | 0.000224897
MULLION TOP PLATE | PL/450 | +4.642 | +4.831 | 87 | 340.7 | 220.002 | 0.154194 | 0.0749586 | 0.000225814
MULLION TOP PLATE | PL/449 | +4.642 | +4.821 | 87 | 339.7 | 220.002 | 0.153768 | 0.0747245 | 0.000225094
MULLION TOP PLATE | PL/474 | +5.031 | +5.283 | 86.8 | 345.1 | 220.002 | 0.155962 | 0.0759249 | 0.000228697
MULLION TOP PLATE | PL/473 | +5.031 | +5.206 | 87.2 | 336.3 | 220.002 | 0.152472 | 0.0739928 | 0.000222905
MULLION TOP PLATE | PL/470 | +4.898 | +5.130 | 86.8 | 343.7 | 220.002 | 0.155381 | 0.0756088 | 0.000227746
MULLION TOP PLATE | PL/469 | +4.898 | +5.075 | 87.2 | 337 | 220.002 | 0.152674 | 0.0741328 | 0.000223204
MULLION TOP PLATE | PL/347 | +4.781 | +4.988 | 87 | 341.9 | 220.002 | 0.1547 | 0.075233 | 0.00022664
MULLION TOP PLATE | PL/348 | +4.781 | +4.960 | 87.2 | 338.7 | 220.002 | 0.1534 | 0.0745209 | 0.00022445
MULLION TOP PLATE | PL/343 | +4.712 | +4.907 | 87 | 341.1 | 220.002 | 0.15437 | 0.0750532 | 0.0002261
MULLION TOP PLATE | PL/344 | +4.712 | +4.892 | 87 | 339.4 | 220.002 | 0.153656 | 0.0746618 | 0.000224897
MULLION TOP PLATE | PL/339 | +4.678 | +4.867 | 87 | 340.7 | 220.002 | 0.154196 | 0.0749594 | 0.000225817
MULLION TOP PLATE | PL/340 | +4.678 | +4.858 | 87 | 339.7 | 220.002 | 0.153775 | 0.074728 | 0.000225105
MULLION TOP PLATE | PL/363 | +5.081 | +5.333 | 86.8 | 345 | 220.002 | 0.155891 | 0.0758932 | 0.000228562
MULLION TOP PLATE | PL/364 | +5.081 | +5.256 | 87.2 | 335.2 | 220.002 | 0.151933 | 0.073746 | 0.000221953
MULLION TOP PLATE | PL/359 | +4.943 | +5.176 | 86.8 | 343.7 | 220.002 | 0.155387 | 0.0756117 | 0.000227754
MULLION TOP PLATE | PL/360 | +4.943 | +5.120 | 87.2 | 337 | 220.002 | 0.152676 | 0.0741337 | 0.000223207
MULLION TOP PLATE | PL/355 | +4.889 | +5.112 | 86.8 | 342.3 | 220.002 | 0.15473 | 0.0752743 | 0.000226753
MULLION TOP PLATE | PL/356 | +4.889 | +5.065 | 87.2 | 336.6 | 220.002 | 0.152509 | 0.0740611 | 0.00022302
MULLION TOP PLATE | PL/346 | +4.781 | +4.988 | 87 | 341.9 | 220.002 | 0.1547 | 0.075233 | 0.00022664
MULLION TOP PLATE | PL/345 | +4.781 | +4.960 | 87.2 | 338.7 | 220.002 | 0.1534 | 0.0745209 | 0.00022445
MULLION TOP PLATE | PL/342 | +4.712 | +4.907 | 87 | 341.1 | 220.002 | 0.15437 | 0.0750532 | 0.0002261
MULLION TOP PLATE | PL/341 | +4.712 | +4.892 | 87 | 339.4 | 220.002 | 0.153656 | 0.0746618 | 0.000224897
MULLION TOP PLATE | PL/338 | +4.678 | +4.867 | 87 | 340.7 | 220.002 | 0.154196 | 0.0749594 | 0.000225817
MULLION TOP PLATE | PL/337 | +4.678 | +4.858 | 87 | 339.7 | 220.002 | 0.153775 | 0.074728 | 0.000225105
MULLION TOP PLATE | PL/362 | +5.081 | +5.333 | 86.8 | 345 | 220.002 | 0.155891 | 0.0758932 | 0.000228562
MULLION TOP PLATE | PL/361 | +5.081 | +5.256 | 87.2 | 335.2 | 220.002 | 0.151933 | 0.073746 | 0.000221953
MULLION TOP PLATE | PL/358 | +4.943 | +5.176 | 86.8 | 343.7 | 220.002 | 0.155387 | 0.0756117 | 0.000227754
MULLION TOP PLATE | PL/357 | +4.943 | +5.120 | 87.2 | 337 | 220.002 | 0.152676 | 0.0741337 | 0.000223207
MULLION TOP PLATE | PL/348 | +4.827 | +5.005 | 87.2 | 338.7 | 220.002 | 0.153399 | 0.0745205 | 0.000224448
MULLION TOP PLATE | PL/347 | +4.827 | +5.033 | 87 | 341.9 | 220.002 | 0.154695 | 0.0752304 | 0.000226632
MULLION TOP PLATE | PL/344 | +4.754 | +4.933 | 87 | 339.4 | 220.002 | 0.153655 | 0.0746613 | 0.000224895
MULLION TOP PLATE | PL/343 | +4.754 | +4.949 | 87 | 341.1 | 220.002 | 0.154367 | 0.075052 | 0.000226097
MULLION TOP PLATE | PL/340 | +4.718 | +4.898 | 87 | 339.7 | 220.002 | 0.15377 | 0.0747257 | 0.000225098
MULLION TOP PLATE | PL/339 | +4.718 | +4.907 | 87 | 340.7 | 220.002 | 0.154194 | 0.0749583 | 0.000225813
MULLION TOP PLATE | PL/364 | +5.137 | +5.312 | 87.2 | 335.2 | 220.002 | 0.151926 | 0.0737429 | 0.000221944
MULLION TOP PLATE | PL/363 | +5.137 | +5.389 | 86.8 | 345 | 220.002 | 0.155889 | 0.0758923 | 0.000228559
MULLION TOP PLATE | PL/360 | +4.994 | +5.171 | 87.2 | 337 | 220.002 | 0.152671 | 0.0741311 | 0.000223199
MULLION TOP PLATE | PL/359 | +4.994 | +5.227 | 86.8 | 343.7 | 220.002 | 0.15538 | 0.0756082 | 0.000227744
MULLION TOP PLATE | PL/356 | +4.937 | +5.114 | 87.2 | 337.6 | 220.002 | 0.152936 | 0.0742717 | 0.000223652
MULLION TOP PLATE | PL/355 | +4.937 | +5.161 | 86.8 | 343.1 | 220.002 | 0.155159 | 0.0754857 | 0.000227387
MULLION TOP PLATE | PL/345 | +4.827 | +5.005 | 87.2 | 338.7 | 220.002 | 0.153399 | 0.0745205 | 0.000224448
MULLION TOP PLATE | PL/346 | +4.827 | +5.033 | 87 | 341.9 | 220.002 | 0.154695 | 0.0752304 | 0.000226632
MULLION TOP PLATE | PL/341 | +4.754 | +4.933 | 87 | 339.4 | 220.002 | 0.153655 | 0.0746613 | 0.000224895
MULLION TOP PLATE | PL/342 | +4.754 | +4.949 | 87 | 341.1 | 220.002 | 0.154367 | 0.075052 | 0.000226097
MULLION TOP PLATE | PL/337 | +4.718 | +4.898 | 87 | 339.7 | 220.002 | 0.15377 | 0.0747257 | 0.000225098
MULLION TOP PLATE | PL/338 | +4.718 | +4.907 | 87 | 340.7 | 220.002 | 0.154194 | 0.0749583 | 0.000225813
MULLION TOP PLATE | PL/361 | +5.137 | +5.312 | 87.2 | 335.2 | 220.002 | 0.151926 | 0.0737429 | 0.000221944
MULLION TOP PLATE | PL/362 | +5.137 | +5.389 | 86.8 | 345 | 220.002 | 0.155889 | 0.0758923 | 0.000228559
MULLION TOP PLATE | PL/357 | +4.994 | +5.171 | 87.2 | 337 | 220.002 | 0.152671 | 0.0741311 | 0.000223199
MULLION TOP PLATE | PL/358 | +4.994 | +5.227 | 86.8 | 343.7 | 220.002 | 0.15538 | 0.0756082 | 0.000227744
MULLION TOP PLATE | PL/577 | +4.796 | +4.974 | 87.2 | 337.6 | 220.002 | 0.152937 | 0.0742721 | 0.000223653
MULLION TOP PLATE | PL/578 | +4.796 | +5.021 | 86.8 | 343.1 | 220.002 | 0.155159 | 0.0754855 | 0.000227387
MULLION TOP PLATE | PL/354 | +4.889 | +5.112 | 86.8 | 342.3 | 220.002 | 0.15473 | 0.0752743 | 0.000226753
MULLION TOP PLATE | PL/353 | +4.889 | +5.065 | 87.2 | 336.6 | 220.002 | 0.152509 | 0.0740611 | 0.00022302
MULLION TOP PLATE | PL/353 | +4.937 | +5.114 | 87.2 | 337.6 | 220.002 | 0.152936 | 0.0742717 | 0.000223652
MULLION TOP PLATE | PL/354 | +4.937 | +5.161 | 86.8 | 343.1 | 220.002 | 0.155159 | 0.0754857 | 0.000227387
MULLION TOP PLATE | PL/466 | +4.844 | +5.068 | 86.8 | 343.1 | 220.002 | 0.15516 | 0.0754864 | 0.000227389
MULLION TOP PLATE | PL/465 | +4.844 | +5.022 | 87.2 | 337.6 | 220.002 | 0.152937 | 0.074272 | 0.000223653
MULLION TOP PLATE | PL/463 | +4.792 | +5.008 | 86.8 | 342.5 | 220.002 | 0.154935 | 0.0753617 | 0.000227023
MULLION TOP PLATE | PL/464 | +4.792 | +4.970 | 87.2 | 338.2 | 220.002 | 0.153178 | 0.0744012 | 0.000224068
MULLION TOP PLATE | PL/352 | +4.834 | +5.012 | 87.2 | 338.2 | 220.008 | 0.153181 | 0.0744043 | 0.000224071
MULLION TOP PLATE | PL/351 | +4.834 | +5.049 | 86.8 | 342.6 | 220.008 | 0.154936 | 0.0753645 | 0.000227025
MULLION TOP PLATE | PL/575 | +4.746 | +4.962 | 86.8 | 342.5 | 220.008 | 0.154934 | 0.0753635 | 0.000227022
MULLION TOP PLATE | PL/576 | +4.746 | +4.924 | 87.2 | 338.2 | 220.008 | 0.153178 | 0.0744029 | 0.000224067
MULLION TOP PLATE | PL/351 | +4.881 | +5.096 | 86.8 | 342.6 | 220.008 | 0.154935 | 0.075364 | 0.000227023
MULLION TOP PLATE | PL/352 | +4.881 | +5.059 | 87.2 | 338.2 | 220.008 | 0.153181 | 0.0744045 | 0.000224072
MULLION TOP PLATE | PL/462 | +4.792 | +5.008 | 86.8 | 342.5 | 220.002 | 0.154935 | 0.0753617 | 0.000227023
MULLION TOP PLATE | PL/461 | +4.792 | +4.970 | 87.2 | 338.2 | 220.002 | 0.153178 | 0.0744012 | 0.000224068
MULLION TOP PLATE | PL/349 | +4.834 | +5.012 | 87.2 | 338.2 | 220.008 | 0.153181 | 0.0744043 | 0.000224071
MULLION TOP PLATE | PL/350 | +4.834 | +5.049 | 86.8 | 342.6 | 220.008 | 0.154936 | 0.0753645 | 0.000227025
MULLION TOP PLATE | PL/574 | +4.746 | +4.962 | 86.8 | 342.5 | 220.008 | 0.154934 | 0.0753635 | 0.000227022
MULLION TOP PLATE | PL/573 | +4.746 | +4.924 | 87.2 | 338.2 | 220.008 | 0.153178 | 0.0744029 | 0.000224067
MULLION TOP PLATE | PL/350 | +4.881 | +5.096 | 86.8 | 342.6 | 220.008 | 0.154935 | 0.075364 | 0.000227023
MULLION TOP PLATE | PL/349 | +4.881 | +5.059 | 87.2 | 338.2 | 220.008 | 0.153181 | 0.0744045 | 0.000224072

# IfcPlate: PLT3*270 (112)
In: Undefined
Description: PLT3*270; Material: STEEL/450
Tekla Common - Phase: 1; Class: 3
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.2 m2; Height: 270 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Length (mm) | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
MULLION TOP PLATE | PL/600 | +4.807 | +4.985 | 2.2 | 86.8 | 338.7 | 270.002 | 0.187793 | 0.0914543 | 0.000275452
MULLION TOP PLATE | PL/599 | +4.807 | +5.013 | 2.2 | 86.7 | 342.1 | 270.002 | 0.189437 | 0.0923545 | 0.000278219
MULLION TOP PLATE | PL/596 | +4.694 | +4.873 | 2.2 | 86.8 | 339.4 | 270.002 | 0.188108 | 0.091628 | 0.000276002
MULLION TOP PLATE | PL/595 | +4.694 | +4.889 | 2.2 | 86.8 | 341.2 | 270.002 | 0.189011 | 0.092123 | 0.000277524
MULLION TOP PLATE | PL/592 | +4.638 | +4.817 | 2.2 | 86.8 | 339.6 | 270.002 | 0.188246 | 0.0917056 | 0.000276247
MULLION TOP PLATE | PL/591 | +4.638 | +4.827 | 2.2 | 86.8 | 340.7 | 270.002 | 0.188789 | 0.0920028 | 0.00027716
MULLION TOP PLATE | PL/616 | +5.298 | +5.473 | 2.1 | 87 | 335.2 | 270.002 | 0.185991 | 0.0904997 | 0.000272377
MULLION TOP PLATE | PL/615 | +5.298 | +5.550 | 2.2 | 86.7 | 345.2 | 270.002 | 0.190999 | 0.0932162 | 0.000280732
MULLION TOP PLATE | PL/612 | +5.072 | +5.249 | 2.2 | 86.8 | 337 | 270.002 | 0.186912 | 0.0909809 | 0.000273931
MULLION TOP PLATE | PL/611 | +5.072 | +5.305 | 2.2 | 86.7 | 343.9 | 270.002 | 0.190333 | 0.0928466 | 0.000279668
MULLION TOP PLATE | PL/608 | +4.981 | +5.159 | 2.2 | 86.8 | 337.6 | 270.002 | 0.187234 | 0.0911522 | 0.000274484
MULLION TOP PLATE | PL/607 | +4.981 | +5.206 | 2.2 | 86.7 | 343.3 | 270.008 | 0.190041 | 0.0926871 | 0.000279197
MULLION TOP PLATE | PL/597 | +4.807 | +4.985 | 2.2 | 86.8 | 338.7 | 270.002 | 0.187793 | 0.0914543 | 0.000275452
MULLION TOP PLATE | PL/598 | +4.807 | +5.013 | 2.2 | 86.7 | 342.1 | 270.002 | 0.189437 | 0.0923545 | 0.000278219
MULLION TOP PLATE | PL/593 | +4.694 | +4.873 | 2.2 | 86.8 | 339.4 | 270.002 | 0.188108 | 0.091628 | 0.000276002
MULLION TOP PLATE | PL/594 | +4.694 | +4.889 | 2.2 | 86.8 | 341.2 | 270.002 | 0.189011 | 0.092123 | 0.000277524
MULLION TOP PLATE | PL/589 | +4.638 | +4.817 | 2.2 | 86.8 | 339.6 | 270.002 | 0.188246 | 0.0917056 | 0.000276247
MULLION TOP PLATE | PL/590 | +4.638 | +4.827 | 2.2 | 86.8 | 340.7 | 270.002 | 0.188789 | 0.0920028 | 0.00027716
MULLION TOP PLATE | PL/613 | +5.298 | +5.473 | 2.1 | 87 | 335.2 | 270.002 | 0.185991 | 0.0904997 | 0.000272377
MULLION TOP PLATE | PL/614 | +5.298 | +5.550 | 2.2 | 86.7 | 345.2 | 270.002 | 0.190999 | 0.0932162 | 0.000280732
MULLION TOP PLATE | PL/609 | +5.072 | +5.249 | 2.2 | 86.8 | 337 | 270.002 | 0.186912 | 0.0909809 | 0.000273931
MULLION TOP PLATE | PL/610 | +5.072 | +5.305 | 2.2 | 86.7 | 343.9 | 270.002 | 0.190333 | 0.0928466 | 0.000279668
MULLION TOP PLATE | PL/487 | +4.851 | +5.057 | 2.2 | 86.7 | 342.1 | 270.002 | 0.189439 | 0.0923552 | 0.000278221
MULLION TOP PLATE | PL/488 | +4.851 | +5.029 | 2.2 | 86.8 | 338.7 | 270.002 | 0.187795 | 0.0914552 | 0.000275455
MULLION TOP PLATE | PL/483 | +4.735 | +4.930 | 2.2 | 86.8 | 341.2 | 270.002 | 0.18901 | 0.0921226 | 0.000277523
MULLION TOP PLATE | PL/484 | +4.735 | +4.914 | 2.2 | 86.8 | 339.4 | 270.002 | 0.188107 | 0.0916274 | 0.000276001
MULLION TOP PLATE | PL/480 | +4.678 | +4.857 | 2.2 | 86.8 | 339.7 | 270.008 | 0.188252 | 0.0917101 | 0.000276254
MULLION TOP PLATE | PL/479 | +4.678 | +4.867 | 2.2 | 86.8 | 340.7 | 270.008 | 0.18879 | 0.0920056 | 0.000277163
MULLION TOP PLATE | PL/503 | +5.352 | +5.605 | 2.2 | 86.7 | 345.4 | 270.002 | 0.191087 | 0.0932555 | 0.000280898
MULLION TOP PLATE | PL/504 | +5.352 | +5.528 | 2.1 | 86.8 | 336.3 | 270.002 | 0.186662 | 0.0908088 | 0.000273563
MULLION TOP PLATE | PL/499 | +5.122 | +5.355 | 2.2 | 86.7 | 343.9 | 270.002 | 0.190338 | 0.0928487 | 0.000279675
MULLION TOP PLATE | PL/500 | +5.122 | +5.299 | 2.2 | 86.8 | 337 | 270.002 | 0.186911 | 0.0909807 | 0.000273931
MULLION TOP PLATE | PL/495 | +5.029 | +5.253 | 2.2 | 86.7 | 343.3 | 270.002 | 0.190043 | 0.0926863 | 0.0002792
MULLION TOP PLATE | PL/496 | +5.029 | +5.207 | 2.2 | 86.8 | 337.6 | 270.002 | 0.187239 | 0.0911548 | 0.000274492
MULLION TOP PLATE | PL/486 | +4.851 | +5.057 | 2.2 | 86.7 | 342.1 | 270.002 | 0.189439 | 0.0923552 | 0.000278221
MULLION TOP PLATE | PL/485 | +4.851 | +5.029 | 2.2 | 86.8 | 338.7 | 270.002 | 0.187795 | 0.0914552 | 0.000275454
MULLION TOP PLATE | PL/482 | +4.735 | +4.930 | 2.2 | 86.8 | 341.2 | 270.002 | 0.18901 | 0.0921226 | 0.000277523
MULLION TOP PLATE | PL/481 | +4.735 | +4.914 | 2.2 | 86.8 | 339.4 | 270.002 | 0.188107 | 0.0916274 | 0.000276001
MULLION TOP PLATE | PL/477 | +4.678 | +4.857 | 2.2 | 86.8 | 339.7 | 270.008 | 0.188252 | 0.0917101 | 0.000276254
MULLION TOP PLATE | PL/478 | +4.678 | +4.867 | 2.2 | 86.8 | 340.7 | 270.008 | 0.18879 | 0.0920056 | 0.000277163
MULLION TOP PLATE | PL/502 | +5.352 | +5.605 | 2.2 | 86.7 | 345.4 | 270.002 | 0.191087 | 0.0932555 | 0.000280898
MULLION TOP PLATE | PL/501 | +5.352 | +5.528 | 2.1 | 86.8 | 336.3 | 270.002 | 0.186662 | 0.0908088 | 0.000273563
MULLION TOP PLATE | PL/498 | +5.122 | +5.355 | 2.2 | 86.7 | 343.9 | 270.002 | 0.190338 | 0.0928487 | 0.000279675
MULLION TOP PLATE | PL/497 | +5.122 | +5.299 | 2.2 | 86.8 | 337 | 270.002 | 0.186911 | 0.0909807 | 0.000273931
MULLION TOP PLATE | PL/375 | +4.891 | +5.097 | 2.2 | 86.7 | 342.1 | 270.002 | 0.18944 | 0.0923557 | 0.000278222
MULLION TOP PLATE | PL/376 | +4.891 | +5.069 | 2.2 | 86.8 | 338.7 | 270.002 | 0.187795 | 0.0914551 | 0.000275454
MULLION TOP PLATE | PL/371 | +4.773 | +4.968 | 2.2 | 86.8 | 341.2 | 270.002 | 0.189014 | 0.0921242 | 0.000277528
MULLION TOP PLATE | PL/372 | +4.773 | +4.952 | 2.2 | 86.8 | 339.4 | 270.002 | 0.188112 | 0.0916297 | 0.000276008
MULLION TOP PLATE | PL/367 | +4.714 | +4.903 | 2.2 | 86.8 | 340.7 | 270.002 | 0.188787 | 0.092002 | 0.000277158
MULLION TOP PLATE | PL/368 | +4.714 | +4.894 | 2.2 | 86.8 | 339.7 | 270.002 | 0.188255 | 0.0917098 | 0.000276259
MULLION TOP PLATE | PL/391 | +5.402 | +5.655 | 2.2 | 86.7 | 345.2 | 270.002 | 0.191005 | 0.0932192 | 0.000280741
MULLION TOP PLATE | PL/392 | +5.402 | +5.577 | 2.1 | 87 | 335.2 | 270.002 | 0.186003 | 0.0905058 | 0.000272395
MULLION TOP PLATE | PL/387 | +5.167 | +5.400 | 2.2 | 86.7 | 343.9 | 270.002 | 0.190334 | 0.0928469 | 0.000279669
MULLION TOP PLATE | PL/388 | +5.167 | +5.344 | 2.2 | 86.8 | 337 | 270.002 | 0.186913 | 0.0909818 | 0.000273934
MULLION TOP PLATE | PL/383 | +5.074 | +5.297 | 2.2 | 86.7 | 342.3 | 270.002 | 0.189511 | 0.0924232 | 0.000278411
MULLION TOP PLATE | PL/384 | +5.074 | +5.250 | 2.1 | 86.8 | 336.6 | 270.002 | 0.186705 | 0.0908905 | 0.000273699
MULLION TOP PLATE | PL/374 | +4.891 | +5.097 | 2.2 | 86.7 | 342.1 | 270.002 | 0.18944 | 0.0923557 | 0.000278222
MULLION TOP PLATE | PL/373 | +4.891 | +5.069 | 2.2 | 86.8 | 338.7 | 270.002 | 0.187795 | 0.0914551 | 0.000275454
MULLION TOP PLATE | PL/370 | +4.773 | +4.968 | 2.2 | 86.8 | 341.2 | 270.002 | 0.189014 | 0.0921242 | 0.000277528
MULLION TOP PLATE | PL/369 | +4.773 | +4.952 | 2.2 | 86.8 | 339.4 | 270.002 | 0.188112 | 0.0916297 | 0.000276008
MULLION TOP PLATE | PL/366 | +4.714 | +4.903 | 2.2 | 86.8 | 340.7 | 270.002 | 0.188787 | 0.092002 | 0.000277158
MULLION TOP PLATE | PL/365 | +4.714 | +4.894 | 2.2 | 86.8 | 339.7 | 270.002 | 0.188255 | 0.0917098 | 0.000276259
MULLION TOP PLATE | PL/390 | +5.402 | +5.655 | 2.2 | 86.7 | 345.2 | 270.002 | 0.191005 | 0.0932192 | 0.000280741
MULLION TOP PLATE | PL/389 | +5.402 | +5.577 | 2.1 | 87 | 335.2 | 270.002 | 0.186003 | 0.0905058 | 0.000272395
MULLION TOP PLATE | PL/386 | +5.167 | +5.400 | 2.2 | 86.7 | 343.9 | 270.002 | 0.190334 | 0.0928469 | 0.000279669
MULLION TOP PLATE | PL/385 | +5.167 | +5.344 | 2.2 | 86.8 | 337 | 270.002 | 0.186913 | 0.0909818 | 0.000273934
MULLION TOP PLATE | PL/375 | +4.936 | +5.143 | 2.2 | 86.7 | 341.9 | 270.002 | 0.189435 | 0.0923531 | 0.000278215
MULLION TOP PLATE | PL/376 | +4.936 | +5.115 | 2.2 | 86.8 | 338.7 | 270.002 | 0.187802 | 0.0914587 | 0.000275465
MULLION TOP PLATE | PL/371 | +4.814 | +5.009 | 2.2 | 86.8 | 341.2 | 270.002 | 0.189012 | 0.0921234 | 0.000277525
MULLION TOP PLATE | PL/372 | +4.814 | +4.994 | 2.2 | 86.8 | 339.4 | 270.002 | 0.188114 | 0.0916307 | 0.00027601
MULLION TOP PLATE | PL/367 | +4.754 | +4.943 | 2.2 | 86.8 | 340.7 | 270.002 | 0.188785 | 0.0920012 | 0.000277155
MULLION TOP PLATE | PL/368 | +4.754 | +4.934 | 2.2 | 86.8 | 339.7 | 270.002 | 0.188252 | 0.0917085 | 0.000276255
MULLION TOP PLATE | PL/391 | +5.458 | +5.711 | 2.2 | 86.7 | 345.2 | 270.002 | 0.190999 | 0.093216 | 0.000280731
MULLION TOP PLATE | PL/392 | +5.458 | +5.633 | 2.1 | 87 | 335.2 | 270.002 | 0.185999 | 0.0905038 | 0.000272389
MULLION TOP PLATE | PL/387 | +5.218 | +5.451 | 2.2 | 86.7 | 343.9 | 270.002 | 0.190337 | 0.0928486 | 0.000279674
MULLION TOP PLATE | PL/388 | +5.218 | +5.395 | 2.2 | 86.8 | 337 | 270.002 | 0.186916 | 0.0909829 | 0.000273937
MULLION TOP PLATE | PL/383 | +5.121 | +5.346 | 2.2 | 86.7 | 343.3 | 270.002 | 0.190042 | 0.0926859 | 0.000279199
MULLION TOP PLATE | PL/384 | +5.121 | +5.299 | 2.2 | 86.8 | 337.6 | 270.002 | 0.187241 | 0.0911559 | 0.000274495
MULLION TOP PLATE | PL/374 | +4.936 | +5.143 | 2.2 | 86.7 | 341.9 | 270.002 | 0.189435 | 0.0923531 | 0.000278215
MULLION TOP PLATE | PL/373 | +4.936 | +5.115 | 2.2 | 86.8 | 338.7 | 270.002 | 0.187802 | 0.0914587 | 0.000275465
MULLION TOP PLATE | PL/370 | +4.814 | +5.009 | 2.2 | 86.8 | 341.2 | 270.002 | 0.189012 | 0.0921234 | 0.000277525
MULLION TOP PLATE | PL/369 | +4.814 | +4.994 | 2.2 | 86.8 | 339.4 | 270.002 | 0.188114 | 0.0916307 | 0.00027601
MULLION TOP PLATE | PL/366 | +4.754 | +4.943 | 2.2 | 86.8 | 340.7 | 270.002 | 0.188785 | 0.0920012 | 0.000277155
MULLION TOP PLATE | PL/365 | +4.754 | +4.934 | 2.2 | 86.8 | 339.7 | 270.002 | 0.188252 | 0.0917085 | 0.000276255
MULLION TOP PLATE | PL/390 | +5.458 | +5.711 | 2.2 | 86.7 | 345.2 | 270.002 | 0.190999 | 0.093216 | 0.000280731
MULLION TOP PLATE | PL/389 | +5.458 | +5.633 | 2.1 | 87 | 335.2 | 270.002 | 0.185999 | 0.0905038 | 0.000272389
MULLION TOP PLATE | PL/386 | +5.218 | +5.451 | 2.2 | 86.7 | 343.9 | 270.002 | 0.190337 | 0.0928486 | 0.000279674
MULLION TOP PLATE | PL/385 | +5.218 | +5.395 | 2.2 | 86.8 | 337 | 270.002 | 0.186916 | 0.0909829 | 0.000273937
MULLION TOP PLATE | PL/605 | +4.981 | +5.159 | 2.2 | 86.8 | 337.6 | 270.002 | 0.187234 | 0.0911522 | 0.000274484
MULLION TOP PLATE | PL/494 | +5.029 | +5.253 | 2.2 | 86.7 | 343.3 | 270.002 | 0.190043 | 0.0926863 | 0.0002792
MULLION TOP PLATE | PL/382 | +5.074 | +5.297 | 2.2 | 86.7 | 342.3 | 270.002 | 0.189511 | 0.0924232 | 0.000278411
MULLION TOP PLATE | PL/381 | +5.074 | +5.250 | 2.1 | 86.8 | 336.6 | 270.002 | 0.186705 | 0.0908905 | 0.000273699
MULLION TOP PLATE | PL/382 | +5.121 | +5.346 | 2.2 | 86.7 | 343.3 | 270.002 | 0.190042 | 0.0926859 | 0.000279199
MULLION TOP PLATE | PL/381 | +5.121 | +5.299 | 2.2 | 86.8 | 337.6 | 270.002 | 0.187241 | 0.0911559 | 0.000274495
MULLION TOP PLATE | PL/606 | +4.981 | +5.206 | 2.2 | 86.7 | 343.3 | 270.008 | 0.190041 | 0.0926871 | 0.000279197
MULLION TOP PLATE | PL/493 | +5.029 | +5.207 | 2.2 | 86.8 | 337.6 | 270.002 | 0.187239 | 0.0911548 | 0.000274492
MULLION TOP PLATE | PL/603 | +4.893 | +5.109 | 2.2 | 86.7 | 342.7 | 270.008 | 0.189749 | 0.0925266 | 0.000278724
MULLION TOP PLATE | PL/604 | +4.893 | +5.071 | 2.2 | 86.8 | 338.2 | 270.008 | 0.18753 | 0.0913133 | 0.000274995
MULLION TOP PLATE | PL/379 | +4.981 | +5.196 | 2.2 | 86.7 | 342.7 | 270.008 | 0.189752 | 0.0925279 | 0.000278728
MULLION TOP PLATE | PL/380 | +4.981 | +5.159 | 2.2 | 86.8 | 338.2 | 270.008 | 0.187534 | 0.091315 | 0.000275
MULLION TOP PLATE | PL/379 | +5.027 | +5.243 | 2.2 | 86.7 | 342.7 | 270.008 | 0.189746 | 0.092525 | 0.00027872
MULLION TOP PLATE | PL/380 | +5.027 | +5.205 | 2.2 | 86.8 | 338.2 | 270.008 | 0.187532 | 0.091314 | 0.000274997
MULLION TOP PLATE | PL/492 | +4.939 | +5.117 | 2.2 | 86.8 | 338.2 | 270.002 | 0.187531 | 0.0913116 | 0.000274995
MULLION TOP PLATE | PL/491 | +4.939 | +5.154 | 2.2 | 86.7 | 342.7 | 270.008 | 0.18975 | 0.0925269 | 0.000278725
MULLION TOP PLATE | PL/602 | +4.893 | +5.109 | 2.2 | 86.7 | 342.7 | 270.008 | 0.189749 | 0.0925266 | 0.000278724
MULLION TOP PLATE | PL/601 | +4.893 | +5.071 | 2.2 | 86.8 | 338.2 | 270.008 | 0.18753 | 0.0913133 | 0.000274995
MULLION TOP PLATE | PL/378 | +4.981 | +5.196 | 2.2 | 86.7 | 342.7 | 270.008 | 0.189752 | 0.0925279 | 0.000278728
MULLION TOP PLATE | PL/377 | +4.981 | +5.159 | 2.2 | 86.8 | 338.2 | 270.008 | 0.187534 | 0.091315 | 0.000275
