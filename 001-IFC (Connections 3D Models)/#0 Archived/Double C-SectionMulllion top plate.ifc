Properties of the parts of a building model (IFC2X3), part 3 of 3

# IfcPlate: PLT3*270 (112)
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Length (mm) | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
MULLION TOP PLATE | PL/378 | +5.027 | +5.243 | 2.2 | 86.7 | 342.7 | 270.008 | 0.189746 | 0.092525 | 0.00027872
MULLION TOP PLATE | PL/377 | +5.027 | +5.205 | 2.2 | 86.8 | 338.2 | 270.008 | 0.187532 | 0.091314 | 0.000274997
MULLION TOP PLATE | PL/489 | +4.939 | +5.117 | 2.2 | 86.8 | 338.2 | 270.002 | 0.187531 | 0.0913116 | 0.000274995
MULLION TOP PLATE | PL/490 | +4.939 | +5.154 | 2.2 | 86.7 | 342.7 | 270.008 | 0.18975 | 0.0925269 | 0.000278725

# IfcPlate: PLT3*320 (112)
In: Undefined
Description: PLT3*320; Material: STEEL/450
Tekla Common - Phase: 1; Class: 3
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.2 m2; Height: 320 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Length (mm) | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
MULLION TOP PLATE | PL/628 | +4.915 | +5.094 | 2.6 | 86.7 | 338.7 | 320.002 | 0.222194 | 0.108391 | 0.000326464
MULLION TOP PLATE | PL/627 | +4.915 | +5.122 | 2.6 | 86.7 | 341.9 | 320.002 | 0.224133 | 0.109455 | 0.000329736
MULLION TOP PLATE | PL/624 | +4.754 | +4.933 | 2.6 | 86.7 | 339.4 | 320.002 | 0.222563 | 0.108595 | 0.000327111
MULLION TOP PLATE | PL/623 | +4.754 | +4.949 | 2.6 | 86.7 | 341.2 | 320.002 | 0.223627 | 0.10918 | 0.000328909
MULLION TOP PLATE | PL/620 | +4.674 | +4.853 | 2.6 | 86.7 | 339.6 | 320.002 | 0.222729 | 0.108689 | 0.000327405
MULLION TOP PLATE | PL/619 | +4.674 | +4.863 | 2.6 | 86.7 | 340.7 | 320.002 | 0.223364 | 0.109038 | 0.000328478
MULLION TOP PLATE | PL/644 | +5.617 | +5.792 | 2.5 | 86.8 | 335.2 | 320.002 | 0.220063 | 0.107261 | 0.000322822
MULLION TOP PLATE | PL/643 | +5.617 | +5.870 | 2.6 | 86.5 | 345.2 | 320.002 | 0.225982 | 0.110477 | 0.000332716
MULLION TOP PLATE | PL/640 | +5.295 | +5.472 | 2.5 | 86.8 | 337 | 320.002 | 0.221146 | 0.107828 | 0.000324655
MULLION TOP PLATE | PL/639 | +5.295 | +5.528 | 2.6 | 86.5 | 343.9 | 320.002 | 0.225192 | 0.110038 | 0.000331452
MULLION TOP PLATE | PL/636 | +5.165 | +5.342 | 2.6 | 86.7 | 337.6 | 320.002 | 0.221534 | 0.108034 | 0.00032532
MULLION TOP PLATE | PL/635 | +5.165 | +5.389 | 2.6 | 86.7 | 343.3 | 320.002 | 0.224847 | 0.109847 | 0.000330895
MULLION TOP PLATE | PL/625 | +4.915 | +5.094 | 2.6 | 86.7 | 338.7 | 320.002 | 0.222194 | 0.108391 | 0.000326464
MULLION TOP PLATE | PL/626 | +4.915 | +5.122 | 2.6 | 86.7 | 341.9 | 320.002 | 0.224133 | 0.109455 | 0.000329736
MULLION TOP PLATE | PL/621 | +4.754 | +4.933 | 2.6 | 86.7 | 339.4 | 320.002 | 0.222563 | 0.108595 | 0.000327111
MULLION TOP PLATE | PL/622 | +4.754 | +4.949 | 2.6 | 86.7 | 341.2 | 320.002 | 0.223627 | 0.10918 | 0.000328909
MULLION TOP PLATE | PL/617 | +4.674 | +4.853 | 2.6 | 86.7 | 339.6 | 320.002 | 0.222729 | 0.108689 | 0.000327405
MULLION TOP PLATE | PL/618 | +4.674 | +4.863 | 2.6 | 86.7 | 340.7 | 320.002 | 0.223364 | 0.109038 | 0.000328478
MULLION TOP PLATE | PL/641 | +5.617 | +5.792 | 2.5 | 86.8 | 335.2 | 320.002 | 0.220063 | 0.107261 | 0.000322822
MULLION TOP PLATE | PL/642 | +5.617 | +5.870 | 2.6 | 86.5 | 345.2 | 320.002 | 0.225982 | 0.110477 | 0.000332716
MULLION TOP PLATE | PL/637 | +5.295 | +5.472 | 2.5 | 86.8 | 337 | 320.002 | 0.221146 | 0.107828 | 0.000324655
MULLION TOP PLATE | PL/638 | +5.295 | +5.528 | 2.6 | 86.5 | 343.9 | 320.002 | 0.225192 | 0.110038 | 0.000331452
MULLION TOP PLATE | PL/515 | +4.959 | +5.166 | 2.6 | 86.7 | 341.9 | 320.002 | 0.224133 | 0.109455 | 0.000329736
MULLION TOP PLATE | PL/516 | +4.959 | +5.138 | 2.6 | 86.7 | 338.7 | 320.002 | 0.22219 | 0.108389 | 0.000326458
MULLION TOP PLATE | PL/511 | +4.795 | +4.990 | 2.6 | 86.7 | 341.2 | 320.002 | 0.223638 | 0.109185 | 0.000328925
MULLION TOP PLATE | PL/512 | +4.795 | +4.974 | 2.6 | 86.7 | 339.4 | 320.002 | 0.222568 | 0.108598 | 0.000327119
MULLION TOP PLATE | PL/507 | +4.714 | +4.903 | 2.6 | 86.7 | 340.7 | 320.008 | 0.223364 | 0.10904 | 0.000328479
MULLION TOP PLATE | PL/508 | +4.714 | +4.893 | 2.6 | 86.7 | 339.7 | 320.008 | 0.222735 | 0.108694 | 0.000327414
MULLION TOP PLATE | PL/531 | +5.672 | +5.925 | 2.6 | 86.5 | 345.4 | 320.002 | 0.226084 | 0.110523 | 0.000332909
MULLION TOP PLATE | PL/532 | +5.672 | +5.848 | 2.5 | 86.8 | 336.3 | 320.002 | 0.220851 | 0.107624 | 0.000324218
MULLION TOP PLATE | PL/527 | +5.345 | +5.578 | 2.6 | 86.5 | 343.9 | 320.002 | 0.225195 | 0.11004 | 0.000331456
MULLION TOP PLATE | PL/528 | +5.345 | +5.521 | 2.5 | 86.8 | 337 | 320.002 | 0.221146 | 0.107828 | 0.000324654
MULLION TOP PLATE | PL/523 | +5.213 | +5.437 | 2.6 | 86.7 | 343.3 | 320.002 | 0.224854 | 0.109851 | 0.000330906
MULLION TOP PLATE | PL/524 | +5.213 | +5.390 | 2.6 | 86.7 | 337.6 | 320.002 | 0.221534 | 0.108034 | 0.00032532
MULLION TOP PLATE | PL/514 | +4.959 | +5.166 | 2.6 | 86.7 | 341.9 | 320.002 | 0.224133 | 0.109455 | 0.000329736
MULLION TOP PLATE | PL/513 | +4.959 | +5.138 | 2.6 | 86.7 | 338.7 | 320.002 | 0.22219 | 0.108389 | 0.000326458
MULLION TOP PLATE | PL/510 | +4.795 | +4.990 | 2.6 | 86.7 | 341.2 | 320.002 | 0.223638 | 0.109185 | 0.000328925
MULLION TOP PLATE | PL/509 | +4.795 | +4.974 | 2.6 | 86.7 | 339.4 | 320.002 | 0.222568 | 0.108598 | 0.000327119
MULLION TOP PLATE | PL/506 | +4.714 | +4.903 | 2.6 | 86.7 | 340.7 | 320.008 | 0.223364 | 0.10904 | 0.000328479
MULLION TOP PLATE | PL/505 | +4.714 | +4.893 | 2.6 | 86.7 | 339.7 | 320.008 | 0.222735 | 0.108694 | 0.000327414
MULLION TOP PLATE | PL/530 | +5.672 | +5.925 | 2.6 | 86.5 | 345.4 | 320.002 | 0.226084 | 0.110523 | 0.000332909
MULLION TOP PLATE | PL/529 | +5.672 | +5.848 | 2.5 | 86.8 | 336.3 | 320.002 | 0.220851 | 0.107624 | 0.000324218
MULLION TOP PLATE | PL/526 | +5.345 | +5.578 | 2.6 | 86.5 | 343.9 | 320.002 | 0.225195 | 0.11004 | 0.000331456
MULLION TOP PLATE | PL/525 | +5.345 | +5.521 | 2.5 | 86.8 | 337 | 320.002 | 0.221146 | 0.107828 | 0.000324654
MULLION TOP PLATE | PL/403 | +4.999 | +5.206 | 2.6 | 86.7 | 342.1 | 320.002 | 0.224141 | 0.109459 | 0.000329747
MULLION TOP PLATE | PL/404 | +4.999 | +5.178 | 2.6 | 86.7 | 338.7 | 320.002 | 0.222196 | 0.108392 | 0.000326467
MULLION TOP PLATE | PL/399 | +4.833 | +5.028 | 2.6 | 86.7 | 341.2 | 320.002 | 0.223635 | 0.109184 | 0.000328921
MULLION TOP PLATE | PL/400 | +4.833 | +5.012 | 2.6 | 86.7 | 339.4 | 320.002 | 0.222567 | 0.108597 | 0.000327118
MULLION TOP PLATE | PL/395 | +4.750 | +4.939 | 2.6 | 86.7 | 340.7 | 320.002 | 0.223373 | 0.109042 | 0.000328492
MULLION TOP PLATE | PL/396 | +4.750 | +4.930 | 2.6 | 86.7 | 339.7 | 320.002 | 0.222739 | 0.108694 | 0.00032742
MULLION TOP PLATE | PL/419 | +5.722 | +5.975 | 2.6 | 86.5 | 345.2 | 320.002 | 0.225987 | 0.11048 | 0.000332723
MULLION TOP PLATE | PL/420 | +5.722 | +5.897 | 2.5 | 86.8 | 335.2 | 320.002 | 0.220071 | 0.107265 | 0.000322834
MULLION TOP PLATE | PL/415 | +5.390 | +5.623 | 2.6 | 86.5 | 343.9 | 320.002 | 0.225203 | 0.110044 | 0.000331469
MULLION TOP PLATE | PL/416 | +5.390 | +5.567 | 2.5 | 86.8 | 337 | 320.002 | 0.221148 | 0.107829 | 0.000324658
MULLION TOP PLATE | PL/411 | +5.257 | +5.481 | 2.6 | 86.7 | 342.3 | 320.002 | 0.224225 | 0.109539 | 0.00032997
MULLION TOP PLATE | PL/412 | +5.257 | +5.434 | 2.5 | 86.8 | 336.6 | 320.002 | 0.220908 | 0.107724 | 0.00032439
MULLION TOP PLATE | PL/402 | +4.999 | +5.206 | 2.6 | 86.7 | 342.1 | 320.002 | 0.224141 | 0.109459 | 0.000329747
MULLION TOP PLATE | PL/401 | +4.999 | +5.178 | 2.6 | 86.7 | 338.7 | 320.002 | 0.222196 | 0.108392 | 0.000326467
MULLION TOP PLATE | PL/398 | +4.833 | +5.028 | 2.6 | 86.7 | 341.2 | 320.002 | 0.223635 | 0.109184 | 0.000328921
MULLION TOP PLATE | PL/397 | +4.833 | +5.012 | 2.6 | 86.7 | 339.4 | 320.002 | 0.222567 | 0.108597 | 0.000327118
MULLION TOP PLATE | PL/394 | +4.750 | +4.939 | 2.6 | 86.7 | 340.7 | 320.002 | 0.223373 | 0.109042 | 0.000328492
MULLION TOP PLATE | PL/393 | +4.750 | +4.930 | 2.6 | 86.7 | 339.7 | 320.002 | 0.222739 | 0.108694 | 0.00032742
MULLION TOP PLATE | PL/418 | +5.722 | +5.975 | 2.6 | 86.5 | 345.2 | 320.002 | 0.225987 | 0.11048 | 0.000332723
MULLION TOP PLATE | PL/417 | +5.722 | +5.897 | 2.5 | 86.8 | 335.2 | 320.002 | 0.220071 | 0.107265 | 0.000322834
MULLION TOP PLATE | PL/414 | +5.390 | +5.623 | 2.6 | 86.5 | 343.9 | 320.002 | 0.225203 | 0.110044 | 0.000331469
MULLION TOP PLATE | PL/413 | +5.390 | +5.567 | 2.5 | 86.8 | 337 | 320.002 | 0.221148 | 0.107829 | 0.000324658
MULLION TOP PLATE | PL/403 | +5.044 | +5.251 | 2.6 | 86.7 | 341.9 | 320.002 | 0.224132 | 0.109455 | 0.000329734
MULLION TOP PLATE | PL/404 | +5.044 | +5.223 | 2.6 | 86.7 | 338.7 | 320.002 | 0.222201 | 0.108395 | 0.000326475
MULLION TOP PLATE | PL/399 | +4.874 | +5.069 | 2.6 | 86.7 | 341.2 | 320.002 | 0.223624 | 0.109179 | 0.000328905
MULLION TOP PLATE | PL/400 | +4.874 | +5.054 | 2.6 | 86.7 | 339.4 | 320.002 | 0.22256 | 0.108594 | 0.000327107
MULLION TOP PLATE | PL/395 | +4.790 | +4.979 | 2.6 | 86.7 | 340.7 | 320.002 | 0.223369 | 0.10904 | 0.000328486
MULLION TOP PLATE | PL/396 | +4.790 | +4.970 | 2.6 | 86.7 | 339.7 | 320.002 | 0.222733 | 0.108691 | 0.000327411
MULLION TOP PLATE | PL/419 | +5.778 | +6.031 | 2.6 | 86.5 | 345.2 | 320.002 | 0.225983 | 0.110478 | 0.000332717
MULLION TOP PLATE | PL/420 | +5.778 | +5.953 | 2.5 | 86.8 | 335.2 | 320.002 | 0.220063 | 0.107261 | 0.000322822
MULLION TOP PLATE | PL/415 | +5.441 | +5.674 | 2.6 | 86.5 | 343.9 | 320.002 | 0.225192 | 0.110038 | 0.000331452
MULLION TOP PLATE | PL/416 | +5.441 | +5.618 | 2.5 | 86.8 | 337 | 320.002 | 0.221141 | 0.107825 | 0.000324648
MULLION TOP PLATE | PL/411 | +5.305 | +5.529 | 2.6 | 86.7 | 343.3 | 320.002 | 0.224851 | 0.109849 | 0.000330901
MULLION TOP PLATE | PL/412 | +5.305 | +5.483 | 2.6 | 86.7 | 337.6 | 320.002 | 0.221534 | 0.108034 | 0.00032532
MULLION TOP PLATE | PL/402 | +5.044 | +5.251 | 2.6 | 86.7 | 341.9 | 320.002 | 0.224132 | 0.109455 | 0.000329734
MULLION TOP PLATE | PL/401 | +5.044 | +5.223 | 2.6 | 86.7 | 338.7 | 320.002 | 0.222201 | 0.108395 | 0.000326475
MULLION TOP PLATE | PL/398 | +4.874 | +5.069 | 2.6 | 86.7 | 341.2 | 320.002 | 0.223624 | 0.109179 | 0.000328905
MULLION TOP PLATE | PL/397 | +4.874 | +5.054 | 2.6 | 86.7 | 339.4 | 320.002 | 0.22256 | 0.108594 | 0.000327107
MULLION TOP PLATE | PL/394 | +4.790 | +4.979 | 2.6 | 86.7 | 340.7 | 320.002 | 0.223369 | 0.10904 | 0.000328486
MULLION TOP PLATE | PL/393 | +4.790 | +4.970 | 2.6 | 86.7 | 339.7 | 320.002 | 0.222733 | 0.108691 | 0.000327411
MULLION TOP PLATE | PL/418 | +5.778 | +6.031 | 2.6 | 86.5 | 345.2 | 320.002 | 0.225983 | 0.110478 | 0.000332717
MULLION TOP PLATE | PL/417 | +5.778 | +5.953 | 2.5 | 86.8 | 335.2 | 320.002 | 0.220063 | 0.107261 | 0.000322822
MULLION TOP PLATE | PL/414 | +5.441 | +5.674 | 2.6 | 86.5 | 343.9 | 320.002 | 0.225192 | 0.110038 | 0.000331452
MULLION TOP PLATE | PL/413 | +5.441 | +5.618 | 2.5 | 86.8 | 337 | 320.002 | 0.221141 | 0.107825 | 0.000324648
MULLION TOP PLATE | PL/410 | +5.257 | +5.481 | 2.6 | 86.7 | 342.3 | 320.002 | 0.224225 | 0.109539 | 0.00032997
MULLION TOP PLATE | PL/409 | +5.257 | +5.434 | 2.5 | 86.8 | 336.6 | 320.002 | 0.220908 | 0.107724 | 0.00032439
MULLION TOP PLATE | PL/410 | +5.305 | +5.529 | 2.6 | 86.7 | 343.3 | 320.002 | 0.224851 | 0.109849 | 0.000330901
MULLION TOP PLATE | PL/409 | +5.305 | +5.483 | 2.6 | 86.7 | 337.6 | 320.002 | 0.221534 | 0.108034 | 0.00032532
MULLION TOP PLATE | PL/522 | +5.213 | +5.437 | 2.6 | 86.7 | 343.3 | 320.002 | 0.224854 | 0.109851 | 0.000330906
MULLION TOP PLATE | PL/521 | +5.213 | +5.390 | 2.6 | 86.7 | 337.6 | 320.002 | 0.221534 | 0.108034 | 0.00032532
MULLION TOP PLATE | PL/633 | +5.165 | +5.342 | 2.6 | 86.7 | 337.6 | 320.002 | 0.221534 | 0.108034 | 0.00032532
MULLION TOP PLATE | PL/634 | +5.165 | +5.389 | 2.6 | 86.7 | 343.3 | 320.002 | 0.224847 | 0.109847 | 0.000330895
MULLION TOP PLATE | PL/519 | +5.085 | +5.300 | 2.6 | 86.7 | 342.7 | 320.002 | 0.224505 | 0.109658 | 0.000330339
MULLION TOP PLATE | PL/520 | +5.085 | +5.263 | 2.6 | 86.7 | 338.2 | 320.002 | 0.22188 | 0.10822 | 0.000325918
MULLION TOP PLATE | PL/407 | +5.126 | +5.342 | 2.6 | 86.7 | 342.7 | 320.008 | 0.224507 | 0.109662 | 0.000330342
MULLION TOP PLATE | PL/408 | +5.126 | +5.304 | 2.6 | 86.7 | 338.2 | 320.008 | 0.221884 | 0.108224 | 0.000325923
MULLION TOP PLATE | PL/407 | +5.173 | +5.389 | 2.6 | 86.7 | 342.7 | 320.008 | 0.224498 | 0.109657 | 0.000330328
MULLION TOP PLATE | PL/408 | +5.173 | +5.351 | 2.6 | 86.7 | 338.2 | 320.008 | 0.221878 | 0.108221 | 0.000325915
MULLION TOP PLATE | PL/632 | +5.039 | +5.217 | 2.6 | 86.7 | 338.2 | 320.002 | 0.221879 | 0.10822 | 0.000325917
MULLION TOP PLATE | PL/631 | +5.039 | +5.254 | 2.6 | 86.7 | 342.7 | 320.002 | 0.224499 | 0.109656 | 0.000330331
MULLION TOP PLATE | PL/518 | +5.085 | +5.300 | 2.6 | 86.7 | 342.7 | 320.002 | 0.224505 | 0.109658 | 0.000330339
MULLION TOP PLATE | PL/517 | +5.085 | +5.263 | 2.6 | 86.7 | 338.2 | 320.002 | 0.22188 | 0.10822 | 0.000325918
MULLION TOP PLATE | PL/406 | +5.126 | +5.342 | 2.6 | 86.7 | 342.7 | 320.008 | 0.224507 | 0.109662 | 0.000330342
MULLION TOP PLATE | PL/405 | +5.126 | +5.304 | 2.6 | 86.7 | 338.2 | 320.008 | 0.221884 | 0.108224 | 0.000325923
MULLION TOP PLATE | PL/406 | +5.173 | +5.389 | 2.6 | 86.7 | 342.7 | 320.008 | 0.224498 | 0.109657 | 0.000330328
MULLION TOP PLATE | PL/405 | +5.173 | +5.351 | 2.6 | 86.7 | 338.2 | 320.008 | 0.221878 | 0.108221 | 0.000325915
MULLION TOP PLATE | PL/629 | +5.039 | +5.217 | 2.6 | 86.7 | 338.2 | 320.002 | 0.221879 | 0.10822 | 0.000325917
MULLION TOP PLATE | PL/630 | +5.039 | +5.254 | 2.6 | 86.7 | 342.7 | 320.002 | 0.224499 | 0.109656 | 0.000330331
