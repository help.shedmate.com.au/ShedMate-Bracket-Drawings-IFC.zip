Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView_V2.0, QuantityTakeOffAddOnView], Option [BaseQuantities:On], Option [GridExport:On], Option [Assemblies:On], Option [Bolts:On], Option [Rebars:On], Option [PourObjects:Off], Option [Welds:Off], Option [SurfaceTreatments:On], Option [LocationBy:0], Option [ViewColors:Off], Option [SectionedSpine:Off], Option [PropertySets:On], Option [Export all:Off]
File name: ALLTHREAD ROD BRACING.ifc
Time: 2026-08-22T18:18:55
Author: LAPTOP-2P0BGI6B\lablab
Organization: Structural Designer
Written by: IFC Database Version: Work
Made in: Tekla Structures 2019 Service Pack 13, IFC Export Version: 4.0.0.0 Oct 18 2021

# IfcBuildingStorey, Undefined
In: Undefined
Elevation: 0 mm

# IfcBeam: C:150-15 (4)
In: Undefined
Description: C:150-15; Material: STEEL/300PLUS
Default - ASSEMBLY_POS: Z/2679
Pset_BeamCommon - LoadBearing: no; Reference: Z/2679
BaseQuantities - Length: 1000 mm; OuterSurfaceArea: 0.613915 m2; NetVolume: 0.0004575 m3; NetWeight: 3.59138 kg

# IfcBeam: C:150-24 (8)
In: Undefined
Description: C:150-24; Material: STEEL/G450
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
4 x COLUMN | Z/2393 | 5063.14 | 3.1386 | 0.00373538 | 29.3228
4 x RAFTER | Z/2649 | 3942.51 | 2.44426 | 0.00290863 | 22.8327

# IfcBeam: PLT1.6*60 (4)
In: Undefined
Description: PLT1.6*60; Material: STEEL/250
Default - ASSEMBLY_POS: Z/52
Pset_BeamCommon - LoadBearing: no; Reference: Z/52
BaseQuantities - Length: 297.881 mm; OuterSurfaceArea: 0.0371807 m2; NetVolume: 0.0000287808 m3; NetWeight: 0.225929 kg

# IfcCovering: 12 deg (8)
In: Undefined
Material: Undefined/Undefined

# IfcElementAssembly (51)
In: Undefined
PredefinedType: RIGID_FRAME
Name | ASSEMBLY_POSITION_CODE | ASSEMBLY_POS | Width (mm)
4 x BRACING | ROD16/3 | Z/2651 | 28
2 x PLATE | ROD16/3 | P/3 | 49
BRACKET | ROD16/3 | PL/1680 | 49
3 x ROD BRACING | ROD16-ROD16/3 | X/49 | 16
2 x COUPLER NUT | ROD16-ROD16/3 | X/50 | 28
BRACKET | ROD12/3 | PL/1679 | 49
2 x BRACING | ROD12/3 | Z/2650 | 21
2 x PLATE | ROD12/3 | P/1 | 49
BRACING | ROD12-ROD12/3 | X/45 | 12
2 x COUPLER NUT | ROD12-ROD12/3 | X/46 | 21
ROD BRACING | ROD12-ROD12/3 | X/48 | 12
2 x COLUMN | ROD16/3 | Z/2393 | 64
2 x FASCIA BRACKET | ROD16/3 | Z/52 | 157.2
2 x RAFTER | ROD16/2-3 | Z/2649 | 64
2 x PLATE | ROD16/3 | Z/2673 | 72.5
2 x STIFFINER SLEEVE | ROD16/2-3 | Z/2677 | 54.2
FASCIA | ROD16>/3 | Z/2679 | 64
ROD BRACKET | ROD16/3 | PL/2163 | 49
FASCIA | ROD16-ROD16/3 | Z/2679 | 64
ROD BRACING | ROD16-ROD16/3 | R/49 | 16
2 x NUT | ROD12/3 | Z/2678 | 21
2 x COLUMN | ROD12/3 | Z/2393 | 64
2 x RAFTER | ROD12/2-3 | Z/2649 | 64
2 x FASCIA BRACKET | ROD12/3 | Z/52 | 157.2
2 x PLATE | ROD12/3 | Z/2673 | 72.5
STIFFINER SLEEVE | ROD12/2-3 | Z/2677 | 54.2
FASCIA | ROD12-ROD16/3 | Z/2679 | 64
ROD ALLTHREAD | ROD12-ROD12/3 | X/47 | 12
ROD ALLTHREAD | ROD12-ROD12/3 | R/48 | 12
ROD BRACKET | ROD12/3 | PL/2162 | 49
FASCIA | ROD12-ROD12/3 | Z/2679 | 64

# IfcMechanicalFastener: Bolt assembly (44)
In: Undefined
Name | NominalDiameter (mm) | NominalLength (mm) | Material
4 x Bolt assembly | 16 | 6 | 8.8S
2 x Bolt assembly | 16 | 35 | PB1635
2 x Bolt assembly | 16 | 45 | PB1645
4 x Bolt assembly | 12 | 6 | 8.8S
12 x Bolt assembly | 12 | 30 | PB1230
8 x Bolt assembly | 12 | 30 | 8.8S
12 x Bolt assembly | 5 | 25 | TEK_16TPIM

# IfcMember: M12_COUPLER_NUT (2)
In: Undefined
Description: M12_COUPLER_NUT; Material: STEEL/250
Pset_MemberCommon - LoadBearing: no; Reference: X/46
BaseQuantities - Length: 36.0002 mm; OuterSurfaceArea: 0.00284089 m2; GrossSurfaceArea: 0 m2; CrossSectionArea: 0.000286 m2; NetVolume: 0.0000103118 m3; GrossVolume: 0.0000102961 m3; NetWeight: 0.0809478 kg; GrossWeight: 0.080824 kg

# IfcMember: M12_NUT (4)
In: Undefined
Description: M12_NUT; Material: STEEL/250
Pset_MemberCommon - LoadBearing: no
BaseQuantities - Length: 8.00018 mm; OuterSurfaceArea: 0.00107689 m2; GrossSurfaceArea: 0 m2; CrossSectionArea: 0.000286 m2; NetVolume: 0.00000229156 m3; GrossVolume: 0.00000228805 m3; NetWeight: 0.0179887 kg; GrossWeight: 0.0179612 kg
Name | Reference
2 x BRACING | Z/2650
2 x NUT | Z/2678

# IfcMember: M16_COUPLER_NUT (2)
In: Undefined
Description: M16_COUPLER_NUT; Material: STEEL/250
Pset_MemberCommon - LoadBearing: no; Reference: X/50
BaseQuantities - Length: 48.0002 mm; OuterSurfaceArea: 0.00505046 m2; GrossSurfaceArea: 0 m2; CrossSectionArea: 0.000615 m2; NetVolume: 0.0000244428 m3; GrossVolume: 0.0000295201 m3; NetWeight: 0.191876 kg; GrossWeight: 0.231733 kg

# IfcMember: M16_NUT (4)
In: Undefined
Description: M16_NUT; Material: STEEL/250
Pset_MemberCommon - LoadBearing: no; Reference: Z/2651
BaseQuantities - Length: 8.00018 mm; OuterSurfaceArea: 0.00169046 m2; GrossSurfaceArea: 0 m2; CrossSectionArea: 0.000615 m2; NetVolume: 0.00000407388 m3; GrossVolume: 0.00000492011 m3; NetWeight: 0.0319799 kg; GrossWeight: 0.0386229 kg

# IfcMember: ROD12 (4)
In: Undefined
Description: ROD12; Material: STEEL/250
Pset_MemberCommon - LoadBearing: no
BaseQuantities - Length: 3000 mm; OuterSurfaceArea: 0.110416 m2; GrossSurfaceArea: 0.110416 m2; CrossSectionArea: 0.000101823 m2; NetVolume: 0.00030547 m3; GrossVolume: 0.00030547 m3; NetWeight: 2.39794 kg; GrossWeight: 2.39794 kg
Name | Reference
BRACING | X/45
ROD BRACING | X/48
ROD ALLTHREAD | X/47
ROD ALLTHREAD | R/48

# IfcMember: ROD16 (4)
In: Undefined
Description: ROD16; Material: STEEL/250
Pset_MemberCommon - LoadBearing: no
BaseQuantities - Length: 3000 mm; OuterSurfaceArea: 0.147312 m2; GrossSurfaceArea: 0.147312 m2; CrossSectionArea: 0.000181019 m2; NetVolume: 0.000543058 m3; GrossVolume: 0.000543058 m3; NetWeight: 4.263 kg; GrossWeight: 4.263 kg
Name | Reference
3 x ROD BRACING | X/49
ROD BRACING | R/49

# IfcPlate: FL6*40 (8)
In: Undefined
Description: FL6*40
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 40 mm; NetArea: 0.0156269 m2; GrossArea: 0.00641699 m2; CrossSectionArea: 0.000036 m2; NetVolume: 0.0000392947 m3; GrossVolume: 0.0000392947 m3
Name | Material | ASSEMBLY_POS = Reference
2 x PLATE | STEEL/250 | P/3
BRACKET | STEEL/250 | PL/1680
BRACKET | STEEL/250 | PL/1679
2 x PLATE | STEEL/250 | P/1
ROD BRACKET | STEEL/G450 | PL/2163
ROD BRACKET | STEEL/G450 | PL/2162

# IfcPlate: PLT3*238.6 (3)
In: Undefined
Description: PLT3*238.6; Material: STEEL/250
Default - ASSEMBLY_POS: Z/2677
Pset_PlateCommon - LoadBearing: no; Reference: Z/2677
BaseQuantities - Width: 238.596 mm; NetArea: 0.198176 m2; GrossArea: 0.0954382 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000290091 m3; GrossVolume: 0.000290091 m3

# IfcPlate: PLT3*313.3 (4)
In: Undefined
Description: PLT3*313.3; Material: STEEL/G450
Default - ASSEMBLY_POS: Z/2673
Pset_PlateCommon - LoadBearing: no; Reference: Z/2673
BaseQuantities - Width: 313.286 mm; NetArea: 0.21672 m2; GrossArea: 0.139471 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000318273 m3; GrossVolume: 0.000318273 m3
