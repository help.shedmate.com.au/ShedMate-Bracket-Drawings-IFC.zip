Properties of the parts of a building model (IFC2X3), part 2 of 2

# IfcMember: C:200-24 (2)
Tekla Quantity - Weight: 69.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 110 m2; Net surface area: 7.6 m2; Height: 203 mm; Width: 76 mm; Length: 9790.3 mm
Pset_MemberCommon - LoadBearing: no; Reference: Z/1714
BaseQuantities - Length: 9790.31 mm; OuterSurfaceArea: 7.63438 m2; GrossSurfaceArea: 0 m2; CrossSectionArea: 0.000903 m2; NetVolume: 0.00910264 m3; GrossVolume: 0.00884065 m3; NetWeight: 71.4557 kg; GrossWeight: 69.3991 kg

# IfcMember: C:250-24 (2)
In: Undefined
Description: C:250-24; Material: STEEL/G450
Tekla Common - Finish: 25 deg; Bottom elevation: +4.529; Top elevation: +9.044; Phase: 1; Class: 10
Tekla Quantity - Weight: 81.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 109.7 m2; Net surface area: 8.9 m2; Height: 254 mm; Width: 76 mm; Length: 10138.4 mm
Pset_MemberCommon - LoadBearing: no; Reference: Z/1731
BaseQuantities - Length: 10138.4 mm; OuterSurfaceArea: 8.91982 m2; GrossSurfaceArea: 0 m2; CrossSectionArea: 0.001022 m2; NetVolume: 0.0106429 m3; GrossVolume: 0.0103614 m3; NetWeight: 83.5466 kg; GrossWeight: 81.3372 kg

# IfcMember: C:300-30 (2)
In: Undefined
Description: C:300-30; Material: STEEL/G450
Tekla Common - Finish: 25 deg; Bottom elevation: +3.454; Top elevation: +8.160; Phase: 1; Class: 10
Tekla Quantity - Weight: 131.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.4 m2; Net surface area: 11.5 m2; Height: 300 mm; Width: 96 mm; Length: 10491.6 mm
Pset_MemberCommon - LoadBearing: no; Reference: Z/1748
BaseQuantities - Length: 10491.6 mm; OuterSurfaceArea: 11.46 m2; GrossSurfaceArea: 0 m2; CrossSectionArea: 0.001593 m2; NetVolume: 0.0170907 m3; GrossVolume: 0.0167131 m3; NetWeight: 134.162 kg; GrossWeight: 131.197 kg

# IfcMember: C:350-30 (2)
In: Undefined
Description: C:350-30; Material: STEEL/G450
Tekla Common - Finish: 25 deg; Bottom elevation: +3.405; Top elevation: +8.156; Phase: 1; Class: 10
Tekla Quantity - Weight: 156.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.1 m2; Net surface area: 13.7 m2; Height: 350 mm; Width: 125 mm; Length: 10490.7 mm
Pset_MemberCommon - LoadBearing: no; Reference: Z/1765
BaseQuantities - Length: 10490.7 mm; OuterSurfaceArea: 13.6627 m2; GrossSurfaceArea: 0 m2; CrossSectionArea: 0.001905 m2; NetVolume: 0.0203938 m3; GrossVolume: 0.0199847 m3; NetWeight: 160.092 kg; GrossWeight: 156.88 kg

# IfcPlate: PLT3*394.5 (2)
In: Undefined
Description: PLT3*394.5; Material: STEEL/450
Tekla Common - Bottom elevation: +5.765; Top elevation: +6.180; Phase: 1; Class: 11
Tekla Quantity - Weight: 3.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.5 m2; Net surface area: 0.3 m2; Height: 394.5 mm; Width: 3 mm; Length: 463.2 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 394.529 mm; NetArea: 0.272188 m2; GrossArea: 0.182742 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000400928 m3; GrossVolume: 0.000400928 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1268
PLATE | PL/1250

# IfcPlate: PLT3*398.7 (2)
In: Undefined
Description: PLT3*398.7; Material: STEEL/450
Tekla Common - Bottom elevation: +6.214; Top elevation: +6.640; Phase: 1; Class: 11
Tekla Quantity - Weight: 3.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.5 m2; Net surface area: 0.3 m2; Height: 398.7 mm; Width: 3 mm; Length: 473.2 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 398.698 mm; NetArea: 0.272142 m2; GrossArea: 0.188674 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000400838 m3; GrossVolume: 0.000400838 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1269
PLATE | PL/1251

# IfcPlate: PLT3*399.3 (2)
In: Undefined
Description: PLT3*399.3; Material: STEEL/450
Tekla Common - Bottom elevation: +5.329; Top elevation: +5.733; Phase: 1; Class: 11
Tekla Quantity - Weight: 3.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.5 m2; Net surface area: 0.3 m2; Height: 399.3 mm; Width: 3 mm; Length: 453.8 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 399.25 mm; NetArea: 0.272289 m2; GrossArea: 0.181195 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000401092 m3; GrossVolume: 0.000401092 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1261
PLATE | PL/1253

# IfcPlate: PLT3*399.6 (2)
In: Undefined
Description: PLT3*399.6; Material: STEEL/450
Tekla Common - Bottom elevation: +7.327; Top elevation: +7.782; Phase: 1; Class: 11
Tekla Quantity - Weight: 3.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.5 m2; Net surface area: 0.3 m2; Height: 399.6 mm; Width: 3 mm; Length: 504 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 399.568 mm; NetArea: 0.271684 m2; GrossArea: 0.201392 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000400088 m3; GrossVolume: 0.000400088 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1265
PLATE | PL/1257

# IfcPlate: PLT3*401.9 (2)
In: Undefined
Description: PLT3*401.9; Material: STEEL/450
Tekla Common - Bottom elevation: +5.002; Top elevation: +5.399; Phase: 1; Class: 11
Tekla Quantity - Weight: 3.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.5 m2; Net surface area: 0.3 m2; Height: 401.9 mm; Width: 3 mm; Length: 447.4 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 401.917 mm; NetArea: 0.272101 m2; GrossArea: 0.179821 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000400821 m3; GrossVolume: 0.000400821 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1806
PLATE | PL/1808

# IfcPlate: PLT3*407.3 (2)
In: Undefined
Description: PLT3*407.3; Material: STEEL/450
Tekla Common - Bottom elevation: +5.897; Top elevation: +6.291; Phase: 1; Class: 11
Tekla Quantity - Weight: 3.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.5 m2; Net surface area: 0.3 m2; Height: 407.3 mm; Width: 3 mm; Length: 439.7 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 407.335 mm; NetArea: 0.271991 m2; GrossArea: 0.179115 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000400662 m3; GrossVolume: 0.000400662 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1272
PLATE | PL/1249

# IfcPlate: PLT3*412.5 (2)
In: Undefined
Description: PLT3*412.5; Material: STEEL/450
Tekla Common - Bottom elevation: +5.331; Top elevation: +5.713; Phase: 1; Class: 11
Tekla Quantity - Weight: 3.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.5 m2; Net surface area: 0.3 m2; Height: 412.5 mm; Width: 3 mm; Length: 426.2 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 412.49 mm; NetArea: 0.271189 m2; GrossArea: 0.175805 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00039948 m3; GrossVolume: 0.00039948 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1271
PLATE | PL/1248

# IfcPlate: PLT3*414.4 (2)
In: Undefined
Description: PLT3*414.4; Material: STEEL/450
Tekla Common - Bottom elevation: +5.051; Top elevation: +5.427; Phase: 1; Class: 11
Tekla Quantity - Weight: 3.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.5 m2; Net surface area: 0.3 m2; Height: 414.4 mm; Width: 3 mm; Length: 419.8 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 414.411 mm; NetArea: 0.270632 m2; GrossArea: 0.17395 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000398657 m3; GrossVolume: 0.000398657 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1273
PLATE | PL/1246

# IfcPlate: PLT3*419.4 (2)
In: Undefined
Description: PLT3*419.4; Material: STEEL/450
Tekla Common - Bottom elevation: +4.632; Top elevation: +5.019; Phase: 1; Class: 11
Tekla Quantity - Weight: 3.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.5 m2; Net surface area: 0.3 m2; Height: 419.4 mm; Width: 3 mm; Length: 434.3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 419.362 mm; NetArea: 0.278278 m2; GrossArea: 0.182123 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000410015 m3; GrossVolume: 0.000410015 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1270
PLATE | PL/1247

# IfcPlate: PLT3*425 (2)
In: Undefined
Description: PLT3*425; Material: STEEL/450
Tekla Common - Bottom elevation: +4.632; Top elevation: +5.032; Phase: 1; Class: 11
Tekla Quantity - Weight: 3.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.3 m2; Height: 425 mm; Width: 3 mm; Length: 446.2 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 425.022 mm; NetArea: 0.284054 m2; GrossArea: 0.189625 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00041859 m3; GrossVolume: 0.00041859 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1266
PLATE | PL/1258

# IfcPlate: PLT3*435.5 (2)
In: Undefined
Description: PLT3*435.5; Material: STEEL/450
Tekla Common - Bottom elevation: +4.631; Top elevation: +5.058; Phase: 1; Class: 11
Tekla Quantity - Weight: 3.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.3 m2; Height: 435.5 mm; Width: 3 mm; Length: 469.9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 435.456 mm; NetArea: 0.2955 m2; GrossArea: 0.204623 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000435582 m3; GrossVolume: 0.000435582 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1267
PLATE | PL/1259

# IfcPlate: PLT3*437.8 (2)
In: Undefined
Description: PLT3*437.8; Material: STEEL/450
Tekla Common - Bottom elevation: +3.592; Top elevation: +4.026; Phase: 1; Class: 11
Tekla Quantity - Weight: 3.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.3 m2; Height: 437.8 mm; Width: 3 mm; Length: 476 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 437.789 mm; NetArea: 0.298342 m2; GrossArea: 0.208369 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000439799 m3; GrossVolume: 0.000439799 m3
Name | ASSEMBLY_POS = Reference | Area per tons (m2)
PLATE | PL/1805 | 86.5
PLATE | PL/1807 | 86.3

# IfcPlate: PLT3*442.5 (2)
In: Undefined
Description: PLT3*442.5; Material: STEEL/450
Tekla Common - Bottom elevation: +3.629; Top elevation: +4.077; Phase: 1; Class: 11
Tekla Quantity - Weight: 3.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.3 m2; Height: 442.5 mm; Width: 3 mm; Length: 487.8 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 442.489 mm; NetArea: 0.304007 m2; GrossArea: 0.215836 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000448205 m3; GrossVolume: 0.000448205 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1260
PLATE | PL/1252

# IfcPlate: PLT3*448.6 (2)
In: Undefined
Description: PLT3*448.6; Material: STEEL/450
Tekla Common - Bottom elevation: +5.711; Top elevation: +6.192; Phase: 1; Class: 11
Tekla Quantity - Weight: 4.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.3 m2; Height: 448.6 mm; Width: 3 mm; Length: 535.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 448.573 mm; NetArea: 0.360352 m2; GrossArea: 0.240276 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000532112 m3; GrossVolume: 0.000532112 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1293
PLATE | PL/1281

# IfcPlate: PLT3*448.9 (2)
In: Undefined
Description: PLT3*448.9; Material: STEEL/450
Tekla Common - Bottom elevation: +3.623; Top elevation: +4.091; Phase: 1; Class: 11
Tekla Quantity - Weight: 3.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.3 m2; Height: 448.9 mm; Width: 3 mm; Length: 505.7 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 448.851 mm; NetArea: 0.312452 m2; GrossArea: 0.226981 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000460732 m3; GrossVolume: 0.000460732 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1262
PLATE | PL/1254

# IfcPlate: PLT3*451.2 (2)
In: Undefined
Description: PLT3*451.2; Material: STEEL/450
Tekla Common - Bottom elevation: +5.277; Top elevation: +5.743; Phase: 1; Class: 11
Tekla Quantity - Weight: 4.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.3 m2; Height: 451.2 mm; Width: 3 mm; Length: 521 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 451.17 mm; NetArea: 0.358562 m2; GrossArea: 0.235039 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000529472 m3; GrossVolume: 0.000529472 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1291
PLATE | PL/1279

# IfcPlate: PLT3*452.7 (2)
In: Undefined
Description: PLT3*452.7; Material: STEEL/450
Tekla Common - Bottom elevation: +6.158; Top elevation: +6.654; Phase: 1; Class: 11
Tekla Quantity - Weight: 4.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.3 m2; Height: 452.7 mm; Width: 3 mm; Length: 551.1 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 452.66 mm; NetArea: 0.361979 m2; GrossArea: 0.249461 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000534502 m3; GrossVolume: 0.000534502 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1295
PLATE | PL/1283

# IfcPlate: PLT3*454.7 (2)
In: Undefined
Description: PLT3*454.7; Material: STEEL/450
Tekla Common - Bottom elevation: +3.616; Top elevation: +4.106; Phase: 1; Class: 11
Tekla Quantity - Weight: 3.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.3 m2; Height: 454.8 mm; Width: 3 mm; Length: 524.3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 454.707 mm; NetArea: 0.321325 m2; GrossArea: 0.238384 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000473891 m3; GrossVolume: 0.000473891 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1263
PLATE | PL/1255

# IfcPlate: PLT3*454.8 (2)
In: Undefined
Description: PLT3*454.8; Material: STEEL/450
Tekla Common - Bottom elevation: +4.952; Top elevation: +5.410; Phase: 1; Class: 11
Tekla Quantity - Weight: 4.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.3 m2; Height: 454.8 mm; Width: 3 mm; Length: 511.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 454.753 mm; NetArea: 0.35726 m2; GrossArea: 0.232657 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000527549 m3; GrossVolume: 0.000527549 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1810
PLATE | PL/1812

# IfcPlate: PLT3*456.5 (2)
In: Undefined
Description: PLT3*456.5; Material: STEEL/450
Tekla Common - Bottom elevation: +5.845; Top elevation: +6.299; Phase: 1; Class: 11
Tekla Quantity - Weight: 4.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.3 m2; Height: 456.5 mm; Width: 3 mm; Length: 507 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 456.47 mm; NetArea: 0.356572 m2; GrossArea: 0.231421 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000526531 m3; GrossVolume: 0.000526531 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1300
PLATE | PL/1277

# IfcPlate: PLT3*457.4 (2)
In: Undefined
Description: PLT3*457.4; Material: STEEL/450
Tekla Common - Bottom elevation: +7.264; Top elevation: +7.799; Phase: 1; Class: 11
Tekla Quantity - Weight: 4.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.3 m2; Height: 457.4 mm; Width: 3 mm; Length: 590.8 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 457.385 mm; NetArea: 0.365472 m2; GrossArea: 0.270232 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000539608 m3; GrossVolume: 0.000539608 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1297
PLATE | PL/1285

# IfcPlate: PLT3*458.6 (2)
In: Undefined
Description: PLT3*458.6; Material: STEEL/450
Tekla Common - Bottom elevation: +3.599; Top elevation: +4.137; Phase: 1; Class: 11
Tekla Quantity - Weight: 3.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.3 m2; Height: 458.6 mm; Width: 3 mm; Length: 569.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 458.565 mm; NetArea: 0.340214 m2; GrossArea: 0.261204 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00050188 m3; GrossVolume: 0.00050188 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1264
PLATE | PL/1256

# IfcPlate: PLT3*462 (2)
In: Undefined
Description: PLT3*462; Material: STEEL/450
Tekla Common - Bottom elevation: +5.280; Top elevation: +5.717; Phase: 1; Class: 11
Tekla Quantity - Weight: 4.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.3 m2; Height: 462 mm; Width: 3 mm; Length: 489.3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 462.019 mm; NetArea: 0.353545 m2; GrossArea: 0.226059 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000522048 m3; GrossVolume: 0.000522048 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1299
PLATE | PL/1276

# IfcPlate: PLT3*464.1 (2)
In: Undefined
Description: PLT3*464.1; Material: STEEL/450
Tekla Common - Bottom elevation: +5.000; Top elevation: +5.430; Phase: 1; Class: 11
Tekla Quantity - Weight: 4.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.3 m2; Height: 464.1 mm; Width: 3 mm; Length: 480.8 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 464.091 mm; NetArea: 0.351841 m2; GrossArea: 0.223135 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000519519 m3; GrossVolume: 0.000519519 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1301
PLATE | PL/1274

# IfcPlate: PLT3*478.1 (2)
In: Undefined
Description: PLT3*478.1; Material: STEEL/450
Tekla Common - Bottom elevation: +4.581; Top elevation: +5.021; Phase: 1; Class: 11
Tekla Quantity - Weight: 4.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.3 m2; Height: 478.1 mm; Width: 3 mm; Length: 488.7 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 478.088 mm; NetArea: 0.361817 m2; GrossArea: 0.23366 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000534374 m3; GrossVolume: 0.000534374 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1298
PLATE | PL/1275

# IfcPlate: PLT3*485.3 (2)
In: Undefined
Description: PLT3*485.3; Material: STEEL/450
Tekla Common - Bottom elevation: +4.581; Top elevation: +5.035; Phase: 1; Class: 11
Tekla Quantity - Weight: 4.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.2 m2; Net surface area: 0.3 m2; Height: 485.3 mm; Width: 3 mm; Length: 502.5 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 485.277 mm; NetArea: 0.370345 m2; GrossArea: 0.243836 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000547062 m3; GrossVolume: 0.000547062 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1288
PLATE | PL/1286

# IfcPlate: PLT3*498.1 (2)
In: Undefined
Description: PLT3*498.1; Material: STEEL/450
Tekla Common - Bottom elevation: +4.579; Top elevation: +5.064; Phase: 1; Class: 11
Tekla Quantity - Weight: 4.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.2 m2; Net surface area: 0.3 m2; Height: 498.1 mm; Width: 3 mm; Length: 530.4 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 498.136 mm; NetArea: 0.387458 m2; GrossArea: 0.264221 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000572516 m3; GrossVolume: 0.000572516 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1289
PLATE | PL/1287

# IfcPlate: PLT3*501.1 (2)
In: Undefined
Description: PLT3*501.1; Material: STEEL/450
Tekla Common - Bottom elevation: +3.542; Top elevation: +4.034; Phase: 1; Class: 11
Tekla Quantity - Weight: 4.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.2 m2; Net surface area: 0.3 m2; Height: 501.1 mm; Width: 3 mm; Length: 537.4 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 501.076 mm; NetArea: 0.391733 m2; GrossArea: 0.269279 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000578875 m3; GrossVolume: 0.000578875 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1809
PLATE | PL/1811

# IfcPlate: PLT3*506.3 (2)
In: Undefined
Description: PLT3*506.3; Material: STEEL/450
Tekla Common - Bottom elevation: +3.577; Top elevation: +4.085; Phase: 1; Class: 11
Tekla Quantity - Weight: 4.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.2 m2; Net surface area: 0.3 m2; Height: 506.3 mm; Width: 3 mm; Length: 551.8 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 506.339 mm; NetArea: 0.400316 m2; GrossArea: 0.279384 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000591638 m3; GrossVolume: 0.000591638 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1290
PLATE | PL/1278

# IfcPlate: PLT3*513.3 (2)
In: Undefined
Description: PLT3*513.3; Material: STEEL/450
Tekla Common - Bottom elevation: +3.569; Top elevation: +4.100; Phase: 1; Class: 11
Tekla Quantity - Weight: 4.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.2 m2; Net surface area: 0.3 m2; Height: 513.3 mm; Width: 3 mm; Length: 573.4 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 513.312 mm; NetArea: 0.413232 m2; GrossArea: 0.294359 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000610841 m3; GrossVolume: 0.000610841 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1292
PLATE | PL/1280

# IfcPlate: PLT3*517.4 (2)
In: Undefined
Description: PLT3*517.4; Material: STEEL/450
Tekla Common - Bottom elevation: +5.165; Top elevation: +5.754; Phase: 1; Class: 11
Tekla Quantity - Weight: 6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.5 m2; Height: 517.4 mm; Width: 3 mm; Length: 636.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 517.363 mm; NetArea: 0.515428 m2; GrossArea: 0.329376 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000763135 m3; GrossVolume: 0.000763135 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1317
PLATE | PL/1308

# IfcPlate: PLT3*519 (2)
In: Undefined
Description: PLT3*519; Material: STEEL/450
Tekla Common - Bottom elevation: +3.560; Top elevation: +4.115; Phase: 1; Class: 11
Tekla Quantity - Weight: 4.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.2 m2; Net surface area: 0.3 m2; Height: 519 mm; Width: 3 mm; Length: 595.4 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 519.018 mm; NetArea: 0.426208 m2; GrossArea: 0.309044 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00063013 m3; GrossVolume: 0.00063013 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1294
PLATE | PL/1282

# IfcPlate: PLT3*519.7 (2)
In: Undefined
Description: PLT3*519.7; Material: STEEL/450
Tekla Common - Bottom elevation: +6.606; Top elevation: +7.211; Phase: 1; Class: 11
Tekla Quantity - Weight: 6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.5 m2; Height: 519.7 mm; Width: 3 mm; Length: 653.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 519.726 mm; NetArea: 0.518329 m2; GrossArea: 0.339685 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000767428 m3; GrossVolume: 0.000767428 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1319
PLATE | PL/1310

# IfcPlate: PLT3*521 (2)
In: Undefined
Description: PLT3*521; Material: STEEL/450
Tekla Common - Bottom elevation: +4.842; Top elevation: +5.420; Phase: 1; Class: 11
Tekla Quantity - Weight: 6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.5 m2; Height: 521 mm; Width: 3 mm; Length: 625.3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 521.009 mm; NetArea: 0.512844 m2; GrossArea: 0.325792 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000759302 m3; GrossVolume: 0.000759302 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1814
PLATE | PL/1816

# IfcPlate: PLT3*522.7 (2)
In: Undefined
Description: PLT3*522.7; Material: STEEL/450
Tekla Common - Bottom elevation: +5.734; Top elevation: +6.307; Phase: 1; Class: 11
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.5 m2; Height: 522.7 mm; Width: 3 mm; Length: 619.7 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 522.726 mm; NetArea: 0.5115 m2; GrossArea: 0.323931 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000757306 m3; GrossVolume: 0.000757306 m3
Name | ASSEMBLY_POS = Reference | Weight (kg)
PLATE | PL/1327 | 6
PLATE | PL/1306 | 5.8

# IfcPlate: PLT3*525.5 (2)
In: Undefined
Description: PLT3*525.5; Material: STEEL/450
Tekla Common - Bottom elevation: +7.049; Top elevation: +7.674; Phase: 1; Class: 11
Tekla Quantity - Weight: 6.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.5 m2; Height: 525.5 mm; Width: 3 mm; Length: 673.1 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 525.489 mm; NetArea: 0.522643 m2; GrossArea: 0.353728 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000773819 m3; GrossVolume: 0.000773819 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1321
PLATE | PL/1312

# IfcPlate: PLT3*527.3 (2)
In: Undefined
Description: PLT3*527.3; Material: STEEL/450
Tekla Common - Bottom elevation: +3.536; Top elevation: +4.147; Phase: 1; Class: 11
Tekla Quantity - Weight: 5.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.2 m2; Net surface area: 0.5 m2; Height: 527.3 mm; Width: 3 mm; Length: 648 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 527.271 mm; NetArea: 0.456837 m2; GrossArea: 0.341664 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000675639 m3; GrossVolume: 0.000675639 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1296
PLATE | PL/1284

# IfcPlate: PLT3*528.1 (2)
In: Undefined
Description: PLT3*528.1; Material: STEEL/450
Tekla Common - Bottom elevation: +5.169; Top elevation: +5.722; Phase: 1; Class: 11
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.5 m2; Height: 528.1 mm; Width: 3 mm; Length: 598.3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 528.095 mm; NetArea: 0.505784 m2; GrossArea: 0.315967 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000748812 m3; GrossVolume: 0.000748812 m3
Name | ASSEMBLY_POS = Reference | Weight (kg)
PLATE | PL/1329 | 6
PLATE | PL/1303 | 5.8

# IfcPlate: PLT3*530 (2)
In: Undefined
Description: PLT3*530; Material: STEEL/450
Tekla Common - Bottom elevation: +4.889; Top elevation: +5.432; Phase: 1; Class: 11
Tekla Quantity - Weight: 5.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.5 m2; Height: 530 mm; Width: 3 mm; Length: 588.1 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 529.993 mm; NetArea: 0.502685 m2; GrossArea: 0.311688 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000744205 m3; GrossVolume: 0.000744205 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1328
PLATE | PL/1302

# IfcPlate: PLT3*532.7 (2)
In: Undefined
Description: PLT3*532.7; Material: STEEL/450
Tekla Common - Bottom elevation: +8.149; Top elevation: +8.823; Phase: 1; Class: 11
Tekla Quantity - Weight: 6.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.5 m2; Height: 532.7 mm; Width: 3 mm; Length: 720.3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 532.671 mm; NetArea: 0.529968 m2; GrossArea: 0.383697 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000784611 m3; GrossVolume: 0.000784611 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1323
PLATE | PL/1314

# IfcPlate: PLT3*545.5 (2)
In: Undefined
Description: PLT3*545.5; Material: STEEL/450
Tekla Common - Bottom elevation: +4.470; Top elevation: +5.024; Phase: 1; Class: 11
Tekla Quantity - Weight: 6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.5 m2; Height: 545.5 mm; Width: 3 mm; Length: 597.2 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 545.53 mm; NetArea: 0.515788 m2; GrossArea: 0.325812 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000763734 m3; GrossVolume: 0.000763734 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1325
PLATE | PL/1304

# IfcPlate: PLT3*554 (2)
In: Undefined
Description: PLT3*554; Material: STEEL/450
Tekla Common - Bottom elevation: +4.470; Top elevation: +5.041; Phase: 1; Class: 11
Tekla Quantity - Weight: 6.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.5 m2; Height: 554 mm; Width: 3 mm; Length: 613.7 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 553.963 mm; NetArea: 0.528157 m2; GrossArea: 0.339968 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000782161 m3; GrossVolume: 0.000782161 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1326
PLATE | PL/1305

# IfcPlate: PLT3*569.1 (2)
In: Undefined
Description: PLT3*569.1; Material: STEEL/450
Tekla Common - Bottom elevation: +4.468; Top elevation: +5.073; Phase: 1; Class: 11
Tekla Quantity - Weight: 6.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.6 m2; Height: 569.1 mm; Width: 3 mm; Length: 646.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 569.124 mm; NetArea: 0.552193 m2; GrossArea: 0.367981 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000817953 m3; GrossVolume: 0.000817953 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1324
PLATE | PL/1315

# IfcPlate: PLT3*570.3 (2)
In: Undefined
Description: PLT3*570.3; Material: STEEL/450
Tekla Common - Bottom elevation: +5.549; Top elevation: +6.216; Phase: 1; Class: 11
Tekla Quantity - Weight: 7.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.6 m2; Height: 570.3 mm; Width: 3 mm; Length: 726.1 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 570.276 mm; NetArea: 0.634357 m2; GrossArea: 0.414079 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000940386 m3; GrossVolume: 0.000940386 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1347
PLATE | PL/1336

# IfcPlate: PLT3*572.5 (2)
In: Undefined
Description: PLT3*572.5; Material: STEEL/450
Tekla Common - Bottom elevation: +5.118; Top elevation: +5.764; Phase: 1; Class: 11
Tekla Quantity - Weight: 7.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.6 m2; Height: 572.5 mm; Width: 3 mm; Length: 705.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 572.484 mm; NetArea: 0.628387 m2; GrossArea: 0.403917 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000931523 m3; GrossVolume: 0.000931523 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1345
PLATE | PL/1334

# IfcPlate: PLT3*572.6 (2)
In: Undefined
Description: PLT3*572.6; Material: STEEL/450
Tekla Common - Bottom elevation: +3.433; Top elevation: +4.047; Phase: 1; Class: 11
Tekla Quantity - Weight: 6.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.6 m2; Height: 572.6 mm; Width: 3 mm; Length: 654.9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 572.592 mm; NetArea: 0.558279 m2; GrossArea: 0.374974 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000827016 m3; GrossVolume: 0.000827016 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1813
PLATE | PL/1815

# IfcPlate: PLT3*576.4 (2)
In: Undefined
Description: PLT3*576.4; Material: STEEL/450
Tekla Common - Bottom elevation: +4.798; Top elevation: +5.431; Phase: 1; Class: 11
Tekla Quantity - Weight: 7.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.6 m2; Height: 576.4 mm; Width: 3 mm; Length: 692.2 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 576.37 mm; NetArea: 0.624296 m2; GrossArea: 0.398981 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000925445 m3; GrossVolume: 0.000925445 m3
Name | ASSEMBLY_POS = Reference | Area per tons (m2)
PLATE | PL/1818 | 86
PLATE | PL/1820 | 85.8

# IfcPlate: PLT3*578.4 (2)
In: Undefined
Description: PLT3*578.4; Material: STEEL/450
Tekla Common - Bottom elevation: +5.688; Top elevation: +6.315; Phase: 1; Class: 11
Tekla Quantity - Weight: 7.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.6 m2; Height: 578.4 mm; Width: 3 mm; Length: 685.4 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 578.413 mm; NetArea: 0.622229 m2; GrossArea: 0.396466 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000922375 m3; GrossVolume: 0.000922375 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1357
PLATE | PL/1332

# IfcPlate: PLT3*578.9 (2)
In: Undefined
Description: PLT3*578.9; Material: STEEL/450
Tekla Common - Bottom elevation: +3.465; Top elevation: +4.097; Phase: 1; Class: 11
Tekla Quantity - Weight: 6.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.6 m2; Height: 578.9 mm; Width: 3 mm; Length: 671.9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 578.932 mm; NetArea: 0.570492 m2; GrossArea: 0.388963 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000845199 m3; GrossVolume: 0.000845199 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1316
PLATE | PL/1307

# IfcPlate: PLT3*584.2 (2)
In: Undefined
Description: PLT3*584.2; Material: STEEL/450
Tekla Common - Bottom elevation: +5.124; Top elevation: +5.726; Phase: 1; Class: 11
Tekla Quantity - Weight: 7.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.6 m2; Height: 584.2 mm; Width: 3 mm; Length: 660.3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 584.195 mm; NetArea: 0.613503 m2; GrossArea: 0.385721 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000909398 m3; GrossVolume: 0.000909398 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1356
PLATE | PL/1331

# IfcPlate: PLT3*586.3 (2)
In: Undefined
Description: PLT3*586.3; Material: STEEL/450
Tekla Common - Bottom elevation: +4.844; Top elevation: +5.435; Phase: 1; Class: 11
Tekla Quantity - Weight: 7.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.6 m2; Height: 586.3 mm; Width: 3 mm; Length: 648.2 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 586.286 mm; NetArea: 0.608883 m2; GrossArea: 0.380014 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000902521 m3; GrossVolume: 0.000902521 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1355
PLATE | PL/1330

# IfcPlate: PLT3*587.4 (2)
In: Undefined
Description: PLT3*587.4; Material: STEEL/450
Tekla Common - Bottom elevation: +4.462; Top elevation: +5.121; Phase: 1; Class: 11
Tekla Quantity - Weight: 6.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.6 m2; Height: 587.4 mm; Width: 3 mm; Length: 697.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 587.385 mm; NetArea: 0.588908 m2; GrossArea: 0.409764 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000872615 m3; GrossVolume: 0.000872615 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1318
PLATE | PL/1309

# IfcPlate: PLT3*589 (2)
In: Undefined
Description: PLT3*589; Material: STEEL/450
Tekla Common - Bottom elevation: +7.086; Top elevation: +7.832; Phase: 1; Class: 11
Tekla Quantity - Weight: 7.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.6 m2; Height: 589 mm; Width: 3 mm; Length: 803.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 589.002 mm; NetArea: 0.65396 m2; GrossArea: 0.47331 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000969415 m3; GrossVolume: 0.000969415 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1351
PLATE | PL/1340

# IfcPlate: PLT3*594.4 (2)
In: Undefined
Description: PLT3*594.4; Material: STEEL/450
Tekla Common - Bottom elevation: +4.451; Top elevation: +5.138; Phase: 1; Class: 11
Tekla Quantity - Weight: 7.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.6 m2; Height: 594.4 mm; Width: 3 mm; Length: 723.7 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 594.388 mm; NetArea: 0.607402 m2; GrossArea: 0.430178 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00090014 m3; GrossVolume: 0.00090014 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1320
PLATE | PL/1311

# IfcPlate: PLT3*604.4 (2)
In: Undefined
Description: PLT3*604.4; Material: STEEL/450
Tekla Common - Bottom elevation: +4.425; Top elevation: +5.027; Phase: 1; Class: 11
Tekla Quantity - Weight: 7.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.6 m2; Height: 604.4 mm; Width: 3 mm; Length: 656.7 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 604.407 mm; NetArea: 0.625275 m2; GrossArea: 0.396918 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000926986 m3; GrossVolume: 0.000926986 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1352
PLATE | PL/1341

# IfcPlate: PLT3*605.1 (2)
In: Undefined
Description: PLT3*605.1; Material: STEEL/450
Tekla Common - Bottom elevation: +4.420; Top elevation: +5.173; Phase: 1; Class: 11
Tekla Quantity - Weight: 7.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.6 m2; Height: 605.1 mm; Width: 3 mm; Length: 786.3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 605.064 mm; NetArea: 0.651157 m2; GrossArea: 0.475784 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000965237 m3; GrossVolume: 0.000965237 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1322
PLATE | PL/1313

# IfcPlate: PLT3*614.4 (2)
In: Undefined
Description: PLT3*614.4; Material: STEEL/450
Tekla Common - Bottom elevation: +4.424; Top elevation: +5.044; Phase: 1; Class: 11
Tekla Quantity - Weight: 7.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.6 m2; Height: 614.4 mm; Width: 3 mm; Length: 674.4 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 614.393 mm; NetArea: 0.64118 m2; GrossArea: 0.414318 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000950701 m3; GrossVolume: 0.000950701 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1353
PLATE | PL/1342

# IfcPlate: PLT3*632.6 (2)
In: Undefined
Description: PLT3*632.6; Material: STEEL/450
Tekla Common - Bottom elevation: +4.422; Top elevation: +5.080; Phase: 1; Class: 11
Tekla Quantity - Weight: 7.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.6 m2; Height: 632.6 mm; Width: 3 mm; Length: 710.3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 632.623 mm; NetArea: 0.673364 m2; GrossArea: 0.449363 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000998683 m3; GrossVolume: 0.000998683 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1354
PLATE | PL/1343

# IfcPlate: PLT3*636.8 (2)
In: Undefined
Description: PLT3*636.8; Material: STEEL/450
Tekla Common - Bottom elevation: +3.388; Top elevation: +4.056; Phase: 1; Class: 11
Tekla Quantity - Weight: 7.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.6 m2; Height: 636.8 mm; Width: 3 mm; Length: 719.4 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 636.815 mm; NetArea: 0.681452 m2; GrossArea: 0.458097 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00101074 m3; GrossVolume: 0.00101074 m3
Name | ASSEMBLY_POS = Reference | Area per tons (m2)
PLATE | PL/1817 | 86
PLATE | PL/1819 | 85.8

# IfcPlate: PLT3*643.7 (2)
In: Undefined
Description: PLT3*643.7; Material: STEEL/450
Tekla Common - Bottom elevation: +5.496; Top elevation: +6.228; Phase: 1; Class: 11
Tekla Quantity - Weight: 9.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.8 m2; Height: 643.7 mm; Width: 3 mm; Length: 812.8 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 643.72 mm; NetArea: 0.792455 m2; GrossArea: 0.52323 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00117617 m3; GrossVolume: 0.00117617 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1375
PLATE | PL/1366

# IfcPlate: PLT3*644.6 (2)
In: Undefined
Description: PLT3*644.6; Material: STEEL/450
Tekla Common - Bottom elevation: +3.419; Top elevation: +4.106; Phase: 1; Class: 11
Tekla Quantity - Weight: 8.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.6 m2; Height: 644.6 mm; Width: 3 mm; Length: 737.8 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 644.599 mm; NetArea: 0.697743 m2; GrossArea: 0.475608 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00103502 m3; GrossVolume: 0.00103502 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1344
PLATE | PL/1333

# IfcPlate: PLT3*650.3 (2)
In: Undefined
Description: PLT3*650.3; Material: STEEL/450
Tekla Common - Bottom elevation: +5.936; Top elevation: +6.693; Phase: 1; Class: 11
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.8 m2; Height: 650.3 mm; Width: 3 mm; Length: 838.2 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 650.255 mm; NetArea: 0.800701 m2; GrossArea: 0.545038 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00118842 m3; GrossVolume: 0.00118842 m3
Name | ASSEMBLY_POS = Reference | Weight (kg)
PLATE | PL/1377 | 9.4
PLATE | PL/1368 | 9.2

# IfcPlate: PLT3*651 (2)
In: Undefined
Description: PLT3*651; Material: STEEL/450
Tekla Common - Bottom elevation: +5.067; Top elevation: +5.775; Phase: 1; Class: 11
Tekla Quantity - Weight: 9.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.8 m2; Height: 651 mm; Width: 3 mm; Length: 788.7 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 650.982 mm; NetArea: 0.783716 m2; GrossArea: 0.513416 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00116318 m3; GrossVolume: 0.00116318 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1373
PLATE | PL/1364

# IfcPlate: PLT3*655.1 (2)
In: Undefined
Description: PLT3*655.1; Material: STEEL/450
Tekla Common - Bottom elevation: +3.407; Top elevation: +4.124; Phase: 1; Class: 11
Tekla Quantity - Weight: 8.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.6 m2; Height: 655.1 mm; Width: 3 mm; Length: 765.9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 655.1 mm; NetArea: 0.722393 m2; GrossArea: 0.501711 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00107176 m3; GrossVolume: 0.00107176 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1346
PLATE | PL/1335

# IfcPlate: PLT3*655.4 (2)
In: Undefined
Description: PLT3*655.4; Material: STEEL/450
Tekla Common - Bottom elevation: +4.749; Top elevation: +5.441; Phase: 1; Class: 11
Tekla Quantity - Weight: 9.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.8 m2; Height: 655.4 mm; Width: 3 mm; Length: 773.1 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 655.384 mm; NetArea: 0.777894 m2; GrossArea: 0.506665 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00115452 m3; GrossVolume: 0.00115452 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1700
PLATE | PL/1702

# IfcPlate: PLT3*657.6 (2)
In: Undefined
Description: PLT3*657.6; Material: STEEL/450
Tekla Common - Bottom elevation: +5.637; Top elevation: +6.323; Phase: 1; Class: 11
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.8 m2; Height: 657.6 mm; Width: 3 mm; Length: 765.2 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 657.612 mm; NetArea: 0.774956 m2; GrossArea: 0.503221 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00115015 m3; GrossVolume: 0.00115015 m3
Name | ASSEMBLY_POS = Reference | Weight (kg)
PLATE | PL/1383 | 9.1
PLATE | PL/1362 | 8.9

# IfcPlate: PLT3*664 (2)
In: Undefined
Description: PLT3*664; Material: STEEL/450
Tekla Common - Bottom elevation: +3.394; Top elevation: +4.141; Phase: 1; Class: 11
Tekla Quantity - Weight: 8.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.6 m2; Height: 664 mm; Width: 3 mm; Length: 794.4 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 664.042 mm; NetArea: 0.747322 m2; GrossArea: 0.527485 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00110891 m3; GrossVolume: 0.00110891 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1348
PLATE | PL/1337

# IfcPlate: PLT3*664.3 (2)
In: Undefined
Description: PLT3*664.3; Material: STEEL/450
Tekla Common - Bottom elevation: +5.073; Top elevation: +5.731; Phase: 1; Class: 11
Tekla Quantity - Weight: 8.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.8 m2; Height: 664.3 mm; Width: 3 mm; Length: 735.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 664.345 mm; NetArea: 0.762722 m2; GrossArea: 0.48872 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00113194 m3; GrossVolume: 0.00113194 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1385
PLATE | PL/1359

# IfcPlate: PLT3*664.5 (2)
In: Undefined
Description: PLT3*664.5; Material: STEEL/450
Tekla Common - Bottom elevation: +7.025; Top elevation: +7.849; Phase: 1; Class: 11
Tekla Quantity - Weight: 9.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.8 m2; Height: 664.5 mm; Width: 3 mm; Length: 902.3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 664.511 mm; NetArea: 0.820977 m2; GrossArea: 0.599582 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00121849 m3; GrossVolume: 0.00121849 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1379
PLATE | PL/1370

# IfcPlate: PLT3*666.8 (2)
In: Undefined
Description: PLT3*666.8; Material: STEEL/450
Tekla Common - Bottom elevation: +4.794; Top elevation: +5.438; Phase: 1; Class: 11
Tekla Quantity - Weight: 8.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.8 m2; Height: 666.8 mm; Width: 3 mm; Length: 721.4 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 666.832 mm; NetArea: 0.75628 m2; GrossArea: 0.48106 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00112235 m3; GrossVolume: 0.00112235 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1384
PLATE | PL/1358

# IfcPlate: PLT3*678.7 (2)
In: Undefined
Description: PLT3*678.7; Material: STEEL/450
Tekla Common - Bottom elevation: +3.357; Top elevation: +4.177; Phase: 1; Class: 11
Tekla Quantity - Weight: 9.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.8 m2; Height: 678.7 mm; Width: 3 mm; Length: 862.9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 678.653 mm; NetArea: 0.806843 m2; GrossArea: 0.585627 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00119758 m3; GrossVolume: 0.00119758 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1350
PLATE | PL/1339

# IfcPlate: PLT3*688.4 (2)
In: Undefined
Description: PLT3*688.4; Material: STEEL/450
Tekla Common - Bottom elevation: +4.375; Top elevation: +5.030; Phase: 1; Class: 11
Tekla Quantity - Weight: 9.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.8 m2; Height: 688.4 mm; Width: 3 mm; Length: 729.5 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 688.448 mm; NetArea: 0.777703 m2; GrossArea: 0.502238 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00115435 m3; GrossVolume: 0.00115435 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1381
PLATE | PL/1360

# IfcPlate: PLT3*700.4 (2)
In: Undefined
Description: PLT3*700.4; Material: STEEL/450
Tekla Common - Bottom elevation: +4.374; Top elevation: +5.050; Phase: 1; Class: 11
Tekla Quantity - Weight: 9.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.8 m2; Height: 700.4 mm; Width: 3 mm; Length: 749 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 700.36 mm; NetArea: 0.798964 m2; GrossArea: 0.524604 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00118608 m3; GrossVolume: 0.00118608 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1382
PLATE | PL/1361

# IfcPlate: PLT3*722.2 (2)
In: Undefined
Description: PLT3*722.2; Material: STEEL/450
Tekla Common - Bottom elevation: +4.371; Top elevation: +5.089; Phase: 1; Class: 11
Tekla Quantity - Weight: 9.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.8 m2; Height: 722.2 mm; Width: 3 mm; Length: 788.8 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 722.167 mm; NetArea: 0.842004 m2; GrossArea: 0.569655 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00125031 m3; GrossVolume: 0.00125031 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1380
PLATE | PL/1371

# IfcPlate: PLT3*727.2 (2)
In: Undefined
Description: PLT3*727.2; Material: STEEL/450
Tekla Common - Bottom elevation: +3.339; Top elevation: +4.068; Phase: 1; Class: 11
Tekla Quantity - Weight: 9.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.8 m2; Height: 727.2 mm; Width: 3 mm; Length: 798.8 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 727.227 mm; NetArea: 0.852864 m2; GrossArea: 0.580912 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00126652 m3; GrossVolume: 0.00126652 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1699
PLATE | PL/1701

# IfcPlate: PLT3*736.7 (2)
In: Undefined
Description: PLT3*736.7; Material: STEEL/450
Tekla Common - Bottom elevation: +3.368; Top elevation: +4.119; Phase: 1; Class: 11
Tekla Quantity - Weight: 10.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.8 m2; Height: 736.7 mm; Width: 3 mm; Length: 819.2 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 736.654 mm; NetArea: 0.87477 m2; GrossArea: 0.603501 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.0012992 m3; GrossVolume: 0.0012992 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1372
PLATE | PL/1363

# IfcPlate: PLT3*749.5 (2)
In: Undefined
Description: PLT3*749.5; Material: STEEL/450
Tekla Common - Bottom elevation: +3.354; Top elevation: +4.138; Phase: 1; Class: 11
Tekla Quantity - Weight: 10.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.8 m2; Height: 749.5 mm; Width: 3 mm; Length: 850.3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 749.469 mm; NetArea: 0.908039 m2; GrossArea: 0.637266 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00134884 m3; GrossVolume: 0.00134884 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1374
PLATE | PL/1365

# IfcPlate: PLT3*752.8 (2)
In: Undefined
Description: PLT3*752.8; Material: STEEL/450
Tekla Common - Bottom elevation: +5.992; Top elevation: +6.680; Phase: 1; Class: 11
Tekla Quantity - Weight: 7.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.6 m2; Height: 752.8 mm; Width: 3 mm; Length: 777.5 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 752.829 mm; NetArea: 0.64019 m2; GrossArea: 0.585294 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000949034 m3; GrossVolume: 0.000949034 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1349
PLATE | PL/1338

# IfcPlate: PLT3*760.5 (2)
In: Undefined
Description: PLT3*760.5; Material: STEEL/450
Tekla Common - Bottom elevation: +3.338; Top elevation: +4.156; Phase: 1; Class: 11
Tekla Quantity - Weight: 11 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.7 m2; Net surface area: 0.8 m2; Height: 760.5 mm; Width: 3 mm; Length: 881.9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 760.52 mm; NetArea: 0.941796 m2; GrossArea: 0.670694 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00139919 m3; GrossVolume: 0.00139919 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1376
PLATE | PL/1367

# IfcPlate: PLT3*779.2 (2)
In: Undefined
Description: PLT3*779.2; Material: STEEL/450
Tekla Common - Bottom elevation: +3.296; Top elevation: +4.196; Phase: 1; Class: 11
Tekla Quantity - Weight: 11.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.7 m2; Net surface area: 1 m2; Height: 779.2 mm; Width: 3 mm; Length: 958.1 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 779.245 mm; NetArea: 1.02296 m2; GrossArea: 0.746589 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00152025 m3; GrossVolume: 0.00152025 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1378
PLATE | PL/1369
