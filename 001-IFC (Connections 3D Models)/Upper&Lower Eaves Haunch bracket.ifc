Properties of the parts of a building model (IFC2X3), part 1 of 2

# File
Description: ViewDefinition[CoordinationView_V2.0, QuantityTakeOffAddOnView], Option [BaseQuantities:On], Option [GridExport:On], Option [Assemblies:On], Option [Bolts:On], Option [Rebars:On], Option [PourObjects:Off], Option [Welds:Off], Option [SurfaceTreatments:Off], Option [LocationBy:0], Option [ViewColors:Off], Option [SectionedSpine:Off], Option [PropertySets:On], Option [Export all:Off]
File name: 1.ifc
Time: 2026-07-16T22:21:08
Author: LAPTOP-2P0BGI6B\lablab
Organization: Structural Designer
Written by: IFC Database Version: Work
Made in: Tekla Structures 2019 Service Pack 13, IFC Export Version: 4.0.0.0 Oct 18 2021

# IfcBuildingStorey, Undefined
In: Undefined
Elevation: 0 mm

# IfcBeam: C:150-24 (30)
In: Undefined
Description: C:150-24; Material: STEEL/G450
Tekla Common - Phase: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 111.2 m2; Height: 152 mm; Width: 64 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Finish | Bottom elevation | Top elevation | Class | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
COLUMN | Z/2474 | 12 deg | +0.000 | +5.218 | 12 | 29.1 | 3.2 | 5217.7 | 5217.74 | 3.23439 | 0.00384944 | 30.2181
2 x RAFTER | Z/2473 | 12 deg | +3.626 | +5.671 | 10 | 60.8 | 6.8 | 10914 | 10914 | 6.7638 | 0.00805192 | 63.2076
COLUMN | Z/2472 | 12 deg | +0.000 | +3.807 | 12 | 21.2 | 2.4 | 3807.1 | 3807.12 | 2.36037 | 0.00280874 | 22.0486
COLUMN | Z/1858 | 25 deg | +0.000 | +7.543 | 12 | 42 | 4.7 | 7543.3 | 7543.26 | 4.67528 | 0.00556512 | 43.6862
COLUMN | Z/1693 | 25 deg | +0.000 | +3.813 | 12 | 21.2 | 2.4 | 3812.8 | 3812.81 | 2.36389 | 0.00281294 | 22.0815
COLUMN | Z/1842 | 18 deg | +0.000 | +6.431 | 12 | 35.8 | 4 | 6430.8 | 6430.8 | 3.986 | 0.00474438 | 37.2434
RAFTER | Z/1692 | 18 deg | +3.745 | +6.844 | 10 | 53.3 | 5.8 | 9560.8 | 9560.78 | 5.92534 | 0.00705356 | 55.3705
COLUMN | Z/1691 | 18 deg | +0.000 | +3.831 | 12 | 21.4 | 2.4 | 3830.7 | 3830.73 | 2.37499 | 0.00282616 | 22.1853
COLUMN | Z/1830 | 15 deg | +0.000 | +5.982 | 12 | 33.3 | 3.7 | 5981.8 | 5981.82 | 3.70781 | 0.00441315 | 34.6432
RAFTER | Z/1689 | 15 deg | +3.633 | +6.499 | 10 | 58.6 | 6.5 | 10506.2 | 10506.2 | 6.5111 | 0.00775103 | 60.8456
COLUMN | Z/1688 | 15 deg | +0.000 | +3.838 | 12 | 21.4 | 2.4 | 3838.2 | 3838.23 | 2.37964 | 0.00283169 | 22.2288
RAFTER | Z/1673 | 12 deg | +3.626 | +6.043 | 10 | 60.8 | 6.8 | 10914 | 10914 | 6.7638 | 0.00805192 | 63.2076
COLUMN | Z/1672 | 12 deg | +0.000 | +3.844 | 12 | 21.4 | 2.4 | 3844.4 | 3844.4 | 2.38347 | 0.00283625 | 22.2645
RAFTER | Z/1702 | 9 deg | +4.797 | +6.340 | 10 | 49.6 | 5.5 | 8901.5 | 8901.5 | 5.51685 | 0.00656717 | 51.5523
COLUMN | Z/1701 | 9 deg | +0.000 | +4.846 | 12 | 26.9 | 2.9 | 4845.8 | 4845.81 | 3.00394 | 0.00357505 | 28.0641
RAFTER | Z/1699 | 5 deg | +4.819 | +5.741 | 10 | 49.3 | 5.5 | 8844.6 | 8844.6 | 5.48159 | 0.00652519 | 51.2228
COLUMN | Z/1698 | 5 deg | +0.000 | +4.847 | 12 | 26.9 | 2.9 | 4847.1 | 4847.12 | 3.00475 | 0.00357601 | 28.0717
RAFTER | Z/1696 | 3 deg | +4.830 | +5.444 | 10 | 49.2 | 5.5 | 8830.8 | 8830.76 | 5.47302 | 0.00651498 | 51.1426
COLUMN | Z/1695 | 3 deg | +0.000 | +4.848 | 12 | 26.9 | 2.9 | 4847.6 | 4847.59 | 3.00504 | 0.00357636 | 28.0744
COLUMN | Z/1687 | 12 deg | +0.000 | +5.545 | 12 | 30.9 | 3.4 | 5544.9 | 5544.86 | 3.43707 | 0.00409077 | 32.1126
COLUMN | Z/1703 | 9 deg | +0.000 | +6.113 | 12 | 34.1 | 3.8 | 6112.9 | 6112.89 | 3.78902 | 0.00450985 | 35.4023
COLUMN | Z/1700 | 5 deg | +0.000 | +5.547 | 12 | 30.9 | 3.4 | 5547 | 5547.03 | 3.43842 | 0.00409238 | 32.1252
COLUMN | Z/1697 | 3 deg | +0.000 | +5.267 | 12 | 29.4 | 3.3 | 5266.8 | 5266.85 | 3.26481 | 0.00388567 | 30.5025
RAFTER | Z/2325 | 9 deg | +4.797 | +6.340 | 10 | 49.6 | 5.5 | 8901.5 | 8901.5 | 5.51685 | 0.00656717 | 51.5523
RAFTER | Z/2322 | 5 deg | +4.819 | +5.741 | 10 | 49.3 | 5.5 | 8844.6 | 8844.6 | 5.48159 | 0.00652519 | 51.2228
RAFTER | Z/2318 | 3 deg | +4.830 | +5.444 | 10 | 49.2 | 5.5 | 8830.8 | 8830.76 | 5.47302 | 0.00651498 | 51.1426
RAFTER | Z/2310 | 18 deg | +3.745 | +6.844 | 10 | 53.3 | 5.8 | 9560.8 | 9560.78 | 5.92534 | 0.00705356 | 55.3705
RAFTER | Z/2306 | 15 deg | +3.633 | +6.499 | 10 | 58.6 | 6.5 | 10506.2 | 10506.2 | 6.5111 | 0.00775103 | 60.8456
RAFTER | Z/2304 | 12 deg | +3.626 | +6.043 | 10 | 60.8 | 6.8 | 10914 | 10914 | 6.7638 | 0.00805192 | 63.2076

# IfcBeam: C:200-24 (30)
In: Undefined
Description: C:200-24; Material: STEEL/G450
Tekla Common - Phase: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 203 mm; Width: 76 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Finish | Bottom elevation | Top elevation | Class | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
COLUMN | Z/2477 | 12 deg | +0.000 | +5.168 | 12 | 36.6 | 110 | 4 | 5167.7 | 5167.72 | 4.03062 | 0.00480474 | 37.7172
2 x RAFTER | Z/2476 | 12 deg | +3.587 | +5.675 | 10 | 77.1 | 110 | 8.5 | 10877.1 | 10877.1 | 8.48165 | 0.0101131 | 79.3878
COLUMN | Z/2475 | 12 deg | +0.000 | +3.757 | 12 | 26.6 | 110.1 | 2.9 | 3757.1 | 3757.11 | 2.9309 | 0.00349321 | 27.4217
COLUMN | Z/2104 | 25 deg | +0.000 | +7.480 | 12 | 53 | 110 | 5.8 | 7480.4 | 7480.42 | 5.8336 | 0.006955 | 54.5967
COLUMN | Z/1713 | 25 deg | +0.000 | +3.750 | 12 | 26.6 | 110.1 | 2.9 | 3750 | 3749.95 | 2.92532 | 0.00348656 | 27.3695
COLUMN | Z/2103 | 18 deg | +0.000 | +6.374 | 12 | 45.2 | 110 | 5 | 6374.2 | 6374.21 | 4.97119 | 0.00592648 | 46.5229
2 x RAFTER | Z/1712 | 18 deg | +3.648 | +6.844 | 10 | 68.9 | 110 | 7.6 | 9717.4 | 9717.4 | 7.57754 | 0.00903485 | 70.9236
COLUMN | Z/1711 | 18 deg | +0.000 | +3.775 | 12 | 26.8 | 110 | 2.9 | 3774.8 | 3774.84 | 2.94472 | 0.00350969 | 27.5511
COLUMN | Z/2102 | 15 deg | +0.000 | +5.928 | 12 | 42 | 110 | 4.7 | 5927.5 | 5927.51 | 4.62295 | 0.00551116 | 43.2626
2 x RAFTER | Z/1710 | 15 deg | +3.622 | +6.501 | 10 | 73.5 | 110 | 8 | 10366.1 | 10366.1 | 8.08327 | 0.00963798 | 75.6582
COLUMN | Z/1709 | 15 deg | +0.000 | +3.784 | 12 | 26.8 | 110 | 2.9 | 3783.9 | 3783.91 | 2.95179 | 0.00351813 | 27.6173
2 x RAFTER | Z/1707 | 12 deg | +3.587 | +6.047 | 10 | 77.1 | 110 | 8.5 | 10877.1 | 10877.1 | 8.48165 | 0.0101131 | 79.3878
COLUMN | Z/1706 | 12 deg | +0.000 | +3.792 | 12 | 26.9 | 110 | 2.9 | 3792.2 | 3792.16 | 2.95823 | 0.0035258 | 27.6775
2 x RAFTER | Z/1722 | 9 deg | +4.755 | +6.338 | 10 | 62.7 | 110 | 6.8 | 8841.8 | 8841.79 | 6.89492 | 0.00822074 | 64.5328
COLUMN | Z/1721 | 9 deg | +0.000 | +4.794 | 12 | 34 | 110 | 3.7 | 4794.2 | 4794.17 | 3.73939 | 0.00445742 | 34.9908
2 x RAFTER | Z/1719 | 5 deg | +4.773 | +5.741 | 10 | 62.3 | 110 | 6.8 | 8788.9 | 8788.95 | 6.85372 | 0.00817161 | 64.1472
COLUMN | Z/1718 | 5 deg | +0.000 | +4.796 | 12 | 34 | 110 | 3.7 | 4795.9 | 4795.92 | 3.74076 | 0.00445905 | 35.0035
2 x RAFTER | Z/1716 | 3 deg | +4.782 | +5.444 | 10 | 62.2 | 110 | 6.8 | 8777 | 8777.03 | 6.84443 | 0.00816053 | 64.0602
COLUMN | Z/1715 | 3 deg | +0.000 | +4.796 | 12 | 34 | 110 | 3.7 | 4796.4 | 4796.42 | 3.74115 | 0.00445952 | 35.0072
COLUMN | Z/1708 | 12 deg | +0.000 | +5.493 | 12 | 38.9 | 110 | 4.3 | 5492.6 | 5492.61 | 4.2839 | 0.00510681 | 40.0885
COLUMN | Z/1723 | 9 deg | +0.000 | +6.061 | 12 | 43 | 110 | 4.7 | 6061.2 | 6061.25 | 4.72721 | 0.00563551 | 44.2387
COLUMN | Z/1720 | 5 deg | +0.000 | +5.496 | 12 | 38.9 | 110 | 4.3 | 5495.8 | 5495.83 | 4.28641 | 0.0051098 | 40.112
COLUMN | Z/1717 | 3 deg | +0.000 | +5.216 | 12 | 37 | 110 | 4.1 | 5215.7 | 5215.69 | 4.06801 | 0.00484934 | 38.0673

# IfcBeam: C:250-24 (30)
In: Undefined
Description: C:250-24; Material: STEEL/G450
Tekla Common - Phase: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 109.7 m2; Height: 254 mm; Width: 76 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Finish | Bottom elevation | Top elevation | Class | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
COLUMN | Z/2480 | 12 deg | +0.000 | +5.118 | 12 | 41.1 | 4.5 | 5117.7 | 5117.71 | 4.50364 | 0.00537237 | 42.1731
2 x RAFTER | Z/2479 | 12 deg | +3.547 | +5.680 | 10 | 87 | 9.5 | 10840.2 | 10840.2 | 9.53714 | 0.0113796 | 89.3299
COLUMN | Z/2478 | 12 deg | +0.000 | +3.707 | 12 | 29.7 | 3.3 | 3707.1 | 3707.1 | 3.26287 | 0.00389157 | 30.5488
COLUMN | Z/2236 | 25 deg | +0.000 | +8.425 | 12 | 67.6 | 7.4 | 8424.6 | 8424.61 | 7.41239 | 0.00884382 | 69.424
COLUMN | Z/2235 | 25 deg | +0.000 | +4.694 | 12 | 37.7 | 4.1 | 4694.1 | 4694.15 | 4.13107 | 0.00492773 | 38.6827
COLUMN | Z/2234 | 18 deg | +0.000 | +7.325 | 12 | 58.8 | 6.5 | 7324.7 | 7324.65 | 6.44486 | 0.00768913 | 60.3597
2 x RAFTER | Z/1730 | 18 deg | +4.605 | +7.851 | 10 | 78 | 8.5 | 9724 | 9724.01 | 8.55534 | 0.0102079 | 80.1318
COLUMN | Z/2233 | 18 deg | +0.000 | +4.725 | 12 | 37.9 | 4.1 | 4725.3 | 4725.29 | 4.15847 | 0.00496042 | 38.9393
COLUMN | Z/2175 | 15 deg | +0.000 | +6.880 | 12 | 55.2 | 6.2 | 6880.2 | 6880.23 | 6.05395 | 0.00722259 | 56.6973
2 x RAFTER | Z/1729 | 15 deg | +4.579 | +7.432 | 10 | 80.8 | 8.9 | 10076 | 10076 | 8.86498 | 0.0105774 | 83.0328
COLUMN | Z/2174 | 15 deg | +0.000 | +4.737 | 12 | 38 | 4.1 | 4736.6 | 4736.63 | 4.16844 | 0.00497233 | 39.0328
2 x RAFTER | Z/1727 | 12 deg | +3.547 | +6.050 | 10 | 87 | 9.5 | 10840.2 | 10840.2 | 9.53714 | 0.0113796 | 89.3299
COLUMN | Z/1726 | 12 deg | +0.000 | +3.740 | 12 | 30 | 3.3 | 3739.9 | 3739.92 | 3.29174 | 0.00392602 | 30.8193
2 x RAFTER | Z/1739 | 9 deg | +4.689 | +6.360 | 10 | 72.9 | 8 | 9082.1 | 9082.08 | 7.99069 | 0.009534 | 74.8419
COLUMN | Z/1738 | 9 deg | +0.000 | +4.742 | 12 | 38 | 4.1 | 4742.4 | 4742.42 | 4.17354 | 0.00497841 | 39.0805
2 x RAFTER | Z/1736 | 5 deg | +4.713 | +5.753 | 10 | 72.5 | 8 | 9033.3 | 9033.29 | 7.94778 | 0.00948278 | 74.4399
COLUMN | Z/1735 | 5 deg | +0.000 | +4.745 | 12 | 38.1 | 4.1 | 4744.6 | 4744.63 | 4.17547 | 0.00498072 | 39.0986
2 x RAFTER | Z/1733 | 3 deg | +4.726 | +5.452 | 10 | 72.5 | 8 | 9023.3 | 9023.3 | 7.93899 | 0.0094723 | 74.3575
COLUMN | Z/1732 | 3 deg | +0.000 | +4.745 | 12 | 38.1 | 4.1 | 4745.2 | 4745.25 | 4.17602 | 0.00498137 | 39.1038
COLUMN | Z/1728 | 12 deg | +0.000 | +5.440 | 12 | 43.6 | 4.8 | 5440.4 | 5440.37 | 4.78745 | 0.00571109 | 44.832
COLUMN | Z/1740 | 9 deg | +0.000 | +6.009 | 12 | 48.2 | 5.3 | 6009.5 | 6009.5 | 5.28806 | 0.00630853 | 49.522
COLUMN | Z/1737 | 5 deg | +0.000 | +5.445 | 12 | 43.7 | 4.8 | 5444.5 | 5444.54 | 4.79111 | 0.00571546 | 44.8663
COLUMN | Z/1734 | 3 deg | +0.000 | +5.165 | 12 | 41.4 | 4.5 | 5164.5 | 5164.51 | 4.5448 | 0.0054215 | 42.5588

# IfcBeam: C:300-30 (30)
In: Undefined
Description: C:300-30; Material: STEEL/G450
Tekla Common - Phase: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.4 m2; Height: 300 mm; Width: 96 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Finish | Bottom elevation | Top elevation | Class | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
COLUMN | Z/2483 | 12 deg | +0.000 | +5.073 | 12 | 63.4 | 5.5 | 5073.1 | 5073.1 | 5.54308 | 0.00826408 | 64.873
2 x RAFTER | Z/2482 | 12 deg | +3.513 | +5.685 | 10 | 135.1 | 11.8 | 10806.9 | 10806.9 | 11.8044 | 0.0176044 | 138.195
COLUMN | Z/2481 | 12 deg | +0.000 | +3.662 | 12 | 45.8 | 4 | 3662.5 | 3662.48 | 4.00268 | 0.00596617 | 46.8345
COLUMN | Z/2254 | 25 deg | +0.000 | +7.361 | 12 | 92.1 | 8 | 7361.4 | 7361.38 | 8.04189 | 0.0119917 | 94.1348
COLUMN | Z/2253 | 25 deg | +0.000 | +3.631 | 12 | 45.4 | 4 | 3630.9 | 3630.92 | 3.96822 | 0.00591477 | 46.4309
COLUMN | Z/2252 | 18 deg | +0.000 | +6.267 | 12 | 78.4 | 6.8 | 6267.1 | 6267.06 | 6.84688 | 0.010209 | 80.1409
2 x RAFTER | Z/1747 | 18 deg | +3.505 | +6.845 | 10 | 123.6 | 10.8 | 9884.9 | 9884.88 | 10.7975 | 0.0161025 | 126.404
COLUMN | Z/2251 | 18 deg | +0.000 | +3.668 | 12 | 45.9 | 4 | 3667.7 | 3667.7 | 4.00839 | 0.00597468 | 46.9013
COLUMN | Z/2250 | 15 deg | +0.000 | +5.825 | 12 | 72.8 | 6.5 | 5824.7 | 5824.69 | 6.36382 | 0.00948842 | 74.4841
2 x RAFTER | Z/1746 | 15 deg | +3.526 | +6.376 | 10 | 123.6 | 10.8 | 9889.9 | 9889.9 | 10.803 | 0.0161106 | 126.469
COLUMN | Z/2249 | 15 deg | +0.000 | +3.681 | 12 | 45.9 | 4 | 3681.1 | 3681.1 | 4.02301 | 0.00599651 | 47.0726
2 x RAFTER | Z/1744 | 12 deg | +3.513 | +6.053 | 10 | 135.1 | 11.8 | 10806.9 | 10806.9 | 11.8044 | 0.0176044 | 138.195
COLUMN | Z/1743 | 12 deg | +0.000 | +3.693 | 12 | 46.2 | 4 | 3693.3 | 3693.29 | 4.03633 | 0.00601636 | 47.2284
2 x RAFTER | Z/1756 | 9 deg | +4.596 | +6.414 | 10 | 121.7 | 10.6 | 9728.2 | 9728.22 | 10.6265 | 0.0158473 | 124.401
COLUMN | Z/1755 | 9 deg | +0.000 | +4.696 | 12 | 58.7 | 5.1 | 4696.3 | 4696.25 | 5.13156 | 0.00765019 | 60.054
2 x RAFTER | Z/1753 | 5 deg | +4.641 | +5.784 | 10 | 121.1 | 10.6 | 9683.1 | 9683.09 | 10.5772 | 0.0157738 | 123.824
COLUMN | Z/1752 | 5 deg | +0.000 | +4.699 | 12 | 58.8 | 5.1 | 4698.9 | 4698.85 | 5.1344 | 0.00765443 | 60.0872
2 x RAFTER | Z/1750 | 3 deg | +4.664 | +5.470 | 10 | 121 | 10.6 | 9674.8 | 9674.83 | 10.5682 | 0.0157603 | 123.718
COLUMN | Z/1749 | 3 deg | +0.000 | +4.700 | 12 | 58.8 | 5.1 | 4699.6 | 4699.57 | 5.13519 | 0.0076556 | 60.0965
COLUMN | Z/1745 | 12 deg | +0.000 | +5.394 | 12 | 67.4 | 5.8 | 5393.7 | 5393.74 | 5.89322 | 0.0087864 | 68.9732
COLUMN | Z/1757 | 9 deg | +0.000 | +5.963 | 12 | 74.6 | 6.5 | 5963.3 | 5963.32 | 6.5152 | 0.00971425 | 76.2568
COLUMN | Z/1754 | 5 deg | +0.000 | +5.399 | 12 | 67.4 | 5.8 | 5398.8 | 5398.75 | 5.89869 | 0.00879456 | 69.0373
COLUMN | Z/1751 | 3 deg | +0.000 | +5.119 | 12 | 64 | 5.6 | 5118.8 | 5118.84 | 5.59303 | 0.00833859 | 65.4579

# IfcBeam: C:350-30 (30)
In: Undefined
Description: C:350-30; Material: STEEL/G450
Tekla Common - Phase: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.1 m2; Height: 350 mm; Width: 125 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Finish | Bottom elevation | Top elevation | Class | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
COLUMN | Z/2423 | 12 deg | +0.000 | +5.024 | 12 | 75.1 | 6.5 | 5024.2 | 5024.17 | 6.54536 | 0.00976699 | 76.6709
2 x RAFTER | Z/2422 | 12 deg | +3.474 | +5.689 | 10 | 161.1 | 14 | 10770.7 | 10770.7 | 14.0274 | 0.0209383 | 164.365
COLUMN | Z/2421 | 12 deg | +0.000 | +3.614 | 12 | 54 | 4.7 | 3613.6 | 3613.55 | 4.70873 | 0.00702474 | 55.1442
COLUMN | Z/2272 | 25 deg | +0.000 | +7.300 | 12 | 109.2 | 9.5 | 7299.9 | 7299.86 | 9.50831 | 0.0141909 | 111.399
COLUMN | Z/2271 | 25 deg | +0.000 | +3.569 | 12 | 53.4 | 4.7 | 3569.4 | 3569.4 | 4.65125 | 0.00693892 | 54.4705
COLUMN | Z/2270 | 18 deg | +0.000 | +6.212 | 12 | 92.9 | 8 | 6211.7 | 6211.67 | 8.09148 | 0.0120755 | 94.7925
2 x RAFTER | Z/1764 | 18 deg | +3.486 | +7.000 | 10 | 153.9 | 13.4 | 10292.4 | 10292.4 | 13.4045 | 0.0200083 | 157.065
COLUMN | Z/2269 | 18 deg | +0.000 | +3.612 | 12 | 54 | 4.7 | 3612.3 | 3612.31 | 4.70712 | 0.00702233 | 55.1253
COLUMN | Z/2268 | 15 deg | +0.000 | +5.772 | 12 | 86.3 | 7.4 | 5771.5 | 5771.54 | 7.51843 | 0.0112199 | 88.0759
2 x RAFTER | Z/1763 | 15 deg | +3.529 | +6.377 | 10 | 145.1 | 12.6 | 9700.6 | 9700.62 | 12.6341 | 0.018858 | 148.035
COLUMN | Z/2267 | 15 deg | +0.000 | +3.628 | 12 | 54.3 | 4.7 | 3627.9 | 3627.95 | 4.72747 | 0.00705273 | 55.3639
2 x RAFTER | Z/1761 | 12 deg | +3.474 | +6.056 | 10 | 161.1 | 14 | 10770.7 | 10770.7 | 14.0274 | 0.0209383 | 164.365
COLUMN | Z/1760 | 12 deg | +0.000 | +3.642 | 12 | 54.5 | 4.7 | 3642.2 | 3642.17 | 4.74599 | 0.00708038 | 55.581
2 x RAFTER | Z/1773 | 9 deg | +4.555 | +6.413 | 10 | 144.6 | 12.6 | 9669.7 | 9669.67 | 12.5938 | 0.0187978 | 147.563
COLUMN | Z/1772 | 9 deg | +0.000 | +4.646 | 12 | 69.4 | 6.2 | 4645.6 | 4645.64 | 6.05251 | 0.00903112 | 70.8943
2 x RAFTER | Z/1770 | 5 deg | +4.596 | +5.784 | 10 | 144 | 12.5 | 9628.5 | 9628.52 | 12.5402 | 0.0187178 | 146.935
COLUMN | Z/1769 | 5 deg | +0.000 | +4.649 | 12 | 69.4 | 6.2 | 4648.7 | 4648.66 | 6.05644 | 0.00903699 | 70.9404
2 x RAFTER | Z/1767 | 3 deg | +4.617 | +5.470 | 10 | 144 | 12.5 | 9622.1 | 9622.13 | 12.5319 | 0.0187054 | 146.838
COLUMN | Z/1766 | 3 deg | +0.000 | +4.650 | 12 | 69.4 | 6.2 | 4649.5 | 4649.52 | 6.05756 | 0.00903866 | 70.9535
COLUMN | Z/1762 | 12 deg | +0.000 | +5.343 | 12 | 79.9 | 7 | 5342.6 | 5342.62 | 6.95998 | 0.0103861 | 81.5306
COLUMN | Z/1774 | 9 deg | +0.000 | +5.913 | 12 | 88.4 | 7.6 | 5912.7 | 5912.71 | 7.70223 | 0.0114943 | 90.2303
COLUMN | Z/1771 | 5 deg | +0.000 | +5.349 | 12 | 79.9 | 7 | 5348.6 | 5348.57 | 6.96772 | 0.0103976 | 81.6213
COLUMN | Z/1768 | 3 deg | +0.000 | +5.069 | 12 | 75.8 | 6.6 | 5068.8 | 5068.78 | 6.60344 | 0.0098537 | 77.3516

# IfcBeam: TH:120-120 (14)
In: Undefined
Description: TH:120-120; Material: STEEL/300PLUS
Default - ASSEMBLY_POS: B/63
Tekla Common - Phase: 1; Class: 4
Tekla Quantity - Weight: 1.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 0 m2; Net surface area: 0.6 m2; Height: 120 mm; Width: 165 mm; Length: 1000 mm
Pset_BeamCommon - LoadBearing: no; Reference: B/63
BaseQuantities - Length: 1000 mm; OuterSurfaceArea: 4.5602e-07 m2; NetVolume: 0.000420979 m3; NetWeight: 3.30468 kg
Name | Bottom elevation | Top elevation
2 x TH | +5.223 | +5.358
2 x TH | +5.124 | +5.253
2 x TH | +5.074 | +5.200
2 x TH | +4.485 | +4.638
2 x TH | +4.435 | +4.581
2 x TH | +4.380 | +4.523
2 x TH | +4.236 | +4.376

# IfcBeam: TH:64-95 (16)
In: Undefined
Description: TH:64-95; Material: STEEL/300PLUS
Tekla Common - Phase: 1; Class: 4
Tekla Quantity - Weight: 1.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 0 m2; Net surface area: 0.3 m2; Height: 64 mm; Width: 130 mm; Length: 1000 mm
Pset_BeamCommon - LoadBearing: no
BaseQuantities - Length: 1000 mm; OuterSurfaceArea: 4.5602e-07 m2; NetVolume: 0.000215558 m3; NetWeight: 1.69213 kg
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation
2 x TH | B/11 | +4.251 | +4.328
2 x TH | B/11 | +5.257 | +5.333
2 x TH | B/11 | +5.143 | +5.214
2 x TH | B/11 | +5.086 | +5.154
2 x TH | B/11 | +4.577 | +4.670
2 x TH | B/82 | +4.502 | +4.588
2 x TH | B/82 | +4.424 | +4.507
2 x TH | B/82 | +4.344 | +4.424

# IfcBeam: TH:75-95 (66)
In: Undefined
Description: TH:75-95; Material: STEEL/300PLUS
Default - ASSEMBLY_POS: B/5
Tekla Common - Phase: 1; Class: 4
Tekla Quantity - Weight: 1.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 0 m2; Net surface area: 0.5 m2; Height: 75 mm; Width: 125 mm; Length: 1000 mm
Pset_BeamCommon - LoadBearing: no; Reference: B/5
BaseQuantities - Length: 1000 mm; OuterSurfaceArea: 4.5602e-07 m2; NetVolume: 0.000231901 m3; NetWeight: 1.82042 kg
Name | Bottom elevation | Top elevation
2 x TH | +4.279 | +4.367
2 x TH | +4.271 | +4.359
2 x TH | +4.264 | +4.352
2 x TH | +4.258 | +4.346
2 x TH | +4.317 | +4.407
2 x TH | +4.688 | +4.790
2 x TH | +4.684 | +4.786
2 x TH | +5.688 | +5.790
2 x TH | +4.678 | +4.780
2 x TH | +4.521 | +4.617
2 x TH | +4.520 | +4.616
2 x TH | +5.519 | +5.615
2 x TH | +4.507 | +4.603
2 x TH | +4.444 | +4.537
2 x TH | +4.439 | +4.532
2 x TH | +5.441 | +5.534
2 x TH | +4.429 | +4.522
2 x TH | +4.365 | +4.455
2 x TH | +4.360 | +4.450
2 x TH | +4.355 | +4.445
2 x TH | +4.349 | +4.440
2 x TH | +5.270 | +5.356
2 x TH | +5.266 | +5.352
2 x TH | +5.262 | +5.349
2 x TH | +5.259 | +5.345
2 x TH | +5.151 | +5.233
2 x TH | +5.149 | +5.230
2 x TH | +5.146 | +5.228
2 x TH | +5.145 | +5.226
2 x TH | +5.091 | +5.170
2 x TH | +5.089 | +5.168
2 x TH | +5.087 | +5.166
2 x TH | +5.086 | +5.165

# IfcBeam: TH:96-95 (2)
In: Undefined
Description: TH:96-95; Material: STEEL/300PLUS
Default - ASSEMBLY_POS: B/67
Tekla Common - Bottom elevation: +4.284; Top elevation: +4.397; Phase: 1; Class: 4
Tekla Quantity - Weight: 1.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 0 m2; Net surface area: 0.6 m2; Height: 96 mm; Width: 150 mm; Length: 1000 mm
Pset_BeamCommon - LoadBearing: no; Reference: B/67
BaseQuantities - Length: 1000 mm; OuterSurfaceArea: 4.5602e-07 m2; NetVolume: 0.000287172 m3; NetWeight: 2.2543 kg

# IfcColumn: C:150-24 (16)
In: Undefined
Description: C:150-24; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Phase: 1; Class: 12
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 111.2 m2; Height: 152 mm; Width: 64 mm
Pset_ColumnCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Finish | Top elevation | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
COLUMN | Z/2472 | 12 deg | +3.807 | 21.2 | 2.4 | 3807.1 | 3807.12 | 2.36037 | 0.00280874 | 22.0486
COLUMN | Z/2474 | 12 deg | +5.218 | 29.1 | 3.2 | 5217.7 | 5217.74 | 3.23439 | 0.00384944 | 30.2181
COLUMN | Z/1687 | 12 deg | +5.545 | 30.9 | 3.4 | 5544.9 | 5544.86 | 3.43707 | 0.00409077 | 32.1126
COLUMN | Z/1703 | 9 deg | +6.113 | 34.1 | 3.8 | 6112.9 | 6112.89 | 3.78902 | 0.00450985 | 35.4023
COLUMN | Z/1700 | 5 deg | +5.547 | 30.9 | 3.4 | 5547 | 5547.03 | 3.43842 | 0.00409238 | 32.1252
COLUMN | Z/1697 | 3 deg | +5.267 | 29.4 | 3.3 | 5266.8 | 5266.85 | 3.26481 | 0.00388567 | 30.5025
COLUMN | Z/1858 | 25 deg | +7.543 | 42 | 4.7 | 7543.3 | 7543.26 | 4.67528 | 0.00556512 | 43.6862
COLUMN | Z/1842 | 18 deg | +6.431 | 35.8 | 4 | 6430.8 | 6430.8 | 3.986 | 0.00474438 | 37.2434
COLUMN | Z/1830 | 15 deg | +5.982 | 33.3 | 3.7 | 5981.8 | 5981.82 | 3.70781 | 0.00441315 | 34.6432
COLUMN | Z/1701 | 9 deg | +4.846 | 26.9 | 2.9 | 4845.8 | 4845.81 | 3.00394 | 0.00357505 | 28.0641
COLUMN | Z/1698 | 5 deg | +4.847 | 26.9 | 2.9 | 4847.1 | 4847.12 | 3.00475 | 0.00357601 | 28.0717
COLUMN | Z/1695 | 3 deg | +4.848 | 26.9 | 2.9 | 4847.6 | 4847.59 | 3.00504 | 0.00357636 | 28.0744
COLUMN | Z/1693 | 25 deg | +3.813 | 21.2 | 2.4 | 3812.8 | 3812.81 | 2.36389 | 0.00281294 | 22.0815
COLUMN | Z/1691 | 18 deg | +3.831 | 21.4 | 2.4 | 3830.7 | 3830.73 | 2.37499 | 0.00282616 | 22.1853
COLUMN | Z/1688 | 15 deg | +3.838 | 21.4 | 2.4 | 3838.2 | 3838.23 | 2.37964 | 0.00283169 | 22.2288
COLUMN | Z/1672 | 12 deg | +3.844 | 21.4 | 2.4 | 3844.4 | 3844.4 | 2.38347 | 0.00283625 | 22.2645

# IfcColumn: C:200-24 (16)
In: Undefined
Description: C:200-24; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Phase: 1; Class: 12
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 203 mm; Width: 76 mm
Pset_ColumnCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Finish | Top elevation | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
COLUMN | Z/2475 | 12 deg | +3.757 | 26.6 | 110.1 | 2.9 | 3757.1 | 3757.11 | 2.9309 | 0.00349321 | 27.4217
COLUMN | Z/2477 | 12 deg | +5.168 | 36.6 | 110 | 4 | 5167.7 | 5167.72 | 4.03062 | 0.00480474 | 37.7172
COLUMN | Z/1708 | 12 deg | +5.493 | 38.9 | 110 | 4.3 | 5492.6 | 5492.61 | 4.2839 | 0.00510681 | 40.0885
COLUMN | Z/1723 | 9 deg | +6.061 | 43 | 110 | 4.7 | 6061.2 | 6061.25 | 4.72721 | 0.00563551 | 44.2387
COLUMN | Z/1720 | 5 deg | +5.496 | 38.9 | 110 | 4.3 | 5495.8 | 5495.83 | 4.28641 | 0.0051098 | 40.112
COLUMN | Z/1717 | 3 deg | +5.216 | 37 | 110 | 4.1 | 5215.7 | 5215.69 | 4.06801 | 0.00484934 | 38.0673
COLUMN | Z/2104 | 25 deg | +7.480 | 53 | 110 | 5.8 | 7480.4 | 7480.42 | 5.8336 | 0.006955 | 54.5967
COLUMN | Z/2103 | 18 deg | +6.374 | 45.2 | 110 | 5 | 6374.2 | 6374.21 | 4.97119 | 0.00592648 | 46.5229
COLUMN | Z/2102 | 15 deg | +5.928 | 42 | 110 | 4.7 | 5927.5 | 5927.51 | 4.62295 | 0.00551116 | 43.2626
COLUMN | Z/1721 | 9 deg | +4.794 | 34 | 110 | 3.7 | 4794.2 | 4794.17 | 3.73939 | 0.00445742 | 34.9908
COLUMN | Z/1718 | 5 deg | +4.796 | 34 | 110 | 3.7 | 4795.9 | 4795.92 | 3.74076 | 0.00445905 | 35.0035
COLUMN | Z/1715 | 3 deg | +4.796 | 34 | 110 | 3.7 | 4796.4 | 4796.42 | 3.74115 | 0.00445952 | 35.0072
COLUMN | Z/1713 | 25 deg | +3.750 | 26.6 | 110.1 | 2.9 | 3750 | 3749.95 | 2.92532 | 0.00348656 | 27.3695
COLUMN | Z/1711 | 18 deg | +3.775 | 26.8 | 110 | 2.9 | 3774.8 | 3774.84 | 2.94472 | 0.00350969 | 27.5511
COLUMN | Z/1709 | 15 deg | +3.784 | 26.8 | 110 | 2.9 | 3783.9 | 3783.91 | 2.95179 | 0.00351813 | 27.6173
COLUMN | Z/1706 | 12 deg | +3.792 | 26.9 | 110 | 2.9 | 3792.2 | 3792.16 | 2.95823 | 0.0035258 | 27.6775

# IfcColumn: C:250-24 (16)
In: Undefined
Description: C:250-24; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Phase: 1; Class: 12
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 109.7 m2; Height: 254 mm; Width: 76 mm
Pset_ColumnCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Finish | Top elevation | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
COLUMN | Z/2478 | 12 deg | +3.707 | 29.7 | 3.3 | 3707.1 | 3707.1 | 3.26287 | 0.00389157 | 30.5488
COLUMN | Z/2480 | 12 deg | +5.118 | 41.1 | 4.5 | 5117.7 | 5117.71 | 4.50364 | 0.00537237 | 42.1731
COLUMN | Z/1728 | 12 deg | +5.440 | 43.6 | 4.8 | 5440.4 | 5440.37 | 4.78745 | 0.00571109 | 44.832
COLUMN | Z/1740 | 9 deg | +6.009 | 48.2 | 5.3 | 6009.5 | 6009.5 | 5.28806 | 0.00630853 | 49.522
COLUMN | Z/1737 | 5 deg | +5.445 | 43.7 | 4.8 | 5444.5 | 5444.54 | 4.79111 | 0.00571546 | 44.8663
COLUMN | Z/1734 | 3 deg | +5.165 | 41.4 | 4.5 | 5164.5 | 5164.51 | 4.5448 | 0.0054215 | 42.5588
COLUMN | Z/2236 | 25 deg | +8.425 | 67.6 | 7.4 | 8424.6 | 8424.61 | 7.41239 | 0.00884382 | 69.424
COLUMN | Z/2234 | 18 deg | +7.325 | 58.8 | 6.5 | 7324.7 | 7324.65 | 6.44486 | 0.00768913 | 60.3597
COLUMN | Z/2175 | 15 deg | +6.880 | 55.2 | 6.2 | 6880.2 | 6880.23 | 6.05395 | 0.00722259 | 56.6973
COLUMN | Z/1738 | 9 deg | +4.742 | 38 | 4.1 | 4742.4 | 4742.42 | 4.17354 | 0.00497841 | 39.0805
COLUMN | Z/1735 | 5 deg | +4.745 | 38.1 | 4.1 | 4744.6 | 4744.63 | 4.17547 | 0.00498072 | 39.0986
COLUMN | Z/1732 | 3 deg | +4.745 | 38.1 | 4.1 | 4745.2 | 4745.25 | 4.17602 | 0.00498137 | 39.1038
COLUMN | Z/2235 | 25 deg | +4.694 | 37.7 | 4.1 | 4694.1 | 4694.15 | 4.13107 | 0.00492773 | 38.6827
COLUMN | Z/2233 | 18 deg | +4.725 | 37.9 | 4.1 | 4725.3 | 4725.29 | 4.15847 | 0.00496042 | 38.9393
COLUMN | Z/2174 | 15 deg | +4.737 | 38 | 4.1 | 4736.6 | 4736.63 | 4.16844 | 0.00497233 | 39.0328
COLUMN | Z/1726 | 12 deg | +3.740 | 30 | 3.3 | 3739.9 | 3739.92 | 3.29174 | 0.00392602 | 30.8193

# IfcColumn: C:300-30 (16)
In: Undefined
Description: C:300-30; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Phase: 1; Class: 12
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.4 m2; Height: 300 mm; Width: 96 mm
Pset_ColumnCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Finish | Top elevation | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
COLUMN | Z/2481 | 12 deg | +3.662 | 45.8 | 4 | 3662.5 | 3662.48 | 4.00268 | 0.00596617 | 46.8345
COLUMN | Z/2483 | 12 deg | +5.073 | 63.4 | 5.5 | 5073.1 | 5073.1 | 5.54308 | 0.00826408 | 64.873
COLUMN | Z/1745 | 12 deg | +5.394 | 67.4 | 5.8 | 5393.7 | 5393.74 | 5.89322 | 0.0087864 | 68.9732
COLUMN | Z/1757 | 9 deg | +5.963 | 74.6 | 6.5 | 5963.3 | 5963.32 | 6.5152 | 0.00971425 | 76.2568
COLUMN | Z/1754 | 5 deg | +5.399 | 67.4 | 5.8 | 5398.8 | 5398.75 | 5.89869 | 0.00879456 | 69.0373
COLUMN | Z/1751 | 3 deg | +5.119 | 64 | 5.6 | 5118.8 | 5118.84 | 5.59303 | 0.00833859 | 65.4579
COLUMN | Z/2254 | 25 deg | +7.361 | 92.1 | 8 | 7361.4 | 7361.38 | 8.04189 | 0.0119917 | 94.1348
COLUMN | Z/2252 | 18 deg | +6.267 | 78.4 | 6.8 | 6267.1 | 6267.06 | 6.84688 | 0.010209 | 80.1409
COLUMN | Z/2250 | 15 deg | +5.825 | 72.8 | 6.5 | 5824.7 | 5824.69 | 6.36382 | 0.00948842 | 74.4841
COLUMN | Z/1755 | 9 deg | +4.696 | 58.7 | 5.1 | 4696.3 | 4696.25 | 5.13156 | 0.00765019 | 60.054
COLUMN | Z/1752 | 5 deg | +4.699 | 58.8 | 5.1 | 4698.9 | 4698.85 | 5.1344 | 0.00765443 | 60.0872
COLUMN | Z/1749 | 3 deg | +4.700 | 58.8 | 5.1 | 4699.6 | 4699.57 | 5.13519 | 0.0076556 | 60.0965
COLUMN | Z/2253 | 25 deg | +3.631 | 45.4 | 4 | 3630.9 | 3630.92 | 3.96822 | 0.00591477 | 46.4309
COLUMN | Z/2251 | 18 deg | +3.668 | 45.9 | 4 | 3667.7 | 3667.7 | 4.00839 | 0.00597468 | 46.9013
COLUMN | Z/2249 | 15 deg | +3.681 | 45.9 | 4 | 3681.1 | 3681.1 | 4.02301 | 0.00599651 | 47.0726
COLUMN | Z/1743 | 12 deg | +3.693 | 46.2 | 4 | 3693.3 | 3693.29 | 4.03633 | 0.00601636 | 47.2284

# IfcColumn: C:350-30 (16)
In: Undefined
Description: C:350-30; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Phase: 1; Class: 12
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.1 m2; Height: 350 mm; Width: 125 mm
Pset_ColumnCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Finish | Top elevation | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
COLUMN | Z/2421 | 12 deg | +3.614 | 54 | 4.7 | 3613.6 | 3613.55 | 4.70873 | 0.00702474 | 55.1442
COLUMN | Z/2423 | 12 deg | +5.024 | 75.1 | 6.5 | 5024.2 | 5024.17 | 6.54536 | 0.00976699 | 76.6709
COLUMN | Z/1762 | 12 deg | +5.343 | 79.9 | 7 | 5342.6 | 5342.62 | 6.95998 | 0.0103861 | 81.5306
COLUMN | Z/1774 | 9 deg | +5.913 | 88.4 | 7.6 | 5912.7 | 5912.71 | 7.70223 | 0.0114943 | 90.2303
COLUMN | Z/1771 | 5 deg | +5.349 | 79.9 | 7 | 5348.6 | 5348.57 | 6.96772 | 0.0103976 | 81.6213
COLUMN | Z/1768 | 3 deg | +5.069 | 75.8 | 6.6 | 5068.8 | 5068.78 | 6.60344 | 0.0098537 | 77.3516
COLUMN | Z/2272 | 25 deg | +7.300 | 109.2 | 9.5 | 7299.9 | 7299.86 | 9.50831 | 0.0141909 | 111.399
COLUMN | Z/2270 | 18 deg | +6.212 | 92.9 | 8 | 6211.7 | 6211.67 | 8.09148 | 0.0120755 | 94.7925
COLUMN | Z/2268 | 15 deg | +5.772 | 86.3 | 7.4 | 5771.5 | 5771.54 | 7.51843 | 0.0112199 | 88.0759
COLUMN | Z/1772 | 9 deg | +4.646 | 69.4 | 6.2 | 4645.6 | 4645.64 | 6.05251 | 0.00903112 | 70.8943
COLUMN | Z/1769 | 5 deg | +4.649 | 69.4 | 6.2 | 4648.7 | 4648.66 | 6.05644 | 0.00903699 | 70.9404
COLUMN | Z/1766 | 3 deg | +4.650 | 69.4 | 6.2 | 4649.5 | 4649.52 | 6.05756 | 0.00903866 | 70.9535
COLUMN | Z/2271 | 25 deg | +3.569 | 53.4 | 4.7 | 3569.4 | 3569.4 | 4.65125 | 0.00693892 | 54.4705
COLUMN | Z/2269 | 18 deg | +3.612 | 54 | 4.7 | 3612.3 | 3612.31 | 4.70712 | 0.00702233 | 55.1253
COLUMN | Z/2267 | 15 deg | +3.628 | 54.3 | 4.7 | 3627.9 | 3627.95 | 4.72747 | 0.00705273 | 55.3639
COLUMN | Z/1760 | 12 deg | +3.642 | 54.5 | 4.7 | 3642.2 | 3642.17 | 4.74599 | 0.00708038 | 55.581

# IfcElementAssembly (500)
In: Undefined
PredefinedType: RIGID_FRAME
Name | ASSEMBLY_POSITION_CODE = Assembly/Cast unit position code | ASSEMBLY_POS = Assembly/Cast unit Mark | Assembly/Cast unit weight (kg) | Assembly/Cast unit bottom elevation | Assembly/Cast unit top elevation | Width (mm)
COLUMN | C150SD/3 | Z/2474 | 29.1 | +0.000 | +5.218 | 64
RAFTER | C150SD/<1-3> | Z/2473 | 60.8 | +3.626 | +5.671 | 64
COLUMN | C150SD/1 | Z/2472 | 21.2 | +0.000 | +3.807 | 64
PLATE | C150SD/3 | PL/1806 | 3.1 | +5.002 | +5.399 | 67
PLATE | C150SD/1 | PL/1805 | 3.5 | +3.592 | +4.026 | 67
COLUMN | C200SD/3 | Z/2477 | 36.6 | +0.000 | +5.168 | 76
RAFTER | C200SD/<1-3> | Z/2476 | 77.1 | +3.587 | +5.675 | 76
COLUMN | C200SD/1 | Z/2475 | 26.6 | +0.000 | +3.757 | 76
PLATE | C200SD/3 | PL/1810 | 4.1 | +4.952 | +5.410 | 79
PLATE | C200SD/1 | PL/1809 | 4.5 | +3.542 | +4.034 | 79
COLUMN | C250SD/3 | Z/2480 | 41.1 | +0.000 | +5.118 | 76
RAFTER | C250SD/<1-3> | Z/2479 | 87 | +3.547 | +5.680 | 76
COLUMN | C250SD/1 | Z/2478 | 29.7 | +0.000 | +3.707 | 76
PLATE | C250SD/3 | PL/1814 | 6 | +4.842 | +5.420 | 79
PLATE | C250SD/1 | PL/1813 | 6.5 | +3.433 | +4.047 | 79
COLUMN | C300SD/3 | Z/2483 | 63.4 | +0.000 | +5.073 | 96
RAFTER | C300SD/<1-3> | Z/2482 | 135.1 | +3.513 | +5.685 | 96
COLUMN | C300SD/1 | Z/2481 | 45.8 | +0.000 | +3.662 | 96
PLATE | C300SD/3 | PL/1818 | 7.3 | +4.798 | +5.431 | 99
PLATE | C300SD/1 | PL/1817 | 7.9 | +3.388 | +4.056 | 99
COLUMN | C350SD/3 | Z/2423 | 75.1 | +0.000 | +5.024 | 125
RAFTER | C350SD/<1-3> | Z/2422 | 161.1 | +3.474 | +5.689 | 125
COLUMN | C350SD/1 | Z/2421 | 54 | +0.000 | +3.614 | 125
PLATE | C350SD/3 | PL/1700 | 9.1 | +4.749 | +5.441 | 128
PLATE | C350SD/1 | PL/1699 | 9.9 | +3.339 | +4.068 | 128
COLUMN | C350SD>/3 | Z/2423 | 75.1 | +0.000 | +5.024 | 125
RAFTER | C350SD>/<1-3> | Z/2422 | 161.1 | +3.474 | +5.689 | 125
COLUMN | C350SD>/1 | Z/2421 | 54 | +0.000 | +3.614 | 125
COLUMN | C300SD-C350SD/3 | Z/2483 | 63.4 | +0.000 | +5.073 | 96
RAFTER | C300SD-C350SD/<1-3> | Z/2482 | 135.1 | +3.513 | +5.685 | 96
COLUMN | C300SD-C350SD/1 | Z/2481 | 45.8 | +0.000 | +3.662 | 96
COLUMN | C250SD-C300SD/3 | Z/2480 | 41.1 | +0.000 | +5.118 | 76
RAFTER | C250SD-C300SD/<1-3> | Z/2479 | 87 | +3.547 | +5.680 | 76
COLUMN | C250SD-C300SD/1 | Z/2478 | 29.7 | +0.000 | +3.707 | 76
COLUMN | C200SD-C250SD/3 | Z/2477 | 36.6 | +0.000 | +5.168 | 76
RAFTER | C200SD-C250SD/<1-3> | Z/2476 | 77.1 | +3.587 | +5.675 | 76
COLUMN | C200SD-C250SD/1 | Z/2475 | 26.6 | +0.000 | +3.757 | 76
COLUMN | C150SD-C200SD/3 | Z/2474 | 29.1 | +0.000 | +5.218 | 64
RAFTER | C150SD-C200SD/<1-3> | Z/2473 | 60.8 | +3.626 | +5.671 | 64
COLUMN | C150SD-C200SD/1 | Z/2472 | 21.2 | +0.000 | +3.807 | 64
PLATE | C350SD>/3 | PL/1702 | 9.1 | +4.749 | +5.441 | 128
2 x TH | C350SD>/1-2 | B/5 | 1.8 | +4.279 | +4.367 | 125
PLATE | C350SD>/1 | PL/1701 | 9.9 | +3.339 | +4.068 | 128
PLATE | C300SD-C350SD/3 | PL/1820 | 7.3 | +4.798 | +5.431 | 99
2 x TH | C300SD-C350SD/1-2 | B/5 | 1.8 | +4.271 | +4.359 | 125
PLATE | C300SD-C350SD/1 | PL/1819 | 7.9 | +3.388 | +4.056 | 99
PLATE | C250SD-C300SD/3 | PL/1816 | 6 | +4.842 | +5.420 | 79
2 x TH | C250SD-C300SD/1-2 | B/5 | 1.8 | +4.264 | +4.352 | 125
PLATE | C250SD-C300SD/1 | PL/1815 | 6.5 | +3.433 | +4.047 | 79
PLATE | C200SD-C250SD/3 | PL/1812 | 4.1 | +4.952 | +5.410 | 79
2 x TH | C200SD-C250SD/1-2 | B/5 | 1.8 | +4.258 | +4.346 | 125
PLATE | C200SD-C250SD/1 | PL/1811 | 4.5 | +3.542 | +4.034 | 79
PLATE | C150SD-C200SD/3 | PL/1808 | 3.1 | +5.002 | +5.399 | 67
2 x TH | C150SD-C200SD/1-2 | B/11 | 1.8 | +4.251 | +4.328 | 130
PLATE | C150SD-C200SD/1 | PL/1807 | 3.5 | +3.592 | +4.026 | 67
RAFTER | C150SD/1-3 | Z/2325 | 49.6 | +4.797 | +6.340 | 64
RAFTER | C150SD/1-3 | Z/2318 | 49.2 | +4.830 | +5.444 | 64
RAFTER | C150SD/<1-3> | Z/2309 | 58.6 | +6.133 | +8.999 | 64
RAFTER | C150SD/<1-3> | Z/2314 | 55.7 | +3.601 | +7.962 | 64
RAFTER | C150SD/1-3 | Z/2323 | 49.3 | +5.319 | +6.241 | 64
RAFTER | C150SD/<1-3> | Z/2304 | 60.8 | +3.626 | +6.043 | 64
RAFTER | C150SD/<1-3> | Z/2306 | 58.6 | +3.633 | +6.499 | 64
RAFTER | C150SD/1-3 | Z/2322 | 49.3 | +4.819 | +5.741 | 64
RAFTER | C150SD/1-3> | Z/2310 | 53.3 | +3.745 | +6.844 | 64
2 x TH | C150SD-C200SD/1-2 | B/63 | 1.8 | +5.223 | +5.358 | 165
2 x TH | C150SD-C200SD/1-2 | B/11 | 1.8 | +5.257 | +5.333 | 130
2 x TH | C150SD-C200SD/1-2 | B/63 | 1.8 | +5.124 | +5.253 | 165
2 x TH | C150SD-C200SD/1-2 | B/11 | 1.8 | +5.143 | +5.214 | 130
2 x TH | C150SD-C200SD/1-2 | B/63 | 1.8 | +5.074 | +5.200 | 165
2 x TH | C150SD-C200SD/1-2 | B/11 | 1.8 | +5.086 | +5.154 | 130
2 x TH | C150SD-C200SD/1-2 | B/63 | 1.8 | +4.485 | +4.638 | 165
2 x TH | C150SD-C200SD/1-2 | B/11 | 1.8 | +4.577 | +4.670 | 130
2 x TH | C150SD-C200SD/1-2 | B/63 | 1.8 | +4.435 | +4.581 | 165
2 x TH | C150SD-C200SD/1-2 | B/63 | 1.8 | +4.380 | +4.523 | 165
2 x TH | C150SD-C200SD/1-2 | B/67 | 1.8 | +4.284 | +4.397 | 150
2 x TH | C150SD-C200SD/1-2 | B/5 | 1.8 | +4.317 | +4.407 | 125
2 x TH | C150SD-C200SD/1-2 | B/63 | 1.8 | +4.236 | +4.376 | 165
COLUMN | C350SD>/3 | Z/2272 | 109.2 | +0.000 | +7.300 | 125
RAFTER | C350SD>/<1-3> | Z/1765 | 156.9 | +3.405 | +8.156 | 125
COLUMN | C350SD>/1 | Z/2271 | 53.4 | +0.000 | +3.569 | 125
PLATE | C350SD>/3 | PL/1379 | 9.6 | +7.025 | +7.849 | 128
2 x TH | C350SD>/1-2 | B/5 | 1.8 | +4.688 | +4.790 | 125
PLATE | C350SD>/1 | PL/1378 | 11.9 | +3.296 | +4.196 | 128
COLUMN | C300SD-C350SD/3 | Z/2254 | 92.1 | +0.000 | +7.361 | 96
RAFTER | C300SD-C350SD/<1-3> | Z/1748 | 131.2 | +3.454 | +8.160 | 96
COLUMN | C300SD-C350SD/1 | Z/2253 | 45.4 | +0.000 | +3.631 | 96
PLATE | C300SD-C350SD/3 | PL/1351 | 7.6 | +7.086 | +7.832 | 99
2 x TH | C300SD-C350SD/1-2 | B/5 | 1.8 | +4.684 | +4.786 | 125
PLATE | C300SD-C350SD/1 | PL/1350 | 9.4 | +3.357 | +4.177 | 99
COLUMN | C250SD-C300SD/3 | Z/2236 | 67.6 | +0.000 | +8.425 | 76
RAFTER | C250SD-C300SD/<1-3> | Z/1731 | 81.3 | +4.529 | +9.044 | 76
COLUMN | C250SD-C300SD/1 | Z/2235 | 37.7 | +0.000 | +4.694 | 76
PLATE | C250SD-C300SD/3 | PL/1323 | 6.2 | +8.149 | +8.823 | 79
2 x TH | C250SD-C300SD/1-2 | B/5 | 1.8 | +5.688 | +5.790 | 125
PLATE | C250SD-C300SD/1 | PL/1322 | 7.6 | +4.420 | +5.173 | 79
COLUMN | C200SD-C250SD/3 | Z/2104 | 53 | +0.000 | +7.480 | 76
RAFTER | C200SD-C250SD/<1-3 | Z/1714 | 69.4 | +3.593 | +7.915 | 76
COLUMN | C200SD-C250SD/1 | Z/1713 | 26.6 | +0.000 | +3.750 | 76
PLATE | C200SD-C250SD/3 | PL/1297 | 4.1 | +7.264 | +7.799 | 79
2 x TH | C200SD-C250SD/1-2 | B/5 | 1.8 | +4.678 | +4.780 | 125
PLATE | C200SD-C250SD/1 | PL/1296 | 5.3 | +3.536 | +4.147 | 79
COLUMN | C150SD-C200SD/3 | Z/1858 | 42 | +0.000 | +7.543 | 64
RAFTER | C150SD-C200SD/<1-3> | Z/1694 | 55.7 | +3.601 | +7.962 | 64
COLUMN | C150SD-C200SD/1 | Z/1693 | 21.2 | +0.000 | +3.813 | 64
PLATE | C150SD-C200SD/3 | PL/1265 | 3.1 | +7.327 | +7.782 | 67
PLATE | C150SD-C200SD/1 | PL/1264 | 3.9 | +3.599 | +4.137 | 67
COLUMN | C350SD>/3 | Z/2270 | 92.9 | +0.000 | +6.212 | 125
RAFTER | C350SD>/<1-3> | Z/1764 | 153.9 | +3.486 | +7.000 | 125
COLUMN | C350SD>/1 | Z/2269 | 54 | +0.000 | +3.612 | 125
PLATE | C350SD>/3 | PL/1377 | 9.4 | +5.936 | +6.693 | 128
2 x TH | C350SD>/1-2 | B/5 | 1.8 | +4.521 | +4.617 | 125
PLATE | C350SD>/1 | PL/1376 | 11 | +3.338 | +4.156 | 128
COLUMN | C300SD-C350SD/3 | Z/2252 | 78.4 | +0.000 | +6.267 | 96
RAFTER | C300SD-C350SD/<1-3> | Z/1747 | 123.6 | +3.505 | +6.845 | 96
COLUMN | C300SD-C350SD/1 | Z/2251 | 45.9 | +0.000 | +3.668 | 96
PLATE | C300SD-C350SD/3 | PL/1349 | 7.3 | +5.992 | +6.680 | 686.391
2 x TH | C300SD-C350SD/1-2 | B/5 | 1.8 | +4.520 | +4.616 | 125
PLATE | C300SD-C350SD/1 | PL/1348 | 8.7 | +3.394 | +4.141 | 99
COLUMN | C250SD-C300SD/3 | Z/2234 | 58.8 | +0.000 | +7.325 | 76
RAFTER | C250SD-C300SD/<1-3> | Z/1730 | 78 | +4.605 | +7.851 | 76
COLUMN | C250SD-C300SD/1 | Z/2233 | 37.9 | +0.000 | +4.725 | 76
PLATE | C250SD-C300SD/3 | PL/1321 | 6.2 | +7.049 | +7.674 | 79
2 x TH | C250SD-C300SD/1-2 | B/5 | 1.8 | +5.519 | +5.615 | 125
PLATE | C250SD-C300SD/1 | PL/1320 | 7.1 | +4.451 | +5.138 | 79
COLUMN | C200SD-C250SD/3 | Z/2103 | 45.2 | +0.000 | +6.374 | 76
RAFTER | C200SD-C250SD/<1-3> | Z/1712 | 68.9 | +3.648 | +6.844 | 76
COLUMN | C200SD-C250SD/1 | Z/1711 | 26.8 | +0.000 | +3.775 | 76
PLATE | C200SD-C250SD/3 | PL/1295 | 4.1 | +6.158 | +6.654 | 79
2 x TH | C200SD-C250SD/1-2 | B/5 | 1.8 | +4.507 | +4.603 | 125
PLATE | C200SD-C250SD/1 | PL/1294 | 4.9 | +3.560 | +4.115 | 79
COLUMN | C150SD-C200SD/3 | Z/1842 | 35.8 | +0.000 | +6.431 | 64
RAFTER | C150SD-C200SD/1-3> | Z/1692 | 53.3 | +3.745 | +6.844 | 64
COLUMN | C150SD-C200SD/1 | Z/1691 | 21.4 | +0.000 | +3.831 | 64
PLATE | C150SD-C200SD/3 | PL/1269 | 3.1 | +6.214 | +6.640 | 66.5
2 x TH | C150SD-C200SD/1-2 | B/82 | 1.8 | +4.502 | +4.588 | 130
PLATE | C150SD-C200SD/1 | PL/1263 | 3.7 | +3.616 | +4.106 | 67
COLUMN | C350SD>/3 | Z/2268 | 86.3 | +0.000 | +5.772 | 125
RAFTER | C350SD>/<1-3> | Z/1763 | 145.1 | +3.529 | +6.377 | 125
COLUMN | C350SD>/1 | Z/2267 | 54.3 | +0.000 | +3.628 | 125
PLATE | C350SD>/3 | PL/1375 | 9.2 | +5.496 | +6.228 | 128
2 x TH | C350SD>/1-2 | B/5 | 1.8 | +4.444 | +4.537 | 125
PLATE | C350SD>/1 | PL/1374 | 10.6 | +3.354 | +4.138 | 128
COLUMN | C300SD-C350SD/3 | Z/2250 | 72.8 | +0.000 | +5.825 | 96
RAFTER | C300SD-C350SD/<1-3> | Z/1746 | 123.6 | +3.526 | +6.376 | 96
COLUMN | C300SD-C350SD/1 | Z/2249 | 45.9 | +0.000 | +3.681 | 96
PLATE | C300SD-C350SD/3 | PL/1347 | 7.3 | +5.549 | +6.216 | 99
2 x TH | C300SD-C350SD/1-2 | B/5 | 1.8 | +4.439 | +4.532 | 125
PLATE | C300SD-C350SD/1 | PL/1346 | 8.4 | +3.407 | +4.124 | 99
COLUMN | C250SD-C300SD/3 | Z/2175 | 55.2 | +0.000 | +6.880 | 76
RAFTER | C250SD-C300SD/<1-3> | Z/1729 | 80.8 | +4.579 | +7.432 | 76
COLUMN | C250SD-C300SD/1 | Z/2174 | 38 | +0.000 | +4.737 | 76
PLATE | C250SD-C300SD/3 | PL/1319 | 6 | +6.606 | +7.211 | 79
2 x TH | C250SD-C300SD/1-2 | B/5 | 1.8 | +5.441 | +5.534 | 125
PLATE | C250SD-C300SD/1 | PL/1318 | 6.9 | +4.462 | +5.121 | 79
COLUMN | C200SD-C250SD/3 | Z/2102 | 42 | +0.000 | +5.928 | 76
RAFTER | C200SD-C250SD/<1-3> | Z/1710 | 73.5 | +3.622 | +6.501 | 76
COLUMN | C200SD-C250SD/1 | Z/1709 | 26.8 | +0.000 | +3.784 | 76
PLATE | C200SD-C250SD/3 | PL/1293 | 4.1 | +5.711 | +6.192 | 79
2 x TH | C200SD-C250SD/1-2 | B/5 | 1.8 | +4.429 | +4.522 | 125
PLATE | C200SD-C250SD/1 | PL/1292 | 4.9 | +3.569 | +4.100 | 79
COLUMN | C150SD-C200SD/3 | Z/1830 | 33.3 | +0.000 | +5.982 | 64
RAFTER | C150SD-C200SD/<1-3> | Z/1689 | 58.6 | +3.633 | +6.499 | 64
COLUMN | C150SD-C200SD/1 | Z/1688 | 21.4 | +0.000 | +3.838 | 64
PLATE | C150SD-C200SD/3 | PL/1268 | 3.1 | +5.765 | +6.180 | 66.5
2 x TH | C150SD-C200SD/1-2 | B/82 | 1.8 | +4.424 | +4.507 | 130
PLATE | C150SD-C200SD/1 | PL/1262 | 3.6 | +3.623 | +4.091 | 67
COLUMN | C350SD>/3 | Z/1762 | 79.9 | +0.000 | +5.343 | 125
RAFTER | C350SD>/<1-3> | Z/1761 | 161.1 | +3.474 | +6.056 | 125
COLUMN | C350SD>/1 | Z/1760 | 54.5 | +0.000 | +3.642 | 125
PLATE | C350SD>/3 | PL/1373 | 9.1 | +5.067 | +5.775 | 128
2 x TH | C350SD>/1-2 | B/5 | 1.8 | +4.365 | +4.455 | 125
PLATE | C350SD>/1 | PL/1372 | 10.2 | +3.368 | +4.119 | 128
COLUMN | C300SD-C350SD/3 | Z/1745 | 67.4 | +0.000 | +5.394 | 96
RAFTER | C300SD-C350SD/<1-3> | Z/1744 | 135.1 | +3.513 | +6.053 | 96
COLUMN | C300SD-C350SD/1 | Z/1743 | 46.2 | +0.000 | +3.693 | 96
PLATE | C300SD-C350SD/3 | PL/1345 | 7.3 | +5.118 | +5.764 | 99
2 x TH | C300SD-C350SD/1-2 | B/5 | 1.8 | +4.360 | +4.450 | 125
PLATE | C300SD-C350SD/1 | PL/1344 | 8.1 | +3.419 | +4.106 | 99
COLUMN | C250SD-C300SD/3 | Z/1728 | 43.6 | +0.000 | +5.440 | 76
RAFTER | C250SD-C300SD/<1-3> | Z/1727 | 87 | +3.547 | +6.050 | 76
COLUMN | C250SD-C300SD/1 | Z/1726 | 30 | +0.000 | +3.740 | 76
PLATE | C250SD-C300SD/3 | PL/1317 | 6 | +5.165 | +5.754 | 79
2 x TH | C250SD-C300SD/1-2 | B/5 | 1.8 | +4.355 | +4.445 | 125
PLATE | C250SD-C300SD/1 | PL/1316 | 6.6 | +3.465 | +4.097 | 79
COLUMN | C200SD-C250SD/3 | Z/1708 | 38.9 | +0.000 | +5.493 | 76
RAFTER | C200SD-C250SD/<1-3> | Z/1707 | 77.1 | +3.587 | +6.047 | 76
COLUMN | C200SD-C250SD/1 | Z/1706 | 26.9 | +0.000 | +3.792 | 76
PLATE | C200SD-C250SD/3 | PL/1291 | 4.1 | +5.277 | +5.743 | 79
2 x TH | C200SD-C250SD/1-2 | B/5 | 1.8 | +4.349 | +4.440 | 125
PLATE | C200SD-C250SD/1 | PL/1290 | 4.6 | +3.577 | +4.085 | 79
COLUMN | C150SD-C200SD/3 | Z/1687 | 30.9 | +0.000 | +5.545 | 64
RAFTER | C150SD-C200SD/<1-3> | Z/1673 | 60.8 | +3.626 | +6.043 | 64
COLUMN | C150SD-C200SD/1 | Z/1672 | 21.4 | +0.000 | +3.844 | 64
PLATE | C150SD-C200SD/3 | PL/1261 | 3.1 | +5.329 | +5.733 | 67
2 x TH | C150SD-C200SD/1-2 | B/82 | 1.8 | +4.344 | +4.424 | 130
PLATE | C150SD-C200SD/1 | PL/1260 | 3.5 | +3.629 | +4.077 | 67
COLUMN | C350SD>/3 | Z/1774 | 88.4 | +0.000 | +5.913 | 125
RAFTER | C350SD>/<1-3> | Z/1773 | 144.6 | +4.555 | +6.413 | 125
COLUMN | C350SD>/1 | Z/1772 | 69.4 | +0.000 | +4.646 | 125
2 x TH | C350SD>/1-2 | B/5 | 1.8 | +5.270 | +5.356 | 125
PLATE | C350SD>/3 | PL/1383 | 9.1 | +5.637 | +6.323 | 128
PLATE | C350SD>/1 | PL/1380 | 9.9 | +4.371 | +5.089 | 128
COLUMN | C300SD-C350SD/3 | Z/1757 | 74.6 | +0.000 | +5.963 | 96
RAFTER | C300SD-C350SD/<1-3> | Z/1756 | 121.7 | +4.596 | +6.414 | 96
COLUMN | C300SD-C350SD/1 | Z/1755 | 58.7 | +0.000 | +4.696 | 96
2 x TH | C300SD-C350SD/1-2 | B/5 | 1.8 | +5.266 | +5.352 | 125
PLATE | C300SD-C350SD/3 | PL/1357 | 7.1 | +5.688 | +6.315 | 99
PLATE | C300SD-C350SD/1 | PL/1354 | 7.9 | +4.422 | +5.080 | 99
COLUMN | C250SD-C300SD/3 | Z/1740 | 48.2 | +0.000 | +6.009 | 76
RAFTER | C250SD-C300SD/<1-3> | Z/1739 | 72.9 | +4.689 | +6.360 | 76
COLUMN | C250SD-C300SD/1 | Z/1738 | 38 | +0.000 | +4.742 | 76
2 x TH | C250SD-C300SD/1-2 | B/5 | 1.8 | +5.262 | +5.349 | 125
PLATE | C250SD-C300SD/3 | PL/1327 | 6 | +5.734 | +6.307 | 79
PLATE | C250SD-C300SD/1 | PL/1324 | 6.5 | +4.468 | +5.073 | 79
COLUMN | C200SD-C250SD/3 | Z/1723 | 43 | +0.000 | +6.061 | 76
RAFTER | C200SD-C250SD/1-3 | Z/1722 | 62.7 | +4.755 | +6.338 | 76
COLUMN | C200SD-C250SD/1 | Z/1721 | 34 | +0.000 | +4.794 | 76
2 x TH | C200SD-C250SD/1-2 | B/5 | 1.8 | +5.259 | +5.345 | 125
PLATE | C200SD-C250SD/3 | PL/1300 | 4.1 | +5.845 | +6.299 | 79
PLATE | C200SD-C250SD/1 | PL/1289 | 4.5 | +4.579 | +5.064 | 79
COLUMN | C150SD-C200SD/3 | Z/1703 | 34.1 | +0.000 | +6.113 | 64
RAFTER | C150SD-C200SD/1-3 | Z/1702 | 49.6 | +4.797 | +6.340 | 64
COLUMN | C150SD-C200SD/1 | Z/1701 | 26.9 | +0.000 | +4.846 | 64
PLATE | C150SD-C200SD/3 | PL/1272 | 3.1 | +5.897 | +6.291 | 67
PLATE | C150SD-C200SD/1 | PL/1267 | 3.5 | +4.631 | +5.058 | 67
RAFTER | C350SD>/<1-3> | Z/1770 | 144 | +4.596 | +5.784 | 125
COLUMN | C350SD>/3 | Z/1771 | 79.9 | +0.000 | +5.349 | 125
COLUMN | C350SD>/1 | Z/1769 | 69.4 | +0.000 | +4.649 | 125
2 x TH | C350SD>/1-2 | B/5 | 1.8 | +5.151 | +5.233 | 125
PLATE | C350SD>/3 | PL/1385 | 8.9 | +5.073 | +5.731 | 128
PLATE | C350SD>/1 | PL/1382 | 9.2 | +4.374 | +5.050 | 128
RAFTER | C300SD-C350SD/<1-3> | Z/1753 | 121.1 | +4.641 | +5.784 | 96
COLUMN | C300SD-C350SD/3 | Z/1754 | 67.4 | +0.000 | +5.399 | 96
COLUMN | C300SD-C350SD/1 | Z/1752 | 58.8 | +0.000 | +4.699 | 96
2 x TH | C300SD-C350SD/1-2 | B/5 | 1.8 | +5.149 | +5.230 | 125
PLATE | C300SD-C350SD/3 | PL/1356 | 7.1 | +5.124 | +5.726 | 99
PLATE | C300SD-C350SD/1 | PL/1353 | 7.5 | +4.424 | +5.044 | 99
RAFTER | C250SD-C300SD/<1-3> | Z/1736 | 72.5 | +4.713 | +5.753 | 76
COLUMN | C250SD-C300SD/3 | Z/1737 | 43.7 | +0.000 | +5.445 | 76
COLUMN | C250SD-C300SD/1 | Z/1735 | 38.1 | +0.000 | +4.745 | 76
2 x TH | C250SD-C300SD/1-2 | B/5 | 1.8 | +5.146 | +5.228 | 125
PLATE | C250SD-C300SD/3 | PL/1329 | 6 | +5.169 | +5.722 | 79
PLATE | C250SD-C300SD/1 | PL/1326 | 6.2 | +4.470 | +5.041 | 79
RAFTER | C200SD-C250SD/1-3 | Z/1719 | 62.3 | +4.773 | +5.741 | 76
COLUMN | C200SD-C250SD/3 | Z/1720 | 38.9 | +0.000 | +5.496 | 76
COLUMN | C200SD-C250SD/1 | Z/1718 | 34 | +0.000 | +4.796 | 76
2 x TH | C200SD-C250SD/1-2 | B/5 | 1.8 | +5.145 | +5.226 | 125
PLATE | C200SD-C250SD/3 | PL/1299 | 4.1 | +5.280 | +5.717 | 79
PLATE | C200SD-C250SD/1 | PL/1288 | 4.3 | +4.581 | +5.035 | 79
RAFTER | C150SD-C200SD/1-3 | Z/1699 | 49.3 | +4.819 | +5.741 | 64
COLUMN | C150SD-C200SD/3 | Z/1700 | 30.9 | +0.000 | +5.547 | 64
COLUMN | C150SD-C200SD/1 | Z/1698 | 26.9 | +0.000 | +4.847 | 64
PLATE | C150SD-C200SD/3 | PL/1271 | 3.1 | +5.331 | +5.713 | 67
PLATE | C150SD-C200SD/1 | PL/1266 | 3.3 | +4.632 | +5.032 | 67
RAFTER | C350SD>/<1-3> | Z/1767 | 144 | +4.617 | +5.470 | 125
COLUMN | C350SD>/3 | Z/1768 | 75.8 | +0.000 | +5.069 | 125
COLUMN | C350SD>/1 | Z/1766 | 69.4 | +0.000 | +4.650 | 125
2 x TH | C350SD>/1-2 | B/5 | 1.8 | +5.091 | +5.170 | 125
PLATE | C350SD>/3 | PL/1384 | 8.7 | +4.794 | +5.438 | 128
PLATE | C350SD>/1 | PL/1381 | 9.1 | +4.375 | +5.030 | 128
COLUMN | C300SD-C350SD/3 | Z/1751 | 64 | +0.000 | +5.119 | 96
RAFTER | C300SD-C350SD/<1-3> | Z/1750 | 121 | +4.664 | +5.470 | 96
COLUMN | C300SD-C350SD/1 | Z/1749 | 58.8 | +0.000 | +4.700 | 96
2 x TH | C300SD-C350SD/1-2 | B/5 | 1.8 | +5.089 | +5.168 | 125
PLATE | C300SD-C350SD/3 | PL/1355 | 7.1 | +4.844 | +5.435 | 99
PLATE | C300SD-C350SD/1 | PL/1352 | 7.3 | +4.425 | +5.027 | 99
PLATE | C250SD-C300SD/3 | PL/1328 | 5.8 | +4.889 | +5.432 | 79
COLUMN | C250SD-C300SD/3 | Z/1734 | 41.4 | +0.000 | +5.165 | 76
PLATE | C250SD-C300SD/1 | PL/1325 | 6 | +4.470 | +5.024 | 79
COLUMN | C250SD-C300SD/1 | Z/1732 | 38.1 | +0.000 | +4.745 | 76
2 x TH | C250SD-C300SD/1-2 | B/5 | 1.8 | +5.087 | +5.166 | 125
RAFTER | C250SD-C300SD/<1-3> | Z/1733 | 72.5 | +4.726 | +5.452 | 76
RAFTER | C200SD-C250SD/1-3 | Z/1716 | 62.2 | +4.782 | +5.444 | 76
COLUMN | C200SD-C250SD/3 | Z/1717 | 37 | +0.000 | +5.216 | 76
COLUMN | C200SD-C250SD/1 | Z/1715 | 34 | +0.000 | +4.796 | 76
2 x TH | C200SD-C250SD/1-2 | B/5 | 1.8 | +5.086 | +5.165 | 125
PLATE | C200SD-C250SD/3 | PL/1301 | 4.1 | +5.000 | +5.430 | 79
PLATE | C200SD-C250SD/1 | PL/1298 | 4.1 | +4.581 | +5.021 | 79
RAFTER | C150SD-C200SD/1-3 | Z/1696 | 49.2 | +4.830 | +5.444 | 64
COLUMN | C150SD-C200SD/3 | Z/1697 | 29.4 | +0.000 | +5.267 | 64
COLUMN | C150SD-C200SD/1 | Z/1695 | 26.9 | +0.000 | +4.848 | 64
PLATE | C150SD-C200SD/3 | PL/1273 | 3.1 | +5.051 | +5.427 | 67
PLATE | C150SD-C200SD/1 | PL/1270 | 3.2 | +4.632 | +5.019 | 67
RAFTER | C350SD/<1-3> | Z/1773 | 144.6 | +4.555 | +6.413 | 125
RAFTER | C350SD/<1-3> | Z/1770 | 144 | +4.596 | +5.784 | 125
RAFTER | C350SD/<1-3> | Z/1767 | 144 | +4.617 | +5.470 | 125
COLUMN | C350SD/3 | Z/1774 | 88.4 | +0.000 | +5.913 | 125
COLUMN | C350SD/3 | Z/1771 | 79.9 | +0.000 | +5.349 | 125
COLUMN | C350SD/3 | Z/1768 | 75.8 | +0.000 | +5.069 | 125
RAFTER | C300SD/<1-3> | Z/1756 | 121.7 | +4.596 | +6.414 | 96
COLUMN | C300SD/3 | Z/1757 | 74.6 | +0.000 | +5.963 | 96
RAFTER | C300SD/<1-3> | Z/1753 | 121.1 | +4.641 | +5.784 | 96
COLUMN | C300SD/3 | Z/1754 | 67.4 | +0.000 | +5.399 | 96
COLUMN | C300SD/3 | Z/1751 | 64 | +0.000 | +5.119 | 96
RAFTER | C300SD/<1-3> | Z/1750 | 121 | +4.664 | +5.470 | 96
COLUMN | C350SD/3 | Z/2272 | 109.2 | +0.000 | +7.300 | 125
RAFTER | C350SD/<1-3> | Z/1765 | 156.9 | +3.405 | +8.156 | 125
PLATE | C350SD/3 | PL/1370 | 9.6 | +7.025 | +7.849 | 128
COLUMN | C350SD/3 | Z/2270 | 92.9 | +0.000 | +6.212 | 125
RAFTER | C350SD/<1-3> | Z/1764 | 153.9 | +3.486 | +7.000 | 125
PLATE | C350SD/3 | PL/1368 | 9.2 | +5.936 | +6.693 | 128
COLUMN | C300SD/3 | Z/2254 | 92.1 | +0.000 | +7.361 | 96
RAFTER | C300SD/<1-3> | Z/1748 | 131.2 | +3.454 | +8.160 | 96
PLATE | C300SD/3 | PL/1340 | 7.6 | +7.086 | +7.832 | 99
COLUMN | C300SD/3 | Z/2252 | 78.4 | +0.000 | +6.267 | 96
RAFTER | C300SD/<1-3> | Z/1747 | 123.6 | +3.505 | +6.845 | 96
PLATE | C300SD/3 | PL/1338 | 7.3 | +5.992 | +6.680 | 686.391
COLUMN | C250SD/3 | Z/2236 | 67.6 | +0.000 | +8.425 | 76
RAFTER | C250SD/<1-3> | Z/1731 | 81.3 | +4.529 | +9.044 | 76
PLATE | C250SD/3 | PL/1314 | 6.2 | +8.149 | +8.823 | 79
COLUMN | C250SD/3 | Z/2234 | 58.8 | +0.000 | +7.325 | 76
RAFTER | C250SD/<1-3> | Z/1730 | 78 | +4.605 | +7.851 | 76
PLATE | C250SD/3 | PL/1312 | 6.2 | +7.049 | +7.674 | 79
COLUMN | C200SD/3 | Z/2104 | 53 | +0.000 | +7.480 | 76
RAFTER | C200SD/<1-3 | Z/1714 | 69.4 | +3.593 | +7.915 | 76
PLATE | C200SD/3 | PL/1285 | 4.1 | +7.264 | +7.799 | 79
COLUMN | C200SD/3 | Z/2103 | 45.2 | +0.000 | +6.374 | 76
RAFTER | C200SD/<1-3> | Z/1712 | 68.9 | +3.648 | +6.844 | 76
PLATE | C200SD/3 | PL/1283 | 4.1 | +6.158 | +6.654 | 79
COLUMN | C150SD/3 | Z/1858 | 42 | +0.000 | +7.543 | 64
PLATE | C150SD/3 | PL/1257 | 3.1 | +7.327 | +7.782 | 67
COLUMN | C150SD/3 | Z/1842 | 35.8 | +0.000 | +6.431 | 64
PLATE | C150SD/3 | PL/1251 | 3.1 | +6.214 | +6.640 | 66.5
COLUMN | C350SD/3 | Z/2268 | 86.3 | +0.000 | +5.772 | 125
RAFTER | C350SD/<1-3> | Z/1763 | 145.1 | +3.529 | +6.377 | 125
PLATE | C350SD/3 | PL/1366 | 9.2 | +5.496 | +6.228 | 128
COLUMN | C300SD/3 | Z/2250 | 72.8 | +0.000 | +5.825 | 96
RAFTER | C300SD/<1-3> | Z/1746 | 123.6 | +3.526 | +6.376 | 96
PLATE | C300SD/3 | PL/1336 | 7.3 | +5.549 | +6.216 | 99
COLUMN | C250SD/3 | Z/2175 | 55.2 | +0.000 | +6.880 | 76
RAFTER | C250SD/<1-3> | Z/1729 | 80.8 | +4.579 | +7.432 | 76
PLATE | C250SD/3 | PL/1310 | 6 | +6.606 | +7.211 | 79
COLUMN | C200SD/3 | Z/2102 | 42 | +0.000 | +5.928 | 76
RAFTER | C200SD/<1-3> | Z/1710 | 73.5 | +3.622 | +6.501 | 76
PLATE | C200SD/3 | PL/1281 | 4.1 | +5.711 | +6.192 | 79
COLUMN | C200SD/1 | Z/1709 | 26.8 | +0.000 | +3.784 | 76
COLUMN | C150SD/3 | Z/1830 | 33.3 | +0.000 | +5.982 | 64
PLATE | C150SD/3 | PL/1250 | 3.1 | +5.765 | +6.180 | 66.5
COLUMN | C350SD/3 | Z/1762 | 79.9 | +0.000 | +5.343 | 125
RAFTER | C350SD/<1-3> | Z/1761 | 161.1 | +3.474 | +6.056 | 125
PLATE | C350SD/3 | PL/1364 | 9.1 | +5.067 | +5.775 | 128
COLUMN | C300SD/3 | Z/1745 | 67.4 | +0.000 | +5.394 | 96
RAFTER | C300SD/<1-3> | Z/1744 | 135.1 | +3.513 | +6.053 | 96
PLATE | C300SD/3 | PL/1334 | 7.3 | +5.118 | +5.764 | 99
COLUMN | C250SD/3 | Z/1728 | 43.6 | +0.000 | +5.440 | 76
RAFTER | C250SD/<1-3> | Z/1727 | 87 | +3.547 | +6.050 | 76
PLATE | C250SD/3 | PL/1308 | 6 | +5.165 | +5.754 | 79
COLUMN | C200SD/3 | Z/1708 | 38.9 | +0.000 | +5.493 | 76
RAFTER | C200SD/<1-3> | Z/1707 | 77.1 | +3.587 | +6.047 | 76
PLATE | C200SD/3 | PL/1279 | 4.1 | +5.277 | +5.743 | 79
COLUMN | C150SD/3 | Z/1687 | 30.9 | +0.000 | +5.545 | 64
PLATE | C150SD/3 | PL/1253 | 3.1 | +5.329 | +5.733 | 67
RAFTER | C250SD/<1-3> | Z/1739 | 72.9 | +4.689 | +6.360 | 76
RAFTER | C250SD/<1-3> | Z/1736 | 72.5 | +4.713 | +5.753 | 76
PLATE | C250SD/3 | PL/1302 | 5.8 | +4.889 | +5.432 | 79
RAFTER | C200SD/1-3 | Z/1722 | 62.7 | +4.755 | +6.338 | 76
RAFTER | C200SD/1-3 | Z/1719 | 62.3 | +4.773 | +5.741 | 76
RAFTER | C200SD/1-3 | Z/1716 | 62.2 | +4.782 | +5.444 | 76
COLUMN | C300SD/1 | Z/1749 | 58.8 | +0.000 | +4.700 | 96
COLUMN | C350SD/1 | Z/1766 | 69.4 | +0.000 | +4.650 | 125
COLUMN | C250SD/3 | Z/1734 | 41.4 | +0.000 | +5.165 | 76
COLUMN | C150SD/3 | Z/1697 | 29.4 | +0.000 | +5.267 | 64
COLUMN | C200SD/3 | Z/1717 | 37 | +0.000 | +5.216 | 76
COLUMN | C250SD/3 | Z/1737 | 43.7 | +0.000 | +5.445 | 76
COLUMN | C250SD/3 | Z/1740 | 48.2 | +0.000 | +6.009 | 76
COLUMN | C200SD/3 | Z/1723 | 43 | +0.000 | +6.061 | 76
COLUMN | C150SD/3 | Z/1703 | 34.1 | +0.000 | +6.113 | 64
COLUMN | C200SD/3 | Z/1720 | 38.9 | +0.000 | +5.496 | 76
COLUMN | C150SD/3 | Z/1700 | 30.9 | +0.000 | +5.547 | 64
COLUMN | C350SD/1 | Z/1772 | 69.4 | +0.000 | +4.646 | 125
COLUMN | C300SD/1 | Z/1755 | 58.7 | +0.000 | +4.696 | 96
COLUMN | C250SD/1 | Z/1738 | 38 | +0.000 | +4.742 | 76
COLUMN | C200SD/1 | Z/1721 | 34 | +0.000 | +4.794 | 76
COLUMN | C150SD/1 | Z/1701 | 26.9 | +0.000 | +4.846 | 64
COLUMN | C350SD/1 | Z/1769 | 69.4 | +0.000 | +4.649 | 125
COLUMN | C300SD/1 | Z/1752 | 58.8 | +0.000 | +4.699 | 96
COLUMN | C250SD/1 | Z/1735 | 38.1 | +0.000 | +4.745 | 76
COLUMN | C200SD/1 | Z/1718 | 34 | +0.000 | +4.796 | 76
COLUMN | C150SD/1 | Z/1698 | 26.9 | +0.000 | +4.847 | 64
COLUMN | C200SD/1 | Z/1715 | 34 | +0.000 | +4.796 | 76
PLATE | C250SD/1 | PL/1304 | 6 | +4.470 | +5.024 | 79
COLUMN | C150SD/1 | Z/1695 | 26.9 | +0.000 | +4.848 | 64
COLUMN | C250SD/1 | Z/1732 | 38.1 | +0.000 | +4.745 | 76
PLATE | C300SD/3 | PL/1330 | 7.1 | +4.844 | +5.435 | 99
PLATE | C300SD/1 | PL/1341 | 7.3 | +4.425 | +5.027 | 99
PLATE | C350SD/3 | PL/1359 | 8.9 | +5.073 | +5.731 | 128
PLATE | C350SD/3 | PL/1358 | 8.7 | +4.794 | +5.438 | 128
PLATE | C350SD/1 | PL/1360 | 9.1 | +4.375 | +5.030 | 128
PLATE | C150SD/3 | PL/1246 | 3.1 | +5.051 | +5.427 | 67
PLATE | C200SD/3 | PL/1274 | 4.1 | +5.000 | +5.430 | 79
PLATE | C250SD/3 | PL/1303 | 5.8 | +5.169 | +5.722 | 79
PLATE | C350SD/3 | PL/1362 | 8.9 | +5.637 | +6.323 | 128
PLATE | C300SD/3 | PL/1332 | 7.1 | +5.688 | +6.315 | 99
PLATE | C250SD/3 | PL/1306 | 5.8 | +5.734 | +6.307 | 79
PLATE | C200SD/3 | PL/1277 | 4.1 | +5.845 | +6.299 | 79
PLATE | C150SD/3 | PL/1249 | 3.1 | +5.897 | +6.291 | 67
PLATE | C300SD/3 | PL/1331 | 7.1 | +5.124 | +5.726 | 99
PLATE | C200SD/3 | PL/1276 | 4.1 | +5.280 | +5.717 | 79
PLATE | C150SD/3 | PL/1248 | 3.1 | +5.331 | +5.713 | 67
PLATE | C350SD/1 | PL/1371 | 9.9 | +4.371 | +5.089 | 128
PLATE | C300SD/1 | PL/1343 | 7.9 | +4.422 | +5.080 | 99
PLATE | C250SD/1 | PL/1315 | 6.5 | +4.468 | +5.073 | 79
PLATE | C200SD/1 | PL/1287 | 4.5 | +4.579 | +5.064 | 79
PLATE | C150SD/1 | PL/1259 | 3.5 | +4.631 | +5.058 | 67
PLATE | C350SD/1 | PL/1361 | 9.2 | +4.374 | +5.050 | 128
PLATE | C300SD/1 | PL/1342 | 7.5 | +4.424 | +5.044 | 99
PLATE | C250SD/1 | PL/1305 | 6.2 | +4.470 | +5.041 | 79
PLATE | C200SD/1 | PL/1286 | 4.3 | +4.581 | +5.035 | 79
PLATE | C150SD/1 | PL/1258 | 3.3 | +4.632 | +5.032 | 67
PLATE | C200SD/1 | PL/1275 | 4.1 | +4.581 | +5.021 | 79
PLATE | C150SD/1 | PL/1247 | 3.2 | +4.632 | +5.019 | 67
RAFTER | C250SD/<1-3> | Z/1733 | 72.5 | +4.726 | +5.452 | 76
COLUMN | C350SD/1 | Z/2271 | 53.4 | +0.000 | +3.569 | 125
COLUMN | C300SD/1 | Z/2253 | 45.4 | +0.000 | +3.631 | 96
COLUMN | C250SD/1 | Z/2235 | 37.7 | +0.000 | +4.694 | 76
COLUMN | C200SD/1 | Z/1713 | 26.6 | +0.000 | +3.750 | 76
COLUMN | C150SD/1 | Z/1693 | 21.2 | +0.000 | +3.813 | 64
COLUMN | C350SD/1 | Z/2269 | 54 | +0.000 | +3.612 | 125
COLUMN | C300SD/1 | Z/2251 | 45.9 | +0.000 | +3.668 | 96
COLUMN | C250SD/1 | Z/2233 | 37.9 | +0.000 | +4.725 | 76
COLUMN | C200SD/1 | Z/1711 | 26.8 | +0.000 | +3.775 | 76
COLUMN | C150SD/1 | Z/1691 | 21.4 | +0.000 | +3.831 | 64
COLUMN | C350SD/1 | Z/2267 | 54.3 | +0.000 | +3.628 | 125
COLUMN | C300SD/1 | Z/2249 | 45.9 | +0.000 | +3.681 | 96
COLUMN | C250SD/1 | Z/2174 | 38 | +0.000 | +4.737 | 76
COLUMN | C150SD/1 | Z/1688 | 21.4 | +0.000 | +3.838 | 64
COLUMN | C350SD/1 | Z/1760 | 54.5 | +0.000 | +3.642 | 125
COLUMN | C300SD/1 | Z/1743 | 46.2 | +0.000 | +3.693 | 96
COLUMN | C250SD/1 | Z/1726 | 30 | +0.000 | +3.740 | 76
COLUMN | C200SD/1 | Z/1706 | 26.9 | +0.000 | +3.792 | 76
COLUMN | C150SD/1 | Z/1672 | 21.4 | +0.000 | +3.844 | 64
PLATE | C350SD/1 | PL/1369 | 11.9 | +3.296 | +4.196 | 128
PLATE | C300SD/1 | PL/1339 | 9.4 | +3.357 | +4.177 | 99
PLATE | C250SD/1 | PL/1313 | 7.6 | +4.420 | +5.173 | 79
PLATE | C200SD/1 | PL/1284 | 5.3 | +3.536 | +4.147 | 79
PLATE | C150SD/1 | PL/1256 | 3.9 | +3.599 | +4.137 | 67
PLATE | C350SD/1 | PL/1367 | 11 | +3.338 | +4.156 | 128
PLATE | C300SD/1 | PL/1337 | 8.7 | +3.394 | +4.141 | 99
PLATE | C250SD/1 | PL/1311 | 7.1 | +4.451 | +5.138 | 79
PLATE | C200SD/1 | PL/1282 | 4.9 | +3.560 | +4.115 | 79
PLATE | C150SD/1 | PL/1255 | 3.7 | +3.616 | +4.106 | 67
PLATE | C350SD/1 | PL/1365 | 10.6 | +3.354 | +4.138 | 128
PLATE | C300SD/1 | PL/1335 | 8.4 | +3.407 | +4.124 | 99
PLATE | C250SD/1 | PL/1309 | 6.9 | +4.462 | +5.121 | 79
PLATE | C200SD/1 | PL/1280 | 4.9 | +3.569 | +4.100 | 79
PLATE | C150SD/1 | PL/1254 | 3.6 | +3.623 | +4.091 | 67
PLATE | C350SD/1 | PL/1363 | 10.2 | +3.368 | +4.119 | 128
PLATE | C300SD/1 | PL/1333 | 8.1 | +3.419 | +4.106 | 99
PLATE | C250SD/1 | PL/1307 | 6.6 | +3.465 | +4.097 | 79
PLATE | C200SD/1 | PL/1278 | 4.6 | +3.577 | +4.085 | 79
PLATE | C150SD/1 | PL/1252 | 3.5 | +3.629 | +4.077 | 67

# IfcMechanicalFastener: Bolt assembly (359)
In: Undefined
Tekla Bolt - Slotted hole y: 0 mm; Slotted hole x: 0 mm; Location: Site
Name | NominalDiameter (mm) = Washer diameter (mm) = Bolt size (mm) | NominalLength (mm) = Bolt length (mm) | Material = Bolt standard | Washer count = Nut count = Bolt count | Washer type | Washer name | Nut type | Nut name | Bolt hole diameter (mm) | Bolt Name
128 x Bolt assembly | 12 | 30 | 8.8S | 6 | HARD | WASHERM12-HARD | 8.8-HEX | NUTM12-8.8-HEX | 14 | BOLTM12*30
64 x Bolt assembly | 16 | 35 | 8.8S | 6 | HARD | WASHERM16-HARD | 8.8-HEX | NUTM16-8.8-HEX | 18 | BOLTM16*35
128 x Bolt assembly | 16 | 40 | 8.8S | 6 | HARD | WASHERM16-HARD | 8.8-HEX | NUTM16-8.8-HEX | 18 | BOLTM16*40
39 x Bolt assembly | 12 | 30 | PB1230 | 1 | FLAT | WASHERM12-FLAT | 4.6-HEX | NUTM12-4.6-HEX | 18 | BOLTPB1230

# IfcMember: C:150-24 (2)
In: Undefined
Description: C:150-24; Material: STEEL/G450
Tekla Common - Finish: 25 deg; Bottom elevation: +3.601; Top elevation: +7.962; Phase: 1; Class: 10
Tekla Quantity - Weight: 55.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 111.2 m2; Net surface area: 6.2 m2; Height: 152 mm; Width: 64 mm; Length: 9992.2 mm
Pset_MemberCommon - LoadBearing: no
BaseQuantities - Length: 9992.22 mm; OuterSurfaceArea: 6.19266 m2; GrossSurfaceArea: 0 m2; CrossSectionArea: 0.00071 m2; NetVolume: 0.00737186 m3; GrossVolume: 0.00709448 m3; NetWeight: 57.8691 kg; GrossWeight: 55.6917 kg
Name | Reference
RAFTER | Z/1694
RAFTER | Z/2314

# IfcMember: C:200-24 (2)
In: Undefined
Description: C:200-24; Material: STEEL/G450
Tekla Common - Finish: 25 deg; Bottom elevation: +3.593; Top elevation: +7.915; Phase: 1; Class: 10
