Properties of the parts of a building model (IFC2X3), part 2 of 2

# IfcPlate: PLT3*496.2 (2)
BaseQuantities - Width: 496.203 mm; NetArea: 0.496119 m2; GrossArea: 0.305235 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000734453 m3; GrossVolume: 0.000734453 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/122
PLATE | PL/121

# IfcPlate: PLT3*529.2 (2)
In: Undefined
Description: PLT3*529.2; Material: STEEL/450
Tekla Common - Bottom elevation: +4.574; Top elevation: +5.038; Phase: 1; Class: 11
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.6 m2; Height: 529.2 mm; Width: 3 mm; Length: 779.7 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - NetArea: 0.683154 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00101308 m3; GrossVolume: 0.00101308 m3
Name | ASSEMBLY_POS = Reference | Weight (kg) | Width (mm) | GrossArea (m2)
PLATE | PL/193 | 8.1 | 529.203 | 0.412626
PLATE | PL/77 | 7.9 | 529.206 | 0.412629

# IfcPlate: PLT3*538.5 (2)
In: Undefined
Description: PLT3*538.5; Material: STEEL/450
Tekla Common - Bottom elevation: +4.574; Top elevation: +5.064; Phase: 1; Class: 11
Tekla Quantity - Weight: 8.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.6 m2; Height: 538.5 mm; Width: 3 mm; Length: 796 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - NetArea: 0.69912 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00103692 m3; GrossVolume: 0.00103692 m3
Name | ASSEMBLY_POS = Reference | Width (mm) | GrossArea (m2)
PLATE | PL/194 | 538.535 | 0.428679
PLATE | PL/81 | 538.531 | 0.428675

# IfcPlate: PLT3*555.7 (2)
In: Undefined
Description: PLT3*555.7; Material: STEEL/450
Tekla Common - Bottom elevation: +4.575; Top elevation: +5.115; Phase: 1; Class: 11
Tekla Quantity - Weight: 8.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.6 m2; Height: 555.7 mm; Width: 3 mm; Length: 829 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 555.705 mm; NetArea: 0.731391 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00108508 m3; GrossVolume: 0.00108508 m3
Name | ASSEMBLY_POS = Reference | GrossArea (m2)
PLATE | PL/195 | 0.460689
PLATE | PL/83 | 0.460688

# IfcPlate: PLT3*562.6 (2)
In: Undefined
Description: PLT3*562.6; Material: STEEL/450
Tekla Common - Bottom elevation: +4.574; Top elevation: +5.041; Phase: 1; Class: 11
Tekla Quantity - Weight: 9.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.9 m2; Height: 562.6 mm; Width: 3 mm; Length: 825.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000009 m2; NetVolume: 0.0011504 m3; GrossVolume: 0.0011504 m3
Name | ASSEMBLY_POS = Reference | Width (mm) | NetArea (m2) | GrossArea (m2)
PLATE | PL/200 | 562.596 | 0.775279 | 0.464453
PLATE | PL/92 | 562.595 | 0.775278 | 0.464452

# IfcPlate: PLT3*570 (2)
In: Undefined
Description: PLT3*570; Material: STEEL/450
Tekla Common - Bottom elevation: +4.936; Top elevation: +5.419; Phase: 1; Class: 11
Tekla Quantity - Weight: 8.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.6 m2; Height: 570 mm; Width: 3 mm; Length: 761.7 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - NetArea: 0.725868 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00107692 m3; GrossVolume: 0.00107692 m3
Name | ASSEMBLY_POS = Reference | Width (mm) | GrossArea (m2)
PLATE | PL/196 | 570.034 | 0.43421
PLATE | PL/78 | 570.035 | 0.434211

# IfcPlate: PLT3*573.5 (2)
In: Undefined
Description: PLT3*573.5; Material: STEEL/450
Tekla Common - Bottom elevation: +4.574; Top elevation: +5.068; Phase: 1; Class: 11
Tekla Quantity - Weight: 9.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.9 m2; Height: 573.5 mm; Width: 3 mm; Length: 843.2 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 573.52 mm; NetArea: 0.795105 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00118002 m3; GrossVolume: 0.00118002 m3
Name | ASSEMBLY_POS = Reference | GrossArea (m2)
PLATE | PL/201 | 0.483605
PLATE | PL/94 | 0.483604

# IfcPlate: PLT3*589.9 (2)
In: Undefined
Description: PLT3*589.9; Material: STEEL/450
Tekla Common - Bottom elevation: +5.765; Top elevation: +6.267; Phase: 1; Class: 11
Tekla Quantity - Weight: 8.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.6 m2; Height: 589.9 mm; Width: 3 mm; Length: 771.8 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - NetArea: 0.748799 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00111118 m3; GrossVolume: 0.00111118 m3
Name | ASSEMBLY_POS = Reference | Width (mm) | GrossArea (m2)
PLATE | PL/198 | 589.896 | 0.455257
PLATE | PL/84 | 589.901 | 0.455261

# IfcPlate: PLT3*593.8 (2)
In: Undefined
Description: PLT3*593.8; Material: STEEL/450
Tekla Common - Bottom elevation: +4.574; Top elevation: +5.123; Phase: 1; Class: 11
Tekla Quantity - Weight: 9.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.9 m2; Height: 593.8 mm; Width: 3 mm; Length: 878.7 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - NetArea: 0.835641 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00124058 m3; GrossVolume: 0.00124058 m3
Name | ASSEMBLY_POS = Reference | Width (mm) | GrossArea (m2)
PLATE | PL/199 | 593.82 | 0.521792
PLATE | PL/104 | 593.827 | 0.521799

# IfcPlate: PLT3*606 (2)
In: Undefined
Description: PLT3*606; Material: STEEL/450
Tekla Common - Bottom elevation: +4.930; Top elevation: +5.419; Phase: 1; Class: 11
Tekla Quantity - Weight: 9.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.9 m2; Height: 606 mm; Width: 3 mm; Length: 809.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - NetArea: 0.825728 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00122582 m3; GrossVolume: 0.00122582 m3
Name | ASSEMBLY_POS = Reference | Width (mm) | GrossArea (m2)
PLATE | PL/204 | 605.985 | 0.49061
PLATE | PL/93 | 605.983 | 0.490608

# IfcPlate: PLT3*613.5 (2)
In: Undefined
Description: PLT3*613.5; Material: STEEL/450
Tekla Common - Bottom elevation: +5.171; Top elevation: +5.700; Phase: 1; Class: 11
Tekla Quantity - Weight: 9.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.9 m2; Height: 613.5 mm; Width: 3 mm; Length: 766.2 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000009 m2; NetVolume: 0.00115449 m3; GrossVolume: 0.00115449 m3
Name | ASSEMBLY_POS = Reference | Width (mm) | NetArea (m2) | GrossArea (m2)
PLATE | PL/197 | 613.523 | 0.777789 | 0.470081
PLATE | PL/82 | 613.526 | 0.77779 | 0.470084

# IfcPlate: PLT3*615.6 (2)
In: Undefined
Description: PLT3*615.6; Material: STEEL/450
Tekla Common - Bottom elevation: +6.173; Top elevation: +6.700; Phase: 1; Class: 11
Tekla Quantity - Weight: 9.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.9 m2; Height: 615.6 mm; Width: 3 mm; Length: 783.2 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 615.642 mm; NetArea: 0.776955 m2; GrossArea: 0.48217 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00115317 m3; GrossVolume: 0.00115317 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/129
PLATE | PL/127

# IfcPlate: PLT3*644.9 (2)
In: Undefined
Description: PLT3*644.9; Material: STEEL/450
Tekla Common - Bottom elevation: +5.170; Top elevation: +5.700; Phase: 1; Class: 11
Tekla Quantity - Weight: 10.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.9 m2; Height: 644.9 mm; Width: 3 mm; Length: 815.2 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - NetArea: 0.877296 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.0013029 m3; GrossVolume: 0.0013029 m3
Name | ASSEMBLY_POS = Reference | Width (mm) | GrossArea (m2)
PLATE | PL/203 | 644.925 | 0.525727
PLATE | PL/95 | 644.926 | 0.525728

# IfcPlate: PLT3*668.3, PLATE
In: Undefined
Description: PLT3*668.3; Material: STEEL/450
Tekla Common - Bottom elevation: +5.715; Top elevation: +6.267; Phase: 1; Class: 11
Default - ASSEMBLY_POS: PL/105
Tekla Quantity - Weight: 10.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.9 m2; Height: 668.3 mm; Width: 3 mm; Length: 829.6 mm
Pset_PlateCommon - LoadBearing: no; Reference: PL/105
BaseQuantities - Width: 668.348 mm; NetArea: 0.908001 m2; GrossArea: 0.554431 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00134879 m3; GrossVolume: 0.00134879 m3

# IfcPlate: PLT3*668.4, PLATE
In: Undefined
Description: PLT3*668.4; Material: STEEL/450
Default - ASSEMBLY_POS: PL/202
Tekla Common - Bottom elevation: +5.715; Top elevation: +6.267; Phase: 1; Class: 11
Tekla Quantity - Weight: 10.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.9 m2; Height: 668.4 mm; Width: 3 mm; Length: 829.6 mm
Pset_PlateCommon - LoadBearing: no; Reference: PL/202
BaseQuantities - Width: 668.353 mm; NetArea: 0.908002 m2; GrossArea: 0.554436 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00134879 m3; GrossVolume: 0.00134879 m3

# IfcPlate: PLT3*693.6 (2)
In: Undefined
Description: PLT3*693.6; Material: STEEL/450
Tekla Common - Bottom elevation: +6.123; Top elevation: +6.700; Phase: 1; Class: 11
Tekla Quantity - Weight: 11 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.7 m2; Net surface area: 0.9 m2; Height: 693.6 mm; Width: 3 mm; Length: 843.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 693.603 mm; NetArea: 0.939159 m2; GrossArea: 0.585119 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00139527 m3; GrossVolume: 0.00139527 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/131
PLATE | PL/130
