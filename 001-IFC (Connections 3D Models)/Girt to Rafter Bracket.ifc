Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView_V2.0, QuantityTakeOffAddOnView], Option [BaseQuantities:On], Option [GridExport:Off], Option [Assemblies:On], Option [Bolts:On], Option [Rebars:On], Option [PourObjects:Off], Option [Welds:Off], Option [SurfaceTreatments:Off], Option [LocationBy:0], Option [ViewColors:Off], Option [SectionedSpine:Off], Option [PropertySets:On], Option [Export all:Off]
File name: Girt to Rafter Bracket.ifc
Time: 2026-10-06T08:50:39
Author: DESKTOP-BKNQL56\admin
Organization: Structural Designer
Written by: IFC Database version: Work
Made in: Tekla Structures 2019 Service Pack 13, IFC Export Version: 4.0.0.0 Oct 18 2021

# IfcBuildingStorey, Undefined
In: Undefined
Elevation: 0 mm

# IfcBeam: C:150-24 (4)
In: Undefined
Description: C:150-24; Material: STEEL/G450
Default - ASSEMBLY_POS: Z/2346
Tekla Common - Finish: 12 deg; Phase: 1; Class: 1
Tekla Quantity - Weight: 8.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 111.3 m2; Net surface area: 0.9 m2; Height: 152 mm; Width: 64 mm; Length: 1500 mm
Pset_BeamCommon - LoadBearing: no; Reference: Z/2346
BaseQuantities - Length: 1500 mm; OuterSurfaceArea: 0.930876 m2; NetVolume: 0.00110664 m3; NetWeight: 8.68712 kg
Name | Bottom elevation | Top elevation
RAFTER | +2.329 | +2.739
RAFTER | +3.179 | +3.589
RAFTER | +4.029 | +4.439
RAFTER | +4.879 | +5.289

# IfcBeam: TH:120-95, TH
In: Undefined
Description: TH:120-95; Material: STEEL/300PLUS
Default - ASSEMBLY_POS: B/9
Tekla Common - Bottom elevation: +2.184; Top elevation: +2.349; Phase: 1; Class: 4
Tekla Quantity - Weight: 2.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 0 m2; Net surface area: 0.9 m2; Height: 120 mm; Width: 165 mm; Length: 1343.4 mm
Pset_BeamCommon - LoadBearing: no; Reference: B/9
BaseQuantities - Length: 1343.4 mm; OuterSurfaceArea: 6.12617e-07 m2; NetVolume: 0.000471807 m3; NetWeight: 3.70369 kg

# IfcBeam: TH:64-95, TH
In: Undefined
Description: TH:64-95; Material: STEEL/300PLUS
Default - ASSEMBLY_POS: B/115
Tekla Common - Bottom elevation: +4.773; Top elevation: +4.903; Phase: 1; Class: 4
Tekla Quantity - Weight: 1.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 0 m2; Net surface area: 0.4 m2; Height: 64 mm; Width: 130 mm; Length: 1000 mm
Pset_BeamCommon - LoadBearing: no; Reference: B/115
BaseQuantities - Length: 1000 mm; OuterSurfaceArea: 4.5602e-07 m2; NetVolume: 0.000215558 m3; NetWeight: 1.69213 kg

# IfcBeam: TH:75-95, TH
In: Undefined
Description: TH:75-95; Material: STEEL/300PLUS
Default - ASSEMBLY_POS: B/7
Tekla Common - Bottom elevation: +3.924; Top elevation: +4.049; Phase: 1; Class: 4
Tekla Quantity - Weight: 2.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 0 m2; Net surface area: 0.6 m2; Height: 75 mm; Width: 125 mm; Length: 1343.4 mm
Pset_BeamCommon - LoadBearing: no; Reference: B/7
BaseQuantities - Length: 1343.4 mm; OuterSurfaceArea: 6.12617e-07 m2; NetVolume: 0.000311535 m3; NetWeight: 2.44555 kg

# IfcBeam: TH:96-95, TH
In: Undefined
Description: TH:96-95; Material: STEEL/300PLUS
Default - ASSEMBLY_POS: B/8
Tekla Common - Bottom elevation: +3.049; Top elevation: +3.199; Phase: 1; Class: 4
Tekla Quantity - Weight: 2.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 0 m2; Net surface area: 0.9 m2; Height: 96 mm; Width: 150 mm; Length: 1343.4 mm
Pset_BeamCommon - LoadBearing: no; Reference: B/8
BaseQuantities - Length: 1343.4 mm; OuterSurfaceArea: 6.12617e-07 m2; NetVolume: 0.000385787 m3; NetWeight: 3.02843 kg

# IfcElementAssembly (12)
In: Undefined
PredefinedType: RIGID_FRAME
Name | ASSEMBLY_POS = Assembly/Cast unit Mark | Assembly/Cast unit weight (kg) | Assembly/Cast unit bottom elevation | Assembly/Cast unit top elevation | Width (mm)
GIRT BRACKET | GB/5 | 0.5 | +2.184 | +2.392 | 107.6
RAFTER | Z/2346 | 8.4 | +2.329 | +2.739 | 64
GIRT BRACKET | GB/6 | 0.5 | +3.049 | +3.242 | 83.6
RAFTER | Z/2346 | 8.4 | +3.179 | +3.589 | 64
GIRT BRACKET | GB/7 | 0.5 | +3.924 | +4.092 | 62.6
RAFTER | Z/2346 | 8.4 | +4.029 | +4.439 | 64
GIRT BRACKET | GB/11 | 0.3 | +4.773 | +4.942 | 51.6
TH | B/9 | 2.4 | +2.184 | +2.349 | 165
TH | B/8 | 2.4 | +3.049 | +3.199 | 150
TH | B/7 | 2.4 | +3.924 | +4.049 | 125
TH | B/115 | 1.8 | +4.773 | +4.903 | 130
RAFTER | Z/2346 | 8.4 | +4.879 | +5.289 | 64

# IfcPlate: PLT1.6*138.4, GIRT BRACKET
In: Undefined
Description: PLT1.6*138.4; Material: STEEL/250
Default - ASSEMBLY_POS: GB/11
Tekla Common - Bottom elevation: +4.773; Top elevation: +4.942; Phase: 1; Class: 11
Tekla Quantity - Weight: 0.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 162.7 m2; Net surface area: 0.1 m2; Height: 138.4 mm; Width: 1.6 mm; Length: 214.8 mm
Pset_PlateCommon - LoadBearing: no; Reference: GB/11
BaseQuantities - Width: 138.447 mm; NetArea: 0.0546126 m2; GrossArea: 0.029735 m2; CrossSectionArea: 0.00000256 m2; NetVolume: 0.0000427323 m3; GrossVolume: 0.0000427323 m3

# IfcPlate: PLT1.6*140.4, GIRT BRACKET
In: Undefined
Description: PLT1.6*140.4; Material: STEEL/250
Default - ASSEMBLY_POS: GB/7
Tekla Common - Bottom elevation: +3.924; Top elevation: +4.092; Phase: 1; Class: 11
Tekla Quantity - Weight: 0.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 162.7 m2; Net surface area: 0.1 m2; Height: 140.4 mm; Width: 1.6 mm; Length: 225 mm
Pset_PlateCommon - LoadBearing: no; Reference: GB/7
BaseQuantities - Width: 140.357 mm; NetArea: 0.0573967 m2; GrossArea: 0.0315829 m2; CrossSectionArea: 0.00000256 m2; NetVolume: 0.000044933 m3; GrossVolume: 0.000044933 m3

# IfcPlate: PLT1.6*144, GIRT BRACKET
In: Undefined
Description: PLT1.6*144; Material: STEEL/250
Default - ASSEMBLY_POS: GB/6
Tekla Common - Bottom elevation: +3.049; Top elevation: +3.242; Phase: 1; Class: 11
Tekla Quantity - Weight: 0.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 162.5 m2; Net surface area: 0.1 m2; Height: 144 mm; Width: 1.6 mm; Length: 270.7 mm
Pset_PlateCommon - LoadBearing: no; Reference: GB/6
BaseQuantities - Width: 144.004 mm; NetArea: 0.0695883 m2; GrossArea: 0.0389817 m2; CrossSectionArea: 0.00000256 m2; NetVolume: 0.0000545685 m3; GrossVolume: 0.0000545685 m3

# IfcPlate: PLT1.6*148.2, GIRT BRACKET
In: Undefined
Description: PLT1.6*148.2; Material: STEEL/250
Default - ASSEMBLY_POS: GB/5
Tekla Common - Bottom elevation: +2.184; Top elevation: +2.392; Phase: 1; Class: 11
Tekla Quantity - Weight: 0.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 162.3 m2; Net surface area: 0.1 m2; Height: 148.2 mm; Width: 1.6 mm; Length: 309.3 mm
Pset_PlateCommon - LoadBearing: no; Reference: GB/5
BaseQuantities - Width: 148.172 mm; NetArea: 0.0799496 m2; GrossArea: 0.0458345 m2; CrossSectionArea: 0.00000256 m2; NetVolume: 0.0000627577 m3; GrossVolume: 0.0000627577 m3
