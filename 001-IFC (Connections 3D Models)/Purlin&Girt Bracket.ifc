Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView_V2.0, QuantityTakeOffAddOnView], Option [BaseQuantities:On], Option [GridExport:On], Option [Assemblies:On], Option [Bolts:On], Option [Rebars:On], Option [PourObjects:Off], Option [Welds:Off], Option [SurfaceTreatments:Off], Option [LocationBy:0], Option [ViewColors:Off], Option [SectionedSpine:Off], Option [PropertySets:On], Option [Export all:Off]
File name: Purlin&Girt Bracket.ifc
Time: 2026-04-16T14:20:36
Author: DESKTOP-BKNQL56\admin
Organization: Structural Designer
Written by: IFC Database Version: Work
Made in: Tekla Structures 2019 Service Pack 13, IFC Export Version: 4.0.0.0 Oct 18 2021

# IfcBuildingStorey, Undefined
In: Undefined
Elevation: 0 mm

# IfcBeam: C:100-15 (9)
In: Undefined
Description: C:100-15; Material: STEEL/450
Tekla Common - Bottom elevation: +0.249; Top elevation: +0.300; Phase: 1; Class: 99
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 102 mm; Width: 51 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
6 x GIRT | Z/1674 | 1.1 | 179.3 | 0.2 | 426 | 0.193653 | 0.000143775 | 1.12863
2 x GIRT | Z/1658 | 0.5 | 179.9 | 0.1 | 213 | 0.097164 | 0.0000718875 | 0.564317
GIRT | Z/1665(?) | 1.1 | 179.3 | 0.2 | 436 | 0.198183 | 0.00014715 | 1.15513

# IfcBeam: C:150-15 (9)
In: Undefined
Description: C:150-15; Material: STEEL/450
Tekla Common - Bottom elevation: +0.936; Top elevation: +1.000; Phase: 1; Class: 99
Tekla Quantity - Volume: 0 m3; Height: 152 mm; Width: 64 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Weight (kg) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
6 x GIRT | Z/1675 | 1.5 | 0.1 | 176.9 | 0.3 | 426 | 0.262053 | 0.000194895 | 1.52993
2 x GIRT | Z/1659 | 0.6 | 0 | 177.5 | 0.1 | 213 | 0.131484 | 0.0000974475 | 0.764963
GIRT | Z/1666(?) | 1.5 | 0.1 | 176.9 | 0.3 | 436 | 0.268183 | 0.00019947 | 1.56584

# IfcBeam: C:200-15 (9)
In: Undefined
Description: C:200-15; Material: STEEL/450
Tekla Common - Bottom elevation: +1.624; Top elevation: +1.700; Phase: 1; Class: 99
Tekla Quantity - Volume: 0 m3; Height: 203 mm; Width: 76 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Weight (kg) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
6 x GIRT | Z/1676 | 1.9 | 0.1 | 175.7 | 0.3 | 426 | 0.326178 | 0.00024282 | 1.90614
GIRT | Z/1660 | 0.9 | 0 | 176.4 | 0.2 | 213 | 0.163659 | 0.00012141 | 0.953069
GIRT | Z/1660 | 0.9 | 0 | 176.4 | 0.2 | 213 | 0.163659 | 0.00012141 | 0.953068
GIRT | Z/1667(?) | 1.9 | 0.1 | 175.7 | 0.3 | 436 | 0.333808 | 0.00024852 | 1.95088

# IfcBeam: Z:100-15 (3)
In: Undefined
Description: Z:100-15; Material: STEEL/450
Tekla Common - Phase: 1; Class: 99
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 102 mm; Width: 100.5 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
GIRT | Z/1677 | +0.248 | +0.348 | 2.4 | 179.3 | 0.3 | 950 | 0.431025 | 0.000320625 | 2.51691
GIRT | Z/1684 | +0.252 | +0.352 | 2.4 | 179.3 | 0.3 | 950 | 0.431025 | 0.000320625 | 2.51691
GIRT | Z/1680 | +0.248 | +0.348 | 1.1 | 179.5 | 0.2 | 436 | 0.198183 | 0.00014715 | 1.15513

# IfcBeam: Z:150-15 (3)
In: Undefined
Description: Z:150-15; Material: STEEL/450
Tekla Common - Phase: 1; Class: 99
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 152 mm; Width: 124.5 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
GIRT | Z/1678 | +0.936 | +1.060 | 3.3 | 176.7 | 0.6 | 950 | 0.583265 | 0.000434625 | 3.41181
GIRT | Z/1685 | +0.940 | +1.064 | 3.3 | 176.7 | 0.6 | 950 | 0.583265 | 0.000434625 | 3.41181
GIRT | Z/1681 | +0.936 | +1.060 | 1.5 | 177.1 | 0.3 | 436 | 0.268183 | 0.00019947 | 1.56584

# IfcBeam: Z:200-15 (3)
In: Undefined
Description: Z:200-15; Material: STEEL/450
Tekla Common - Phase: 1; Class: 99
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 203 mm; Width: 151.5 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
GIRT | Z/1679 | +1.622 | +1.773 | 4.1 | 175.4 | 0.6 | 950 | 0.72599 | 0.0005415 | 4.25077
GIRT | Z/1686 | +1.627 | +1.778 | 4.1 | 175.4 | 0.6 | 950 | 0.72599 | 0.0005415 | 4.25078
GIRT | Z/1682 | +1.622 | +1.773 | 1.9 | 175.7 | 0.3 | 436 | 0.333808 | 0.00024852 | 1.95088

# IfcColumn: C:100-19, COLUMN
In: Undefined
Description: C:100-19; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Top elevation: +2.000; Phase: 1; Class: 12
Default - ASSEMBLY_POS: Z/1670
Tekla Quantity - Weight: 6.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 141.7 m2; Net surface area: 0.9 m2; Height: 102 mm; Width: 51 mm; Length: 2000 mm
Pset_ColumnCommon - LoadBearing: no; Reference: Z/1670
BaseQuantities - Length: 2000 mm; OuterSurfaceArea: 0.910057 m2; NetVolume: 0.00085652 m3; NetWeight: 6.72368 kg

# IfcColumn: C:150-24 (5)
In: Undefined
Description: C:150-24; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Top elevation: +2.000; Phase: 1; Class: 12
Tekla Quantity - Weight: 11.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 111.3 m2; Net surface area: 1.2 m2; Height: 152 mm; Width: 64 mm; Length: 2000 mm
Pset_ColumnCommon - LoadBearing: no
BaseQuantities - Length: 2000 mm; OuterSurfaceArea: 1.24068 m2; NetVolume: 0.00147552 m3; NetWeight: 11.5828 kg
Name | ASSEMBLY_POS = Reference
COLUMN | Z/1664
2 x COLUMN | Z/1683
COLUMN | Z/1668
COLUMN | Z/1668(?)

# IfcColumn: C:200-24, COLUMN
In: Undefined
Description: C:200-24; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Top elevation: +2.000; Phase: 1; Class: 12
Default - ASSEMBLY_POS: Z/1663
Tekla Quantity - Weight: 14.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 110.1 m2; Net surface area: 1.6 m2; Height: 203 mm; Width: 76 mm; Length: 2000 mm
Pset_ColumnCommon - LoadBearing: no; Reference: Z/1663
BaseQuantities - Length: 2000 mm; OuterSurfaceArea: 1.56106 m2; NetVolume: 0.00185952 m3; NetWeight: 14.5972 kg

# IfcColumn: C:250-24, COLUMN
In: Undefined
Description: C:250-24; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Top elevation: +2.000; Phase: 1; Class: 12
Default - ASSEMBLY_POS: Z/1662
Tekla Quantity - Weight: 16 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 109.8 m2; Net surface area: 1.8 m2; Height: 254 mm; Width: 76 mm; Length: 2000 mm
Pset_ColumnCommon - LoadBearing: no; Reference: Z/1662
BaseQuantities - Length: 2000 mm; OuterSurfaceArea: 1.7613 m2; NetVolume: 0.00209952 m3; NetWeight: 16.4812 kg

# IfcColumn: C:300-24, COLUMN
In: Undefined
Description: C:300-24; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Top elevation: +2.000; Phase: 1; Class: 12
Default - ASSEMBLY_POS: Z/1661
Tekla Quantity - Weight: 19.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 108.6 m2; Net surface area: 2.2 m2; Height: 300 mm; Width: 96 mm; Length: 2000 mm
Pset_ColumnCommon - LoadBearing: no; Reference: Z/1661
BaseQuantities - Length: 2000 mm; OuterSurfaceArea: 2.16178 m2; NetVolume: 0.00257952 m3; NetWeight: 20.2492 kg

# IfcColumn: C:350-30, COLUMN
In: Undefined
Description: C:350-30; Material: STEEL/G450
Default - ASSEMBLY_POS: Z/1690
Tekla Common - Bottom elevation: +0.000; Top elevation: +2.000; Phase: 1; Class: 12
Tekla Quantity - Weight: 29.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.2 m2; Net surface area: 2.6 m2; Height: 350 mm; Width: 125 mm; Length: 2000 mm
Pset_ColumnCommon - LoadBearing: no; Reference: Z/1690
BaseQuantities - Length: 2000 mm; OuterSurfaceArea: 2.60789 m2; NetVolume: 0.003888 m3; NetWeight: 30.5208 kg

# IfcElementAssembly (76)
In: Undefined
PredefinedType: RIGID_FRAME
Name | ASSEMBLY_POS = Assembly/Cast unit Mark | Assembly/Cast unit weight (kg) | Assembly/Cast unit bottom elevation | Assembly/Cast unit top elevation | Width (mm)
GIRT | Z/1665(?) | 1.1 | +0.249 | +0.300 | 51 | Default - ASSEMBLY_POSITION_CODE: C-GIRT/PURLIN/1; Tekla Assembly - Assembly/Cast unit position code: C-GIRT/PURLIN/1
GIRT | Z/1666(?) | 1.5 | +0.936 | +1.000 | 64 | Default - ASSEMBLY_POSITION_CODE: C-GIRT/PURLIN/1; Tekla Assembly - Assembly/Cast unit position code: C-GIRT/PURLIN/1
COLUMN | Z/1668(?) | 11.1 | +0.000 | +2.000 | 64 | Default - ASSEMBLY_POSITION_CODE: C-GIRT/PURLIN/1; Tekla Assembly - Assembly/Cast unit position code: C-GIRT/PURLIN/1
6 x GIRT BRACKETS | PL/765 | 0.6 | +1.633 | +1.699 | 65
COLUMN | Z/1690 | 29.9 | +0.000 | +2.000 | 125
6 x GIRT BRACKETS | PL/764 | 0.5 | +0.934 | +0.999 | 65
6 x GIRT BRACKETS | PL/763 | 0.3 | +0.234 | +0.299 | 65
6 x GIRT | Z/1676 | 1.9 | +1.624 | +1.700 | 76
6 x GIRT | Z/1675 | 1.5 | +0.936 | +1.000 | 64
6 x GIRT | Z/1674 | 1.1 | +0.249 | +0.300 | 51
COLUMN | Z/1661 | 19.9 | +0.000 | +2.000 | 96
COLUMN | Z/1662 | 16 | +0.000 | +2.000 | 76
COLUMN | Z/1663 | 14.2 | +0.000 | +2.000 | 76
COLUMN | Z/1664 | 11.1 | +0.000 | +2.000 | 64
COLUMN | Z/1670 | 6.4 | +0.000 | +2.000 | 51
GIRT | Z/1677 | 2.4 | +0.248 | +0.348 | 100.5 | Default - ASSEMBLY_POSITION_CODE: Z-GIRT/PURLIN/2; Tekla Assembly - Assembly/Cast unit position code: Z-GIRT/PURLIN/2
GIRT | Z/1678 | 3.3 | +0.936 | +1.060 | 124.5 | Default - ASSEMBLY_POSITION_CODE: Z-GIRT/PURLIN/2; Tekla Assembly - Assembly/Cast unit position code: Z-GIRT/PURLIN/2
GIRT | Z/1686 | 4.1 | +1.627 | +1.778 | 151.5 | Default - ASSEMBLY_POSITION_CODE: Z-GIRT/PURLIN/2; Tekla Assembly - Assembly/Cast unit position code: Z-GIRT/PURLIN/2
GIRT | Z/1685 | 3.3 | +0.940 | +1.064 | 124.5 | Default - ASSEMBLY_POSITION_CODE: Z-GIRT/PURLIN/2; Tekla Assembly - Assembly/Cast unit position code: Z-GIRT/PURLIN/2
GIRT | Z/1684 | 2.4 | +0.252 | +0.352 | 100.5 | Default - ASSEMBLY_POSITION_CODE: Z-GIRT/PURLIN/2; Tekla Assembly - Assembly/Cast unit position code: Z-GIRT/PURLIN/2
GIRT | Z/1679 | 4.1 | +1.622 | +1.773 | 151.5 | Default - ASSEMBLY_POSITION_CODE: Z-GIRT/PURLIN/2; Tekla Assembly - Assembly/Cast unit position code: Z-GIRT/PURLIN/2
GIRT/PURLIN BRACKETS | PL/760 | 0.6 | +1.700 | +1.765 | 65 | Default - ASSEMBLY_POSITION_CODE: C-GIRT/PURLIN/2; Tekla Assembly - Assembly/Cast unit position code: C-GIRT/PURLIN/2
GIRT/PURLIN BRACKETS | PL/761 | 0.5 | +1.000 | +1.065 | 65 | Default - ASSEMBLY_POSITION_CODE: C-GIRT/PURLIN/2; Tekla Assembly - Assembly/Cast unit position code: C-GIRT/PURLIN/2
GIRT/PURLIN BRACKETS | PL/762 | 0.3 | +0.300 | +0.365 | 65 | Default - ASSEMBLY_POSITION_CODE: C-GIRT/PURLIN/2; Tekla Assembly - Assembly/Cast unit position code: C-GIRT/PURLIN/2
2 x GIRT | Z/1658 | 0.5 | +0.249 | +0.300 | 51 | Default - ASSEMBLY_POSITION_CODE: C-GIRT/PURLIN/2; Tekla Assembly - Assembly/Cast unit position code: C-GIRT/PURLIN/2
2 x GIRT | Z/1659 | 0.6 | +0.936 | +1.000 | 64 | Default - ASSEMBLY_POSITION_CODE: C-GIRT/PURLIN/2; Tekla Assembly - Assembly/Cast unit position code: C-GIRT/PURLIN/2
2 x GIRT | Z/1660 | 0.9 | +1.624 | +1.700 | 76 | Default - ASSEMBLY_POSITION_CODE: C-GIRT/PURLIN/2; Tekla Assembly - Assembly/Cast unit position code: C-GIRT/PURLIN/2
GIRT/PURLIN BRACKETS | PL/757 | 0.3 | +1.634 | +1.699 | 65 | Default - ASSEMBLY_POSITION_CODE: Z-GIRT/PURLIN/2; Tekla Assembly - Assembly/Cast unit position code: Z-GIRT/PURLIN/2
COLUMN | Z/1683 | 11.1 | +0.000 | +2.000 | 64 | Default - ASSEMBLY_POSITION_CODE: Z-GIRT/PURLIN/2; Tekla Assembly - Assembly/Cast unit position code: Z-GIRT/PURLIN/2
GIRT/PURLIN BRACKETS | PL/758 | 0.3 | +0.934 | +0.999 | 65 | Default - ASSEMBLY_POSITION_CODE: Z-GIRT/PURLIN/2; Tekla Assembly - Assembly/Cast unit position code: Z-GIRT/PURLIN/2
GIRT/PURLIN BRACKETS | PL/759 | 0.2 | +0.234 | +0.299 | 65 | Default - ASSEMBLY_POSITION_CODE: Z-GIRT/PURLIN/2; Tekla Assembly - Assembly/Cast unit position code: Z-GIRT/PURLIN/2
COLUMN | Z/1683 | 11.1 | +0.000 | +2.000 | 64 | Default - ASSEMBLY_POSITION_CODE: Z-GIRT/PURLIN/1; Tekla Assembly - Assembly/Cast unit position code: Z-GIRT/PURLIN/1
COLUMN | Z/1668 | 11.1 | +0.000 | +2.000 | 64 | Default - ASSEMBLY_POSITION_CODE: C-GIRT/PURLIN/2; Tekla Assembly - Assembly/Cast unit position code: C-GIRT/PURLIN/2
GIRT | Z/1682 | 1.9 | +1.622 | +1.773 | 151.5 | Default - ASSEMBLY_POSITION_CODE: Z-GIRT/PURLIN/1; Tekla Assembly - Assembly/Cast unit position code: Z-GIRT/PURLIN/1
GIRT | Z/1681 | 1.5 | +0.936 | +1.060 | 124.5 | Default - ASSEMBLY_POSITION_CODE: Z-GIRT/PURLIN/1; Tekla Assembly - Assembly/Cast unit position code: Z-GIRT/PURLIN/1
GIRT | Z/1680 | 1.1 | +0.248 | +0.348 | 100.5 | Default - ASSEMBLY_POSITION_CODE: Z-GIRT/PURLIN/1; Tekla Assembly - Assembly/Cast unit position code: Z-GIRT/PURLIN/1
GIRT/PURLIN BRACKETS | PL/757 | 0.3 | +1.634 | +1.699 | 65 | Default - ASSEMBLY_POSITION_CODE: Z-GIRT/PURLIN/1; Tekla Assembly - Assembly/Cast unit position code: Z-GIRT/PURLIN/1
GIRT/PURLIN BRACKETS | PL/758 | 0.3 | +0.934 | +0.999 | 65 | Default - ASSEMBLY_POSITION_CODE: Z-GIRT/PURLIN/1; Tekla Assembly - Assembly/Cast unit position code: Z-GIRT/PURLIN/1
GIRT/PURLIN BRACKETS | PL/759 | 0.2 | +0.234 | +0.299 | 65 | Default - ASSEMBLY_POSITION_CODE: Z-GIRT/PURLIN/1; Tekla Assembly - Assembly/Cast unit position code: Z-GIRT/PURLIN/1
GIRT | Z/1667(?) | 1.9 | +1.624 | +1.700 | 76 | Default - ASSEMBLY_POSITION_CODE: C-GIRT/PURLIN/1; Tekla Assembly - Assembly/Cast unit position code: C-GIRT/PURLIN/1
GIRT/PURLIN BRACKETS | PL/757 | 0.3 | +1.700 | +1.765 | 65 | Default - ASSEMBLY_POSITION_CODE: C-GIRT/PURLIN/1; Tekla Assembly - Assembly/Cast unit position code: C-GIRT/PURLIN/1
GIRT/PURLIN BRACKETS | PL/758 | 0.3 | +1.000 | +1.065 | 65 | Default - ASSEMBLY_POSITION_CODE: C-GIRT/PURLIN/1; Tekla Assembly - Assembly/Cast unit position code: C-GIRT/PURLIN/1
GIRT/PURLIN BRACKETS | PL/759 | 0.2 | +0.300 | +0.365 | 65 | Default - ASSEMBLY_POSITION_CODE: C-GIRT/PURLIN/1; Tekla Assembly - Assembly/Cast unit position code: C-GIRT/PURLIN/1

# IfcMechanicalFastener: Bolt assembly (102)
In: Undefined
NominalDiameter: 12 mm; Material: PB1230
Tekla Bolt - Washer diameter: 12 mm; Washer type: FLAT; Washer name: WASHERM12-FLAT; Nut type: 4.6-HEX; Nut name: NUTM12-4.6-HEX; Slotted hole x: 0 mm; Location: Site; Bolt standard: PB1230; Bolt Name: BOLTPB1230
Name | NominalLength (mm) = Bolt length (mm) | Washer count = Nut count | Slotted hole y (mm) | Bolt hole diameter (mm) | Bolt count | Bolt size (mm)
27 x Bolt assembly | 30 | 1 | 0 | 18 | 1 | 12
6 x Bolt assembly | 3 | 0 | 160 | 14 | 1 | 14
18 x Bolt assembly | 30 | 1 | 0 | 14 | 1 | 12
6 x Bolt assembly | 3 | 0 | 110 | 14 | 1 | 14
6 x Bolt assembly | 3 | 0 | 60 | 14 | 1 | 14
39 x Bolt assembly | 30 | 2 | 0 | 18 | 2 | 12

# IfcPlate: PLT3*137.1 (12)
In: Undefined
Description: PLT3*137.1; Material: STEEL/250
Tekla Common - Phase: 1; Class: 10
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 137.1 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 137.069 mm; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
6 x GIRT BRACKETS | PL/765 | +1.633 | +1.699 | 0.6 | 88.5 | 0.1 | 190 | 0.054861 | 0.026043 | 0.0000789366
6 x GIRT BRACKETS | PL/764 | +0.934 | +0.999 | 0.5 | 89 | 0 | 140 | 0.0406425 | 0.0191896 | 0.0000581638

# IfcPlate: PLT3*150 (3)
In: Undefined
Description: PLT3*150; Material: STEEL/250
Tekla Common - Phase: 1; Class: 10
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 150 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 150 mm; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) | GrossVolume (m3)
GIRT/PURLIN BRACKETS | PL/760 | +1.700 | +1.765 | 0.6 | 88.3 | 0.1 | 243.6 | 0.064072 | 0.0365353 | 0.0000924274 | 0.000110243
GIRT/PURLIN BRACKETS | PL/761 | +1.000 | +1.065 | 0.5 | 89 | 0 | 193.1 | 0.048619 | 0.0289603 | 0.0000697024 | 0.0000875184
GIRT/PURLIN BRACKETS | PL/762 | +0.300 | +0.365 | 0.3 | 89.6 | 0 | 153.1 | 0.036379 | 0.0229603 | 0.0000517024 | 0.0000695184

# IfcPlate: PLT3*60 (9)
In: Undefined
Description: PLT3*60; Material: STEEL/250
Tekla Common - Phase: 1; Class: 10
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0 m2; Height: 60 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 60 mm; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
2 x GIRT/PURLIN BRACKETS | PL/757 | +1.634 | +1.699 | 0.3 | 90.5 | 243.6 | 0.031312 | 0.0146141 | 0.0000440974
2 x GIRT/PURLIN BRACKETS | PL/758 | +0.934 | +0.999 | 0.3 | 90.8 | 193.1 | 0.024949 | 0.0115841 | 0.0000350074
2 x GIRT/PURLIN BRACKETS | PL/759 | +0.234 | +0.299 | 0.2 | 91.2 | 153.1 | 0.019909 | 0.00918412 | 0.0000278074
GIRT/PURLIN BRACKETS | PL/757 | +1.700 | +1.765 | 0.3 | 90.5 | 243.6 | 0.031312 | 0.0146141 | 0.0000440974
GIRT/PURLIN BRACKETS | PL/758 | +1.000 | +1.065 | 0.3 | 90.8 | 193.1 | 0.024949 | 0.0115841 | 0.0000350074
GIRT/PURLIN BRACKETS | PL/759 | +0.300 | +0.365 | 0.2 | 91.2 | 153.1 | 0.019909 | 0.00918412 | 0.0000278074

# IfcPlate: PLT3*90 (6)
In: Undefined
Description: PLT3*90; Material: STEEL/250
Default - ASSEMBLY_POS: PL/763
Tekla Common - Bottom elevation: +0.234; Top elevation: +0.299; Phase: 1; Class: 10
Tekla Quantity - Weight: 0.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 90 m2; Net surface area: 0 m2; Height: 90 mm; Width: 3 mm; Length: 137.1 mm
Pset_PlateCommon - LoadBearing: no; Reference: PL/763
BaseQuantities - Width: 90 mm; NetArea: 0.0264241 m2; GrossArea: 0.0123362 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000037391 m3; GrossVolume: 0.000037391 m3
