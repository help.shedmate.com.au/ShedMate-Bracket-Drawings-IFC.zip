Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView_V2.0, QuantityTakeOffAddOnView], Option [BaseQuantities:On], Option [GridExport:Off], Option [Assemblies:Off], Option [Bolts:On], Option [Rebars:On], Option [PourObjects:Off], Option [Welds:Off], Option [SurfaceTreatments:Off], Option [LocationBy:0], Option [ViewColors:Off], Option [SectionedSpine:Off], Option [PropertySets:On], Option [Export all:Off]
File name: Double C-Section Column Welded Baseplate.ifc
Time: 2026-03-26T06:20:15
Author: DESKTOP-BKNQL56\admin
Organization: Structural Designer
Written by: IFC Database Version: Work
Made in: Tekla Structures 2019 Service Pack 13, IFC Export Version: 4.0.0.0 Oct 18 2021

# IfcBuildingStorey, Undefined
In: Undefined
Elevation: 0 mm

# IfcBeam: C:150-24, COLUMN
In: Undefined
Description: C:150-24; Material: STEEL/G450
Tekla Common - Finish: 1mm ggap +4; Bottom elevation: +0.012; Top elevation: +1.500; Phase: 1; Class: 12
Tekla Quantity - Weight: 8.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 111.3 m2; Net surface area: 0.9 m2; Height: 152 mm; Width: 64 mm; Length: 1488 mm
Pset_BeamCommon - LoadBearing: no; Reference: Z/1125
BaseQuantities - Length: 1488 mm; OuterSurfaceArea: 0.923438 m2; NetVolume: 0.00109778 m3; NetWeight: 8.61761 kg

# IfcBeam: C:200-24, COLUMN
In: Undefined
Description: C:200-24; Material: STEEL/G450
Tekla Common - Finish: 1mm ggap +4; Bottom elevation: +0.012; Top elevation: +1.500; Phase: 1; Class: 12
Tekla Quantity - Weight: 10.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 110.2 m2; Net surface area: 1.2 m2; Height: 203 mm; Width: 76 mm; Length: 1488 mm
Pset_BeamCommon - LoadBearing: no; Reference: Z/1128
BaseQuantities - Length: 1488 mm; OuterSurfaceArea: 1.1619 m2; NetVolume: 0.00138348 m3; NetWeight: 10.8603 kg

# IfcBeam: C:250-24, COLUMN
In: Undefined
Description: C:250-24; Material: STEEL/G450
Tekla Common - Finish: 1mm ggap +4; Bottom elevation: +0.016; Top elevation: +1.500; Phase: 1; Class: 12
Tekla Quantity - Weight: 11.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 109.8 m2; Net surface area: 1.2 m2; Height: 254 mm; Width: 76 mm; Length: 1484 mm
Pset_BeamCommon - LoadBearing: no; Reference: Z/1130
BaseQuantities - Length: 1484 mm; OuterSurfaceArea: 1.30742 m2; NetVolume: 0.00155784 m3; NetWeight: 12.229 kg

# IfcBeam: C:300-30, COLUMN
In: Undefined
Description: C:300-30; Material: STEEL/G450
Tekla Common - Finish: 1mm ggap +4; Bottom elevation: +0.016; Top elevation: +1.500; Phase: 1; Class: 12
Tekla Quantity - Weight: 18.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.5 m2; Net surface area: 1.6 m2; Height: 300 mm; Width: 96 mm; Length: 1484 mm
Pset_BeamCommon - LoadBearing: no; Reference: Z/1132
BaseQuantities - Length: 1484 mm; OuterSurfaceArea: 1.62378 m2; NetVolume: 0.00241743 m3; NetWeight: 18.9768 kg

# IfcBeam: C:350-30, COLUMN
In: Undefined
Description: C:350-30; Material: STEEL/G450
Tekla Common - Finish: 1mm ggap +4; Bottom elevation: +0.016; Top elevation: +1.500; Phase: 1; Class: 12
Tekla Quantity - Weight: 22.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.2 m2; Net surface area: 1.9 m2; Height: 350 mm; Width: 125 mm; Length: 1484 mm
Pset_BeamCommon - LoadBearing: no; Reference: Z/1134
BaseQuantities - Length: 1484 mm; OuterSurfaceArea: 1.93605 m2; NetVolume: 0.00288489 m3; NetWeight: 22.6464 kg

# IfcBeam: D16 (20)
In: Undefined
Description: D16; Material: STEEL/250
Tekla Common - Phase: 1; Class: 1
Tekla Quantity - Weight: 0.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 35 m2; Net surface area: 0 m2; Height: 16 mm; Width: 16 mm; Length: 486.8 mm
Pset_BeamCommon - LoadBearing: no; Reference: z/2
BaseQuantities - Length: 486.832 mm; OuterSurfaceArea: 0.0241597 m2; NetVolume: 0.0000878359 m3; NetWeight: 0.689512 kg
Name | Bottom elevation | Top elevation
8 x ANCHOR ROD | -0.358 | +0.062
12 x ANCHOR ROD | -0.354 | +0.066

# IfcBeam: M16_NUT (20)
In: Undefined
Description: M16_NUT; Material: STEEL/250
Tekla Common - Phase: 1; Class: 1
Tekla Quantity - Weight: 0.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 30.6 m2; Net surface area: 0 m2; Height: 24.2 mm; Width: 28 mm; Length: 16 mm
Pset_BeamCommon - LoadBearing: no; Reference: z/696
BaseQuantities - Length: 16 mm; OuterSurfaceArea: 0.00236245 m2; NetVolume: 0.00000814757 m3; NetWeight: 0.0639584 kg
Name | Bottom elevation | Top elevation
8 x NUT | +0.017 | +0.033
12 x NUT | +0.021 | +0.037

# IfcBeam: PD32*8 (20)
In: Undefined
Description: PD32*8; Material: STEEL/250
Tekla Common - Phase: 1; Class: 1
Tekla Quantity - Weight: 0 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 56 m2; Net surface area: 0 m2; Height: 32 mm; Width: 32 mm; Length: 5 mm
Pset_BeamCommon - LoadBearing: no; Reference: z/695
BaseQuantities - Length: 5 mm; OuterSurfaceArea: 0.00126493 m2; NetVolume: 0.00000288 m3; NetWeight: 0.022608 kg
Name | Bottom elevation | Top elevation
8 x WASHER | +0.012 | +0.017
12 x WASHER | +0.016 | +0.021

# IfcColumn: C:150-24, COLUMN
In: Undefined
Description: C:150-24; Material: STEEL/G450
Tekla Common - Finish: 1mm ggap +4; Bottom elevation: +0.012; Top elevation: +1.500; Phase: 1; Class: 12
Tekla Quantity - Weight: 8.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 111.3 m2; Net surface area: 0.9 m2; Height: 152 mm; Width: 64 mm; Length: 1488 mm
Pset_ColumnCommon - LoadBearing: no; Reference: Z/1126
BaseQuantities - Length: 1488 mm; OuterSurfaceArea: 0.923438 m2; NetVolume: 0.00109778 m3; NetWeight: 8.61761 kg

# IfcColumn: C:200-24, COLUMN
In: Undefined
Description: C:200-24; Material: STEEL/G450
Tekla Common - Finish: 1mm ggap +4; Bottom elevation: +0.012; Top elevation: +1.500; Phase: 1; Class: 12
Tekla Quantity - Weight: 10.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 110.2 m2; Net surface area: 1.2 m2; Height: 203 mm; Width: 76 mm; Length: 1488 mm
Pset_ColumnCommon - LoadBearing: no; Reference: Z/1129
BaseQuantities - Length: 1488 mm; OuterSurfaceArea: 1.1619 m2; NetVolume: 0.00138348 m3; NetWeight: 10.8603 kg

# IfcColumn: C:250-24, COLUMN
In: Undefined
Description: C:250-24; Material: STEEL/G450
Tekla Common - Finish: 1mm ggap +4; Bottom elevation: +0.016; Top elevation: +1.500; Phase: 1; Class: 12
Tekla Quantity - Weight: 11.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 109.8 m2; Net surface area: 1.2 m2; Height: 254 mm; Width: 76 mm; Length: 1484 mm
Pset_ColumnCommon - LoadBearing: no; Reference: Z/1131
BaseQuantities - Length: 1484 mm; OuterSurfaceArea: 1.30742 m2; NetVolume: 0.00155784 m3; NetWeight: 12.229 kg

# IfcColumn: C:300-30, COLUMN
In: Undefined
Description: C:300-30; Material: STEEL/G450
Tekla Common - Finish: 1mm ggap +4; Bottom elevation: +0.016; Top elevation: +1.500; Phase: 1; Class: 12
Tekla Quantity - Weight: 18.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.5 m2; Net surface area: 1.6 m2; Height: 300 mm; Width: 96 mm; Length: 1484 mm
Pset_ColumnCommon - LoadBearing: no; Reference: Z/1133
BaseQuantities - Length: 1484 mm; OuterSurfaceArea: 1.62378 m2; NetVolume: 0.00241743 m3; NetWeight: 18.9768 kg

# IfcColumn: C:350-30, COLUMN
In: Undefined
Description: C:350-30; Material: STEEL/G450
Tekla Common - Finish: 1mm ggap +4; Bottom elevation: +0.016; Top elevation: +1.500; Phase: 1; Class: 12
Tekla Quantity - Weight: 22.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.2 m2; Net surface area: 1.9 m2; Height: 350 mm; Width: 125 mm; Length: 1484 mm
Pset_ColumnCommon - LoadBearing: no; Reference: Z/1135
BaseQuantities - Length: 1484 mm; OuterSurfaceArea: 1.93605 m2; NetVolume: 0.00288489 m3; NetWeight: 22.6464 kg

# IfcDiscreteAccessory: BASEPLATE (5)
In: Undefined
Material: STEEL/450
Tekla Common - Bottom elevation: +0.000; Phase: 1; Class: 5
Tekla Quantity - Volume: 0 m3
Pset_PlateCommon - LoadBearing: no
Name | Description | Top elevation | Weight (kg) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) | Height (mm) | Width (mm) | Length (mm) | Reference | NetArea (m2) = GrossArea (m2) | CrossSectionArea (m2) | NetVolume (m3) = GrossVolume (m3)
BASEPLATE | PLT12*134 | +0.012 | 3.5 | 0 | 24 | 0.1 | 134 | 12 | 280 | PL/683 | 0.084976 | 0.001608 | 0.00045024
BASEPLATE | PLT12*158 | +0.012 | 4.9 | 0.1 | 23.6 | 0.1 | 158 | 12 | 331 | PL/686 | 0.116332 | 0.001896 | 0.000627576
BASEPLATE | PLT16*158 | +0.016 | 7.6 | 0.1 | 18.2 | 0.1 | 158 | 16 | 382 | PL/688 | 0.137992 | 0.002528 | 0.000965696
BASEPLATE | PLT16*198 | +0.016 | 10.6 | 0.1 | 17.8 | 0.2 | 198 | 16 | 428 | PL/690 | 0.18952 | 0.003168 | 0.0013559
BASEPLATE | PLT16*256 | +0.016 | 15.4 | 0.1 | 17.5 | 0.3 | 256 | 16 | 478 | PL/692 | 0.268224 | 0.004096 | 0.00195789

# IfcMechanicalFastener: Bolt assembly (10)
In: Undefined
Tekla Bolt - Location: Site
Name | NominalDiameter (mm) = Washer diameter (mm) | NominalLength (mm) = Bolt length (mm) | Material | Washer count = Nut count | Washer type | Washer name | Nut type | Nut name | Slotted hole y (mm) | Slotted hole x (mm) | Bolt hole diameter (mm) | Bolt count | Bolt size (mm) | Bolt standard | Bolt Name
2 x Bolt assembly | 12 | 30 | 8.8S | 6 | HARD | WASHERM12-HARD | 8.8-HEX | NUTM12-8.8-HEX | 4 | 8 | 14 | 6 | 12 | 8.8S | BOLTM12*30
2 x Bolt assembly | 16 | 12 | HIT_HY150 | 0 | WASHER-HAS | HAS-WASHER-16 | NUT-HAS | HAS-NUT-16 | 0 | 0 | 22 | 4 | 22 | HILTI_HY150-E | HAS
3 x Bolt assembly | 16 | 40 | 8.8S | 6 | HARD | WASHERM16-HARD | 8.8-HEX | NUTM16-8.8-HEX | 0 | 4 | 18 | 6 | 16 | 8.8S | BOLTM16*40
3 x Bolt assembly | 16 | 16 | HIT_HY150 | 0 | WASHER-HAS | HAS-WASHER-16 | NUT-HAS | HAS-NUT-16 | 0 | 0 | 22 | 4 | 22 | HILTI_HY150-E | HAS

# IfcPlate: FL6*150 (5)
In: Undefined
Description: FL6*150; Material: STEEL/450
Tekla Common - Phase: 1; Class: 5
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.1 m2; Height: 150 mm; Width: 6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 150 mm; CrossSectionArea: 0.000036 m2
Name | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Length (mm) | Reference | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
STIFFINER PLATE | +0.012 | +0.162 | 1.5 | 45.4 | 280 | p/503 | 0.069349 | 0.042 | 0.0001944
STIFFINER PLATE | +0.012 | +0.162 | 1.9 | 45.2 | 331 | p/501 | 0.085261 | 0.04965 | 0.0002403
STIFFINER PLATE | +0.016 | +0.166 | 2.2 | 45 | 382 | p/500 | 0.101173 | 0.0573 | 0.0002862
STIFFINER PLATE | +0.016 | +0.166 | 2.6 | 45 | 428 | p/499 | 0.115525 | 0.0642 | 0.0003276
STIFFINER PLATE | +0.016 | +0.166 | 2.9 | 44.8 | 478 | p/498 | 0.131125 | 0.0717 | 0.0003726

# IfcReinforcingBar (5)
In: Undefined
NominalDiameter: 10 mm; CrossSectionArea: 0 m2; Material: R
Tekla Reinforcement - General - Name: REBAR; Group type: 0; Spacing target: 0 mm; Spacing exact: 1*148; Phase: 1
Tekla Reinforcement - Bending List - Number of bars in group: 2; Grade: R; Size: 8; Shape: T
Name | Group position number | Length (mm) | Weight (kg) | Weight total in group (kg) | a (mm) | b (mm)
REBAR | 8 | 880 | 0.35 | 0.7 | 110 | 256
REBAR | 7 | 1010 | 0.4 | 0.7 | 122 | 307
REBAR | 4 | 1110 | 0.44 | 0.9 | 122 | 358
REBAR | 6 | 1240 | 0.49 | 0.9 | 142 | 404
REBAR | 5 | 1400 | 0.55 | 1.1 | 171 | 454
