Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView_V2.0, QuantityTakeOffAddOnView], Option [BaseQuantities:On], Option [GridExport:On], Option [Assemblies:On], Option [Bolts:On], Option [Rebars:On], Option [PourObjects:Off], Option [Welds:Off], Option [SurfaceTreatments:Off], Option [LocationBy:0], Option [ViewColors:Off], Option [SectionedSpine:Off], Option [PropertySets:On], Option [Export all:Off]
File name: Inline Girt Bracket.ifc
Time: 2026-03-27T13:38:02
Author: DESKTOP-BKNQL56\admin
Organization: Structural Designer
Written by: IFC Database Version: Work
Made in: Tekla Structures 2019 Service Pack 13, IFC Export Version: 4.0.0.0 Oct 18 2021

# IfcBuildingStorey, Undefined
In: Undefined
Elevation: 0 mm

# IfcBeam: C:100-15 (6)
In: Undefined
Description: C:100-15; Material: STEEL/450
Tekla Common - Bottom elevation: +1.500; Top elevation: +1.551; Phase: 1; Class: 99
Tekla Quantity - Weight: 0.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 179.7 m2; Net surface area: 0.1 m2; Height: 102 mm; Width: 51 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
3 x GIRT | Z/1637 | 254 | 0.115737 | 0.000085725 | 0.672941
2 x GIRT | Z/1636 | 285 | 0.12978 | 0.0000961875 | 0.755072
GIRT | Z/1641 | 290 | 0.132045 | 0.000097875 | 0.768319

# IfcBeam: C:150-15 (6)
In: Undefined
Description: C:150-15; Material: STEEL/450
Default - ASSEMBLY_POS: Z/1635
Tekla Common - Bottom elevation: +2.487; Top elevation: +2.551; Phase: 1; Class: 99
Tekla Quantity - Weight: 1.2 kg; Volume: 0 m3; Gross footprint area: 0.1 m2; Area per tons: 177 m2; Net surface area: 0.2 m2; Height: 152.1 mm; Width: 64 mm; Length: 350 mm
Pset_BeamCommon - LoadBearing: no; Reference: Z/1635
BaseQuantities - Length: 350 mm; OuterSurfaceArea: 0.215465 m2; NetVolume: 0.000160125 m3; NetWeight: 1.25698 kg

# IfcBeam: C:200-15 (4)
In: Undefined
Description: C:200-15; Material: STEEL/450
Tekla Common - Bottom elevation: +3.475; Top elevation: +3.551; Phase: 1; Class: 99
Tekla Quantity - Volume: 0 m3; Net surface area: 0.2 m2; Height: 203 mm; Width: 76 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Weight (kg) | Gross footprint area (m2) | Area per tons (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x GIRT | Z/1638 | 1.4 | 0.1 | 176 | 317.6 | 317.61 | 0.243476 | 0.000181038 | 1.42115
2 x GIRT | Z/1639 | 1.1 | 0 | 176.2 | 244 | 244 | 0.187312 | 0.00013908 | 1.09178

# IfcBeam: C:250-24 (2)
In: Undefined
Description: C:250-24; Material: STEEL/450
Tekla Common - Bottom elevation: +4.475; Top elevation: +4.551; Phase: 1; Class: 99
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0.1 m2; Height: 254 mm; Width: 76 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
BASEPLATE | Z/1640 | 2.7 | 110.4 | 0.3 | 335.6 | 335.61 | 0.297302 | 0.00035231 | 2.76563
BASEPLATE | Z/1642 | 2.1 | 110.6 | 0.2 | 262 | 262 | 0.232555 | 0.000275037 | 2.15904

# IfcColumn: C:150-24, COLUMN
In: Undefined
Description: C:150-24; Material: STEEL/G450
Default - ASSEMBLY_POS: Z/13
Tekla Common - Bottom elevation: +0.000; Top elevation: +6.051; Phase: 1; Class: 12
Tekla Quantity - Weight: 33.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 111.2 m2; Net surface area: 3.8 m2; Height: 152.1 mm; Width: 64 mm; Length: 6050.7 mm
Pset_ColumnCommon - LoadBearing: no; Reference: Z/13
BaseQuantities - Length: 6050.73 mm; OuterSurfaceArea: 3.75051 m2; NetVolume: 0.00446399 m3; NetWeight: 35.0423 kg

# IfcColumn: C:200-24, COLUMN
In: Undefined
Description: C:200-24; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Top elevation: +6.051; Phase: 1; Class: 12
Default - ASSEMBLY_POS: Z/46
Tekla Quantity - Weight: 42.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 110 m2; Net surface area: 4.7 m2; Height: 203 mm; Width: 76 mm; Length: 6050.7 mm
Pset_ColumnCommon - LoadBearing: no; Reference: Z/46
BaseQuantities - Length: 6050.73 mm; OuterSurfaceArea: 4.71901 m2; NetVolume: 0.00562573 m3; NetWeight: 44.162 kg

# IfcColumn: C:250-24, COLUMN
In: Undefined
Description: C:250-24; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Top elevation: +6.051; Phase: 1; Class: 12
Default - ASSEMBLY_POS: Z/186
Tekla Quantity - Weight: 48.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 109.7 m2; Net surface area: 5.3 m2; Height: 254 mm; Width: 76 mm; Length: 6050.7 mm
Pset_ColumnCommon - LoadBearing: no; Reference: Z/186
BaseQuantities - Length: 6050.73 mm; OuterSurfaceArea: 5.32432 m2; NetVolume: 0.00635181 m3; NetWeight: 49.8617 kg

# IfcElementAssembly (39)
In: Undefined
PredefinedType: RIGID_FRAME
Name | ASSEMBLY_POSITION_CODE = Assembly/Cast unit position code | ASSEMBLY_POS = Assembly/Cast unit Mark | Assembly/Cast unit weight (kg) | Assembly/Cast unit bottom elevation | Assembly/Cast unit top elevation | Width (mm)
INLINE GIRT BRACKET | C250AF/1 | PL/705 | 0.8 | +4.468 | +4.548 | 80.0024
INLINE GIRT BRACKET | C250AF/1 | PL/732 | 1.1 | +4.468 | +4.548 | 80.0024
INLINE GIRT BRACKET | C200AF/1 | PL/729 | 0.8 | +3.469 | +3.549 | 80.0028
INLINE GIRT BRACKET | C200AF/1 | PL/721 | 0.6 | +3.469 | +3.549 | 80.0028
INLINE GIRT BRACKET | C250AF/1 | PL/730 | 0.6 | +3.469 | +3.549 | 79.9911
INLINE GIRT BRACKET | C250AF/1 | PL/731 | 0.8 | +3.469 | +3.549 | 80.0028
INLINE GIRT BRACKET | C250AF/1 | PL/727 | 0.5 | +2.469 | +2.549 | 80.0024
INLINE GIRT BRACKET | C250AF/1 | PL/728 | 0.6 | +2.469 | +2.549 | 80.0024
INLINE GIRT BRACKET | C200AF/1 | PL/726 | 0.6 | +2.469 | +2.549 | 153.602
INLINE GIRT BRACKET | C200AF/1 | PL/725 | 0.5 | +2.469 | +2.549 | 79.9867
INLINE GIRT BRACKET | C150AF/1 | PL/704 | 0.6 | +2.469 | +2.549 | 153.591
INLINE GIRT BRACKET | C150AF/1 | PL/703 | 0.5 | +2.469 | +2.549 | 79.9867
INLINE GIRT BRACKET | C250AF/1 | PL/724 | 0.6 | +1.469 | +1.549 | 80.0021
GIRT | C250AF/1 | Z/1637 | 0.6 | +1.500 | +1.551 | 51
INLINE GIRT BRACKET | C250AF/1 | PL/698 | 0.5 | +1.469 | +1.549 | 80.0021
INLINE GIRT BRACKET | C200AF/1 | PL/697 | 0.5 | +1.469 | +1.549 | 80.0022
INLINE GIRT BRACKET | C200AF/1 | PL/696 | 0.5 | +1.469 | +1.549 | 80.0022
INLINE GIRT BRACKET | C150AF/1 | PL/694 | 0.5 | +1.469 | +1.549 | 85.0071
INLINE GIRT BRACKET | C150AF/1 | PL/695 | 0.5 | +1.469 | +1.549 | 80.0018
COLUMN | C150AF/1 | Z/13 | 33.7 | +0.000 | +6.051 | 64
BASEPLATE | C250AF/1 | Z/1640 | 2.7 | +4.475 | +4.551 | 76
COLUMN | C250AF/1 | Z/186 | 48.5 | +0.000 | +6.051 | 76
COLUMN | C200AF/1 | Z/46 | 42.9 | +0.000 | +6.051 | 76
GIRT | C200AF/1 | Z/1638 | 1.4 | +3.475 | +3.551 | 76
GIRT | C200AF/1 | Z/1639 | 1.1 | +3.475 | +3.551 | 76
GIRT | C250AF/1 | Z/1638 | 1.4 | +3.475 | +3.551 | 76
2 x GIRT | C150AF/1 | Z/1635 | 1.2 | +2.487 | +2.551 | 64
2 x GIRT | C200AF/1 | Z/1635 | 1.2 | +2.487 | +2.551 | 64
2 x GIRT | C250AF/1 | Z/1635 | 1.2 | +2.487 | +2.551 | 64
GIRT | C150AF/1 | Z/1636 | 0.6 | +1.500 | +1.551 | 51
GIRT | C150AF/1 | Z/1637 | 0.6 | +1.500 | +1.551 | 51
GIRT | C200AF/1 | Z/1636 | 0.6 | +1.500 | +1.551 | 51
GIRT | C200AF/1 | Z/1637 | 0.6 | +1.500 | +1.551 | 51
GIRT | C250AF/1 | Z/1641 | 0.6 | +1.500 | +1.551 | 51
BASEPLATE | C250AF/1 | Z/1642 | 2.1 | +4.475 | +4.551 | 76
GIRT | C250AF/1 | Z/1639 | 1.1 | +3.475 | +3.551 | 76

# IfcMechanicalFastener: Bolt assembly (27)
In: Undefined
NominalDiameter: 12 mm
Tekla Bolt - Washer count: 2; Washer diameter: 12 mm; Nut count: 2; Slotted hole y: 0 mm; Slotted hole x: 4 mm; Location: Site; Bolt count: 2; Bolt size: 12 mm
Name | NominalLength (mm) = Bolt length (mm) | Material = Bolt standard | Washer type | Washer name | Nut type | Nut name | Bolt hole diameter (mm) | Bolt Name
21 x Bolt assembly | 30 | PB1230 | FLAT | WASHERM12-FLAT | 4.6-HEX | NUTM12-4.6-HEX | 18 | BOLTPB1230
4 x Bolt assembly | 25 | 8.8S | HARD | WASHERM12-HARD | 8.8-HEX | NUTM12-8.8-HEX | 18 | BOLTM12*25
Bolt assembly | 30 | 8.8S | HARD | WASHERM12-HARD | 8.8-HEX | NUTM12-8.8-HEX | 18 | BOLTM12*30
Bolt assembly | 30 | 8.8S | HARD | WASHERM12-HARD | 8.8-HEX | NUTM12-8.8-HEX | 14 | BOLTM12*30

# IfcPlate: PLT3*120 (4)
In: Undefined
Description: PLT3*120; Material: STEEL/250
Tekla Common - Bottom elevation: +2.469; Top elevation: +2.549; Phase: 1; Class: 10
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 120 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 120.001 mm; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) | GrossVolume (m3)
INLINE GIRT BRACKET | PL/726 | 0.6 | 88.7 | 0.1 | 225.7 | 0.054886 | 0.0270809 | 0.0000788256 | 0.0000817522
INLINE GIRT BRACKET | PL/725 | 0.5 | 89.1 | 0 | 152.1 | 0.0386424 | 0.0182471 | 0.0000552507 | 0.0000552507
INLINE GIRT BRACKET | PL/704 | 0.6 | 89 | 0.1 | 225.7 | 0.0530178 | 0.0270797 | 0.0000758956 | 0.0000817486
INLINE GIRT BRACKET | PL/703 | 0.5 | 89.1 | 0 | 152.1 | 0.0386424 | 0.0182471 | 0.0000552507 | 0.0000552507

# IfcPlate: PLT3*125 (2)
In: Undefined
Description: PLT3*125; Material: STEEL/250
Tekla Common - Bottom elevation: +1.469; Top elevation: +1.549; Phase: 1; Class: 10
Tekla Quantity - Weight: 0.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0 m2; Height: 125 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 125.001 mm; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Area per tons (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) | GrossVolume (m3)
INLINE GIRT BRACKET | PL/697 | 89.3 | 225.7 | 0.0472676 | 0.0282082 | 0.0000674224 | 0.0000693878
INLINE GIRT BRACKET | PL/696 | 89.5 | 157.1 | 0.0354307 | 0.0196348 | 0.0000504058 | 0.0000508699

# IfcPlate: PLT3*130 (2)
In: Undefined
Description: PLT3*130; Material: STEEL/250
Tekla Common - Bottom elevation: +1.469; Top elevation: +1.549; Phase: 1; Class: 10
Tekla Quantity - Weight: 0.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0 m2; Height: 130 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Area per tons (m2) | Length (mm) | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) | GrossVolume (m3)
INLINE GIRT BRACKET | PL/695 | 89.5 | 213.7 | 130 | 0.0443587 | 0.0277768 | 0.0000631324 | 0.0000652305
INLINE GIRT BRACKET | PL/694 | 89.6 | 157.1 | 130.005 | 0.0353195 | 0.020421 | 0.0000502045 | 0.0000507534

# IfcPlate: PLT3*140 (2)
In: Undefined
Description: PLT3*140; Material: STEEL/250
Tekla Common - Bottom elevation: +2.469; Top elevation: +2.549; Phase: 1; Class: 10
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 140 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 140.004 mm; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) | GrossVolume (m3)
INLINE GIRT BRACKET | PL/727 | 0.5 | 89 | 0 | 152.1 | 0.041663 | 0.0212887 | 0.0000596016 | 0.0000598667
INLINE GIRT BRACKET | PL/728 | 0.6 | 88.7 | 0.1 | 225.7 | 0.0579066 | 0.0315951 | 0.0000831765 | 0.0000863682

# IfcPlate: PLT3*150 (2)
In: Undefined
Description: PLT3*150; Material: STEEL/250
Tekla Common - Bottom elevation: +1.469; Top elevation: +1.549; Phase: 1; Class: 10
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 150 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 149.999 mm; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) | GrossVolume (m3)
INLINE GIRT BRACKET | PL/724 | 0.6 | 89.1 | 0.1 | 225.7 | 0.0510431 | 0.0338499 | 0.0000728606 | 0.0000751573
INLINE GIRT BRACKET | PL/698 | 0.5 | 89.5 | 0 | 152.1 | 0.038275 | 0.0228115 | 0.0000544881 | 0.0000552884

# IfcPlate: PLT3*152.1 (3)
In: Undefined
Description: PLT3*152.1; Material: STEEL/250
Tekla Common - Phase: 1; Class: 10
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.1 m2; Height: 152.1 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Length (mm) | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
INLINE GIRT BRACKET | PL/705 | +4.468 | +4.548 | 0.8 | 88.1 | 220 | 152.064 | 0.0700785 | 0.0334542 | 0.000101295
INLINE GIRT BRACKET | PL/721 | +3.469 | +3.549 | 0.6 | 88.5 | 170 | 152.06 | 0.0543614 | 0.0258512 | 0.0000782743
INLINE GIRT BRACKET | PL/730 | +3.469 | +3.549 | 0.6 | 88.5 | 170 | 152.062 | 0.054362 | 0.0258516 | 0.0000782752

# IfcPlate: PLT3*170 (2)
In: Undefined
Description: PLT3*170; Material: STEEL/250
Tekla Common - Bottom elevation: +3.469; Top elevation: +3.549; Phase: 1; Class: 10
Tekla Quantity - Weight: 0.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.1 m2; Height: 170 mm; Width: 3 mm; Length: 225.7 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 170.006 mm; CrossSectionArea: 0.000009 m2; GrossVolume: 0.000115814 m3
Name | ASSEMBLY_POS = Reference | Area per tons (m2) | NetArea (m2) | GrossArea (m2) | NetVolume (m3)
INLINE GIRT BRACKET | PL/729 | 88.1 | 0.0760955 | 0.0383648 | 0.000109957
INLINE GIRT BRACKET | PL/731 | 88 | 0.0779639 | 0.0383649 | 0.000112888

# IfcPlate: PLT3*220, INLINE GIRT BRACKET
In: Undefined
Description: PLT3*220; Material: STEEL/250
Tekla Common - Bottom elevation: +4.468; Top elevation: +4.548; Phase: 1; Class: 10
Default - ASSEMBLY_POS: PL/732
Tekla Quantity - Weight: 1.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.7 m2; Net surface area: 0.1 m2; Height: 220 mm; Width: 3 mm; Length: 225.7 mm
Pset_PlateCommon - LoadBearing: no; Reference: PL/732
BaseQuantities - Width: 220.001 mm; NetArea: 0.0991745 m2; GrossArea: 0.0496471 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000144021 m3; GrossVolume: 0.000149874 m3
