Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView_V2.0, QuantityTakeOffAddOnView], Option [BaseQuantities:On], Option [GridExport:On], Option [Assemblies:On], Option [Bolts:On], Option [Rebars:On], Option [PourObjects:Off], Option [Welds:Off], Option [SurfaceTreatments:On], Option [LocationBy:0], Option [ViewColors:Off], Option [SectionedSpine:Off], Option [PropertySets:On], Option [Export all:Off]
File name: S.ifc
Time: 2026-03-05T21:06:38
Author: DESKTOP-BQ0Q680\danie
Organization: Structural Designer
Written by: IFC Database Version: Work
Made in: Tekla Structures 2019 Service Pack 13, IFC Export Version: 4.0.0.0 Oct 18 2021

# IfcBuildingStorey, Undefined
In: Undefined
Elevation: 0 mm

# IfcColumn: SHS100*100*5.0 (4)
In: Undefined
Description: SHS100*100*5.0; Material: STEEL/300PLUS
Pset_ColumnCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x COLUMN | C/0(?) | 438 | 0.166002 | 0.0008322 | 6.53277
2 x COLUMN | C/1(?) | 888 | 0.336552 | 0.0016872 | 13.2445

# IfcColumn: SHS125*125*5.0 (4)
In: Undefined
Description: SHS125*125*5.0; Material: STEEL/300PLUS
Pset_ColumnCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x COLUMN | C/0(?) | 438 | 0.209802 | 0.0010512 | 8.25192
2 x COLUMN | C/1(?) | 888 | 0.425352 | 0.0021312 | 16.7299

# IfcColumn: SHS50*50*5.0 (4)
In: Undefined
Description: SHS50*50*5.0; Material: STEEL/300PLUS
Pset_ColumnCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x COLUMN | C/0(?) | 438 | 0.078402 | 0.0003942 | 3.09447
2 x COLUMN | C/1(?) | 888 | 0.158952 | 0.0007992 | 6.27372

# IfcColumn: SHS75*75*5.0 (4)
In: Undefined
Description: SHS75*75*5.0; Material: STEEL/300PLUS
Pset_ColumnCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x COLUMN | C/0(?) | 438 | 0.122202 | 0.0006132 | 4.81362
2 x COLUMN | C/1(?) | 888 | 0.247752 | 0.0012432 | 9.75912

# IfcDiscreteAccessory: BASEPLATE (24)
In: Undefined
Material: STEEL/450
Name | Description | NetArea (m2) = GrossArea (m2) | CrossSectionArea (m2) | NetVolume (m3) = GrossVolume (m3)
4 x BASEPLATE | PLT12*245 | 0.13181 | 0.00294 | 0.0007203
4 x BASEPLATE | PLT12*220 | 0.10736 | 0.00264 | 0.0005808
4 x BASEPLATE | PLT12*195 | 0.08541 | 0.00234 | 0.0004563
4 x BASEPLATE | PLT12*170 | 0.06596 | 0.00204 | 0.0003468
2 x BASEPLATE | PLT6*185 | 0.07289 | 0.00111 | 0.00020535
2 x BASEPLATE | PLT6*160 | 0.05504 | 0.00096 | 0.0001536
2 x BASEPLATE | PLT6*135 | 0.03969 | 0.00081 | 0.00010935
2 x BASEPLATE | FL6*110 | 0.02684 | 0.00066 | 0.0000726

# IfcElementAssembly (24)
In: Undefined
PredefinedType: RIGID_FRAME
Name | ASSEMBLY_POSITION_CODE | ASSEMBLY_POS | Width (mm)
COLUMN | SHS125*125*5.0/TYPE2 | C/1(?) | 245
COLUMN | SHS125*125*5.0/TYPE2 | C/0(?) | 245
COLUMN | SHS100*100*5.0/TYPE2 | C/1(?) | 220
COLUMN | SHS100*100*5.0/TYPE2 | C/0(?) | 220
COLUMN | SHS75*75*5.0/TYPE2 | C/1(?) | 195
COLUMN | SHS75*75*5.0/TYPE2 | C/0(?) | 195
COLUMN | SHS50*50*5.0/TYPE2 | C/1(?) | 170
COLUMN | SHS50*50*5.0/TYPE2 | C/0(?) | 170
BASEPLATE | SHS125*125*5.0/TYPE2 | A/7(?) | 6
BASEPLATE | SHS100*100*5.0/TYPE2 | A/7(?) | 6
BASEPLATE | SHS75*75*5.0/TYPE2 | A/7(?) | 6
BASEPLATE | SHS50*50*5.0/TYPE2 | A/7(?) | 6
COLUMN | SHS125*125*5.0/TYPE1 | C/1(?) | 245
COLUMN | SHS125*125*5.0/TYPE1 | C/0(?) | 245
COLUMN | SHS100*100*5.0/TYPE1 | C/1(?) | 220
COLUMN | SHS100*100*5.0/TYPE1 | C/0(?) | 220
COLUMN | SHS75*75*5.0/TYPE1 | C/1(?) | 195
COLUMN | SHS75*75*5.0/TYPE1 | C/0(?) | 195
COLUMN | SHS50*50*5.0/TYPE1 | C/1(?) | 170
COLUMN | SHS50*50*5.0/TYPE1 | C/0(?) | 170
BASEPLATE | SHS125*125*5.0/TYPE1 | A/7(?) | 6
BASEPLATE | SHS100*100*5.0/TYPE1 | A/7(?) | 6
BASEPLATE | SHS75*75*5.0/TYPE1 | A/7(?) | 6
BASEPLATE | SHS50*50*5.0/TYPE1 | A/7(?) | 6

# IfcMechanicalFastener: Bolt assembly (8)
In: Undefined
NominalDiameter: 16 mm; NominalLength: 50 mm; Material: 8.8S
