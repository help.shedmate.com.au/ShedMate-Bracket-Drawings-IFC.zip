Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView_V2.0, QuantityTakeOffAddOnView], Option [BaseQuantities:On], Option [GridExport:On], Option [Assemblies:On], Option [Bolts:On], Option [Rebars:On], Option [PourObjects:Off], Option [Welds:Off], Option [SurfaceTreatments:Off], Option [LocationBy:0], Option [ViewColors:Off], Option [SectionedSpine:Off], Option [PropertySets:On], Option [Export all:Off]
File name: Double C-Section Filler plate.ifc
Time: 2026-02-26T11:17:23
Author: DESKTOP-BKNQL56\admin
Organization: Structural Designer
Written by: IFC Database Version: Work
Made in: Tekla Structures 2019 Service Pack 13, IFC Export Version: 4.0.0.0 Oct 18 2021

# IfcBuildingStorey, Undefined
In: Undefined
Elevation: 0 mm

# IfcBeam: C:150-24, COLUMN
In: Undefined
Description: C:150-24; Material: STEEL/G450
Default - ASSEMBLY_POS: Z/1124
Tekla Common - Finish: 1mm ggap +4; Bottom elevation: +0.000; Top elevation: +1.500; Phase: 1; Class: 1
Tekla Quantity - Weight: 8.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 111.3 m2; Net surface area: 0.9 m2; Height: 152 mm; Width: 64 mm; Length: 1500 mm
Pset_BeamCommon - LoadBearing: no; Reference: Z/1124
BaseQuantities - Length: 1500 mm; OuterSurfaceArea: 0.930874 m2; NetVolume: 0.00110664 m3; NetWeight: 8.68711 kg

# IfcBeam: C:200-24, COLUMN
In: Undefined
Description: C:200-24; Material: STEEL/G450
Default - ASSEMBLY_POS: Z/58
Tekla Common - Finish: 1mm ggap +4; Bottom elevation: +0.016; Top elevation: +1.500; Phase: 1; Class: 1
Tekla Quantity - Weight: 10.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 110.2 m2; Net surface area: 1.2 m2; Height: 203 mm; Width: 76 mm; Length: 1484 mm
Pset_BeamCommon - LoadBearing: no; Reference: Z/58
BaseQuantities - Length: 1484 mm; OuterSurfaceArea: 1.15878 m2; NetVolume: 0.00137976 m3; NetWeight: 10.8311 kg

# IfcBeam: C:250-24, COLUMN
In: Undefined
Description: C:250-24; Material: STEEL/G450
Tekla Common - Finish: 1mm ggap +4; Bottom elevation: +0.016; Top elevation: +1.500; Phase: 1; Class: 1
Default - ASSEMBLY_POS: Z/947
Tekla Quantity - Weight: 11.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 109.8 m2; Net surface area: 1.2 m2; Height: 254 mm; Width: 76 mm; Length: 1484 mm
Pset_BeamCommon - LoadBearing: no; Reference: Z/947
BaseQuantities - Length: 1484 mm; OuterSurfaceArea: 1.30742 m2; NetVolume: 0.00155784 m3; NetWeight: 12.229 kg

# IfcBeam: C:300-30, COLUMN
In: Undefined
Description: C:300-30; Material: STEEL/G450
Tekla Common - Finish: 1mm ggap +4; Bottom elevation: +0.016; Top elevation: +1.500; Phase: 1; Class: 1
Default - ASSEMBLY_POS: Z/950
Tekla Quantity - Weight: 18.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.5 m2; Net surface area: 1.6 m2; Height: 300 mm; Width: 96 mm; Length: 1484 mm
Pset_BeamCommon - LoadBearing: no; Reference: Z/950
BaseQuantities - Length: 1484 mm; OuterSurfaceArea: 1.62378 m2; NetVolume: 0.00241743 m3; NetWeight: 18.9768 kg

# IfcBeam: C:350-30, COLUMN
In: Undefined
Description: C:350-30; Material: STEEL/G450
Tekla Common - Finish: 1mm ggap +4; Bottom elevation: +0.016; Top elevation: +1.500; Phase: 1; Class: 1
Default - ASSEMBLY_POS: Z/955
Tekla Quantity - Weight: 22.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.2 m2; Net surface area: 1.9 m2; Height: 350 mm; Width: 125 mm; Length: 1484 mm
Pset_BeamCommon - LoadBearing: no; Reference: Z/955
BaseQuantities - Length: 1484 mm; OuterSurfaceArea: 1.93605 m2; NetVolume: 0.00288489 m3; NetWeight: 22.6464 kg

# IfcColumn: C:150-24, COLUMN
In: Undefined
Description: C:150-24; Material: STEEL/G450
Tekla Common - Finish: 1mm ggap +4; Bottom elevation: +0.000; Top elevation: +1.500; Phase: 1; Class: 1
Tekla Quantity - Weight: 8.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 111.3 m2; Net surface area: 0.9 m2; Height: 152 mm; Width: 64 mm; Length: 1500 mm
BaseQuantities - Length: 1500 mm; OuterSurfaceArea: 0.930874 m2; NetVolume: 0.00110664 m3; NetWeight: 8.68711 kg
Default - ASSEMBLY_POS: Z/1127
Pset_ColumnCommon - LoadBearing: no; Reference: Z/1127

# IfcColumn: C:200-24, COLUMN
In: Undefined
Description: C:200-24; Material: STEEL/G450
Tekla Common - Finish: 1mm ggap +4; Bottom elevation: +0.016; Top elevation: +1.500; Phase: 1; Class: 1
Tekla Quantity - Weight: 10.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 110.2 m2; Net surface area: 1.2 m2; Height: 203 mm; Width: 76 mm; Length: 1484 mm
Default - ASSEMBLY_POS: Z/45
Pset_ColumnCommon - LoadBearing: no; Reference: Z/45
BaseQuantities - Length: 1484 mm; OuterSurfaceArea: 1.15878 m2; NetVolume: 0.00137976 m3; NetWeight: 10.8311 kg

# IfcColumn: C:250-24, COLUMN
In: Undefined
Description: C:250-24; Material: STEEL/G450
Tekla Common - Finish: 1mm ggap +4; Bottom elevation: +0.016; Top elevation: +1.500; Phase: 1; Class: 1
Tekla Quantity - Weight: 11.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 109.8 m2; Net surface area: 1.2 m2; Height: 254 mm; Width: 76 mm; Length: 1484 mm
Default - ASSEMBLY_POS: Z/50
Pset_ColumnCommon - LoadBearing: no; Reference: Z/50
BaseQuantities - Length: 1484 mm; OuterSurfaceArea: 1.30742 m2; NetVolume: 0.00155784 m3; NetWeight: 12.229 kg

# IfcColumn: C:300-30, COLUMN
In: Undefined
Description: C:300-30; Material: STEEL/G450
Tekla Common - Finish: 1mm ggap +4; Bottom elevation: +0.016; Top elevation: +1.500; Phase: 1; Class: 1
Tekla Quantity - Weight: 18.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.5 m2; Net surface area: 1.6 m2; Height: 300 mm; Width: 96 mm; Length: 1484 mm
Default - ASSEMBLY_POS: Z/185
Pset_ColumnCommon - LoadBearing: no; Reference: Z/185
BaseQuantities - Length: 1484 mm; OuterSurfaceArea: 1.62378 m2; NetVolume: 0.00241743 m3; NetWeight: 18.9768 kg

# IfcColumn: C:350-30, COLUMN
In: Undefined
Description: C:350-30; Material: STEEL/G450
Tekla Common - Finish: 1mm ggap +4; Bottom elevation: +0.016; Top elevation: +1.500; Phase: 1; Class: 1
Tekla Quantity - Weight: 22.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.2 m2; Net surface area: 1.9 m2; Height: 350 mm; Width: 125 mm; Length: 1484 mm
Default - ASSEMBLY_POS: Z/200
Pset_ColumnCommon - LoadBearing: no; Reference: Z/200
BaseQuantities - Length: 1484 mm; OuterSurfaceArea: 1.93605 m2; NetVolume: 0.00288489 m3; NetWeight: 22.6464 kg

# IfcDiscreteAccessory: FILLER PLATE (5)
In: Undefined
Description: FL6*75; Material: STEEL/450
Tekla Common - Bottom elevation: +0.862; Top elevation: +0.937; Phase: 1; Class: 11
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 75 mm; Width: 6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.00045 m2
Name | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Length (mm) | Reference | NetArea (m2) = GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
FILLER PLATE | 0.5 | 47.5 | 0 | 152 | PL/684 | 0.025524 | 0.0000684
FILLER PLATE | 1.2 | 46.6 | 0.1 | 350 | PL/307 | 0.0576 | 0.0001575
FILLER PLATE | 1.1 | 46.7 | 0 | 300 | PL/306 | 0.0495 | 0.000135
FILLER PLATE | 0.7 | 47.1 | 0 | 203 | PL/304 | 0.033786 | 0.00009135
FILLER PLATE | 0.9 | 46.9 | 0 | 254 | PL/305 | 0.042048 | 0.0001143

# IfcElementAssembly (15)
In: Undefined
PredefinedType: RIGID_FRAME
Name | ASSEMBLY_POSITION_CODE = Assembly/Cast unit position code | ASSEMBLY_POS = Assembly/Cast unit Mark | Assembly/Cast unit weight (kg) | Assembly/Cast unit bottom elevation | Assembly/Cast unit top elevation | Width (mm)
FILLER PLATE | C150SD/5 | PL/684 | 0.5 | +0.862 | +0.937 | 6
COLUMN | C150SD/5 | Z/1124 | 8.4 | +0.000 | +1.500 | 64
COLUMN | C150SD/5 | Z/1127 | 8.4 | +0.000 | +1.500 | 64
FILLER PLATE | C350SD/5 | PL/307 | 1.2 | +0.862 | +0.937 | 6
FILLER PLATE | C300SD/5 | PL/306 | 1.1 | +0.862 | +0.937 | 6
FILLER PLATE | C200SD/5 | PL/304 | 0.7 | +0.862 | +0.937 | 6
FILLER PLATE | C250SD/5 | PL/305 | 0.9 | +0.862 | +0.937 | 6
COLUMN | C200SD/5 | Z/58 | 10.5 | +0.016 | +1.500 | 76
COLUMN | C200SD/5 | Z/45 | 10.5 | +0.016 | +1.500 | 76
COLUMN | C250SD/5 | Z/947 | 11.9 | +0.016 | +1.500 | 76
COLUMN | C250SD/5 | Z/50 | 11.9 | +0.016 | +1.500 | 76
COLUMN | C300SD/5 | Z/950 | 18.6 | +0.016 | +1.500 | 96
COLUMN | C300SD/5 | Z/185 | 18.6 | +0.016 | +1.500 | 96
COLUMN | C350SD/5 | Z/955 | 22.2 | +0.016 | +1.500 | 125
COLUMN | C350SD/5 | Z/200 | 22.2 | +0.016 | +1.500 | 125

# IfcMechanicalFastener: Bolt assembly (21)
In: Undefined
NominalDiameter: 12 mm; NominalLength: 30 mm; Material: PB1230
Tekla Bolt - Washer diameter: 12 mm; Washer type: FLAT; Washer name: WASHERM12-FLAT; Nut type: 4.6-HEX; Nut name: NUTM12-4.6-HEX; Bolt hole diameter: 14 mm; Location: Site; Bolt size: 12 mm; Bolt length: 30 mm; Bolt standard: PB1230; Bolt Name: BOLTPB1230
Name | Washer count = Nut count = Bolt count | Slotted hole y (mm) | Slotted hole x (mm)
5 x Bolt assembly | 2 | 4 | 8
16 x Bolt assembly | 3 | 0 | 6
