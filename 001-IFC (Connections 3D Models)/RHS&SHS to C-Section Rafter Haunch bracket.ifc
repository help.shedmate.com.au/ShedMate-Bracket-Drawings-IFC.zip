Properties of the parts of a building model (IFC2X3), part 2 of 5

# IfcElementAssembly (1642)
Name | ASSEMBLY_POSITION_CODE = Assembly/Cast unit position code | ASSEMBLY_POS = Assembly/Cast unit Mark | Assembly/Cast unit weight (kg) | Assembly/Cast unit bottom elevation | Assembly/Cast unit top elevation | Width (mm)
PLATE | C250SD-C300SD/RHS200*100-RHS250*150 | PL/1840 | 4.7 | +4.332 | +4.700 | 79
PLATE | C250SD-C300SD/RHS200*100 | PL/1839 | 4.9 | +4.681 | +5.103 | 79
4 x COLUMN |  | Z/2185 | 155.6 | +0.000 | +5.203 | 150
2 x RAFTER |  | Z/2176 | 9.4 | +4.234 | +4.688 | 125
RAFTER | C350SD>/RHS250*150> | Z/1818 | 9 | +4.721 | +5.170 | 125
2 x COLUMN | C350SD>/RHS250*150 | Z/1823 | 154.1 | +0.000 | +5.153 | 150
PLATE |  | PL/1864 | 8.7 | +4.202 | +4.700 | 128
PLATE | C350SD>/RHS250*150> | PL/1863 | 9 | +4.567 | +5.138 | 128
4 x COLUMN |  | Z/2131 | 154.4 | +0.000 | +5.163 | 150
2 x RAFTER |  | Z/2110 | 8.6 | +4.274 | +4.689 | 96
RAFTER | C300SD-C350SD/RHS250*150> | Z/1804 | 8 | +4.765 | +5.171 | 96
2 x COLUMN | C300SD-C350SD/RHS250*150 | Z/1809 | 152.9 | +0.000 | +5.113 | 150
PLATE |  | PL/1852 | 8 | +4.218 | +4.700 | 99
PLATE | C300SD-C350SD/RHS250*150> | PL/1851 | 8.3 | +4.576 | +5.133 | 99
2 x COLUMN | C350SD/RHS200*100-RHS250*150 | Z/2184 | 113.9 | +0.000 | +5.163 | 100
2 x COLUMN | C350SD/RHS150*100-RHS200*100 | Z/2183 | 93.6 | +0.000 | +5.163 | 100
2 x COLUMN | C350SD/SHS125*125-RHS100*50 | Z/2182 | 93.6 | +0.000 | +5.163 | 125
2 x COLUMN | C350SD/SHS100*100-SHS125*125 | Z/2181 | 73.4 | +0.000 | +5.163 | 100
2 x COLUMN | C300SD/RHS200*100-RHS250*150 | Z/2130 | 113.9 | +0.000 | +5.163 | 100
2 x COLUMN | C300SD/RHS150*100-RHS200*100 | Z/2129 | 93.6 | +0.000 | +5.163 | 100
2 x COLUMN | C300SD/SHS125*125-RHS100*50 | Z/2128 | 93.6 | +0.000 | +5.163 | 125
2 x COLUMN | C300SD/SHS100*100-SHS125*125 | Z/2127 | 73.4 | +0.000 | +5.163 | 100
2 x COLUMN | C250SD/RHS200*100-RHS250*150 | Z/2072 | 113.9 | +0.000 | +5.163 | 100
2 x COLUMN | C250SD/RHS150*100-RHS200*100 | Z/2071 | 93.6 | +0.000 | +5.163 | 100
2 x COLUMN | C250SD/SHS125*125-RHS100*50 | Z/2070 | 93.6 | +0.000 | +5.163 | 125
2 x COLUMN | C250SD/SHS100*100-SHS125*125 | Z/2069 | 73.4 | +0.000 | +5.163 | 100
2 x COLUMN | C200SD/RHS150*50-RHS150*100 | Z/2025 | 72.6 | +0.000 | +5.113 | 50
2 x COLUMN | C200SD/SHS75*75-SHS100*100 | Z/2024 | 52.6 | +0.000 | +5.113 | 75
2 x COLUMN | C150SD/RHS150*50-RHS150*100 | Z/1788 | 73.4 | +0.000 | +5.163 | 50
2 x COLUMN | C150SD/RHS100*50-RHS150*50 | Z/1787 | 53.1 | +0.000 | +5.163 | 50
2 x COLUMN | C150SD/SHS75*75-SHS100*100 | Z/1783 | 52.6 | +0.000 | +5.113 | 75
2 x COLUMN | C150SD/SHS50*50-SHS75*75 | Z/1782 | 32.7 | +0.000 | +5.113 | 50
RAFTER | C350SD/RHS200*100-RHS250*150 | Z/2176 | 9.4 | +4.234 | +4.688 | 125
RAFTER | C300SD/RHS200*100-RHS250*150 | Z/2110 | 8.6 | +4.274 | +4.689 | 96
RAFTER | C250SD/RHS200*100-RHS250*150 | Z/2055 | 6 | +4.311 | +4.691 | 76
RAFTER | C350SD/RHS150*100-RHS200*100 | Z/2176 | 9.4 | +4.234 | +4.688 | 125
RAFTER | C300SD/RHS150*100-RHS200*100 | Z/2110 | 8.6 | +4.274 | +4.689 | 96
RAFTER | C250SD/RHS150*100-RHS200*100 | Z/2055 | 6 | +4.311 | +4.691 | 76
RAFTER | C350SD/SHS125*125-RHS100*50 | Z/2176 | 9.4 | +4.234 | +4.688 | 125
RAFTER | C300SD/SHS125*125-RHS100*50 | Z/2110 | 8.6 | +4.274 | +4.689 | 96
RAFTER | C250SD/SHS125*125-RHS100*50 | Z/2055 | 6 | +4.311 | +4.691 | 76
RAFTER | C350SD/SHS100*100-SHS125*125 | Z/2176 | 9.4 | +4.234 | +4.688 | 125
RAFTER | C300SD/SHS100*100-SHS125*125 | Z/2110 | 8.6 | +4.274 | +4.689 | 96
RAFTER | C250SD/SHS100*100-SHS125*125 | Z/2055 | 6 | +4.311 | +4.691 | 76
RAFTER | C200SD/RHS150*50-RHS150*100 | Z/2040 | 5.7 | +4.352 | +4.692 | 76
RAFTER | C200SD/SHS75*75-SHS100*100 | Z/2040 | 5.7 | +4.352 | +4.692 | 76
RAFTER | C150SD/RHS150*50-RHS150*100 | Z/1775 | 4.9 | +4.393 | +4.694 | 64
RAFTER | C150SD/RHS100*50-RHS150*50 | Z/1775 | 4.9 | +4.393 | +4.694 | 64
RAFTER | C150SD/SHS75*75-SHS100*100 | Z/1775 | 4.9 | +4.393 | +4.694 | 64
RAFTER | C150SD/SHS50*50-SHS75*75 | Z/1775 | 4.9 | +4.393 | +4.694 | 64
RAFTER | C150SD/SHS75*75-SHS100*100 | Z/1514 | 3.6 | +4.876 | +5.138 | 64
2 x COLUMN | C150SD/SHS75*75 | Z/1779 | 52.1 | +0.000 | +5.063 | 75
RAFTER | C350SD/RHS250*150> | Z/1818 | 9 | +4.721 | +5.170 | 125
RAFTER | C300SD/RHS250*150> | Z/1804 | 8 | +4.765 | +5.171 | 96
2 x COLUMN | C350SD/RHS250*150 | Z/1823 | 154.1 | +0.000 | +5.153 | 150
2 x COLUMN | C300SD/RHS250*150 | Z/1809 | 152.9 | +0.000 | +5.113 | 150
RAFTER | C350SD/RHS200*100-RHS250*150 | Z/1818 | 9 | +4.716 | +5.165 | 125
RAFTER | C300SD/RHS200*100-RHS250*150 | Z/1804 | 8 | +4.759 | +5.165 | 96
RAFTER | C250SD/RHS200*100-RHS250*150 | Z/1791 | 5.4 | +4.799 | +5.166 | 76
2 x COLUMN | C350SD/RHS200*100 | Z/1822 | 112.8 | +0.000 | +5.113 | 100
2 x COLUMN | C300SD/RHS200*100 | Z/1808 | 112.8 | +0.000 | +5.113 | 100
2 x COLUMN | C250SD/RHS200*100 | Z/1795 | 111.7 | +0.000 | +5.063 | 100
RAFTER | C350SD/RHS150*100-RHS200*100 | Z/1818 | 9 | +4.710 | +5.159 | 125
RAFTER | C300SD/RHS150*100-RHS200*100 | Z/1804 | 8 | +4.754 | +5.160 | 96
RAFTER | C250SD/RHS150*100-RHS200*100 | Z/1791 | 5.4 | +4.794 | +5.160 | 76
2 x COLUMN | C350SD/RHS150*100 | Z/1821 | 92.7 | +0.000 | +5.113 | 100
2 x COLUMN | C300SD/RHS150*100 | Z/1807 | 92.7 | +0.000 | +5.113 | 100
2 x COLUMN | C250SD/RHS150*100 | Z/1794 | 91.8 | +0.000 | +5.063 | 100
RAFTER | C200SD/RHS150*50-RHS150*100 | Z/1786 | 4.9 | +4.839 | +5.162 | 76
RAFTER | C150SD/RHS150*50-RHS150*100 | Z/1514 | 3.6 | +4.884 | +5.145 | 64
2 x COLUMN | C200SD/RHS150*50 | Z/1785 | 71.9 | +0.000 | +5.063 | 50
2 x COLUMN | C150SD/RHS150*50 | Z/1781 | 71.9 | +0.000 | +5.063 | 50
RAFTER | C150SD/RHS100*50-RHS150*50 | Z/1514 | 3.6 | +4.879 | +5.140 | 64
2 x COLUMN | C150SD/RHS100*50 | Z/1780 | 52.1 | +0.000 | +5.063 | 50
RAFTER | C350SD/SHS125*125-RHS100*50 | Z/1818 | 9 | +4.708 | +5.157 | 125
RAFTER | C300SD/SHS125*125-RHS100*50 | Z/1804 | 8 | +4.751 | +5.157 | 96
RAFTER | C250SD/SHS125*125-RHS100*50 | Z/1791 | 5.4 | +4.792 | +5.158 | 76
2 x COLUMN | C350SD/SHS125*125 | Z/1820 | 92.7 | +0.000 | +5.113 | 125
2 x COLUMN | C300SD/SHS125*125 | Z/1806 | 91.8 | +0.000 | +5.063 | 125
2 x COLUMN | C250SD/SHS125*125 | Z/1793 | 91.8 | +0.000 | +5.063 | 125
RAFTER | C350SD/SHS100*100-SHS125*125 | Z/1818 | 9 | +4.705 | +5.154 | 125
RAFTER | C300SD/SHS100*100-SHS125*125 | Z/1804 | 8 | +4.749 | +5.155 | 96
RAFTER | C250SD/SHS100*100-SHS125*125 | Z/1791 | 5.4 | +4.789 | +5.155 | 76
2 x COLUMN | C350SD/SHS100*100 | Z/1819 | 72.6 | +0.000 | +5.113 | 100
2 x COLUMN | C300SD/SHS100*100 | Z/1805 | 71.9 | +0.000 | +5.063 | 100
2 x COLUMN | C250SD/SHS100*100 | Z/1792 | 71.9 | +0.000 | +5.063 | 100
RAFTER | C200SD/SHS75*75-SHS100*100 | Z/1786 | 4.9 | +4.831 | +5.154 | 76
2 x COLUMN | C200SD/SHS75*75 | Z/1784 | 52.1 | +0.000 | +5.063 | 75
RAFTER | C150SD/SHS50*50-SHS75*75 | Z/1514 | 3.6 | +4.873 | +5.135 | 64
2 x COLUMN | C150SD/SHS50*50 | Z/1513 | 32.4 | +0.000 | +5.063 | 50
PLATE |  | PL/1854 | 8.7 | +4.202 | +4.700 | 128
PLATE |  | PL/1842 | 8 | +4.218 | +4.700 | 99
TH |  | B/5 | 1.8 | +4.570 | +4.658 | 125
TH |  | B/5 | 1.8 | +4.566 | +4.654 | 125
PLATE | C350SD/RHS200*100-RHS250*150 | PL/1858 | 8 | +4.202 | +4.700 | 128
PLATE | C300SD/RHS200*100-RHS250*150 | PL/1846 | 7.4 | +4.218 | +4.700 | 99
PLATE | C250SD/RHS200*100-RHS250*150 | PL/1836 | 4.7 | +4.332 | +4.700 | 79
TH | C350SD>/RHS200*100-RHS250*150 | B/5 | 1.8 | +4.570 | +4.658 | 125
TH | C300SD-C350SD/RHS200*100-RHS250*150 | B/5 | 1.8 | +4.566 | +4.654 | 125
TH | C250SD-C300SD/RHS200*100-RHS250*150 | B/5 | 1.8 | +4.561 | +4.649 | 125
PLATE | C350SD/RHS150*100-RHS200*100 | PL/1856 | 7.4 | +4.202 | +4.700 | 128
PLATE | C300SD/RHS150*100-RHS200*100 | PL/1844 | 6.8 | +4.218 | +4.700 | 99
PLATE | C250SD/RHS150*100-RHS200*100 | PL/1834 | 4.3 | +4.332 | +4.700 | 79
TH | C350SD>/RHS150*100-RHS200*100 | B/5 | 1.8 | +4.570 | +4.658 | 125
TH | C300SD-C350SD/RHS150*100-RHS200*100 | B/5 | 1.8 | +4.566 | +4.654 | 125
TH | C250SD-C300SD/RHS150*100-RHS200*100 | B/5 | 1.8 | +4.561 | +4.649 | 125
PLATE | C350SD/SHS125*125-RHS100*50 | PL/1710 | 7.2 | +4.202 | +4.700 | 128
PLATE | C300SD/SHS125*125-RHS100*50 | PL/1706 | 6.5 | +4.218 | +4.700 | 99
PLATE | C250SD/SHS125*125-RHS100*50 | PL/1698 | 4.1 | +4.332 | +4.700 | 79
TH | C350SD>/SHS125*125-RHS100*50 | B/5 | 1.8 | +4.570 | +4.658 | 125
TH | C300SD-C350SD/SHS125*125-RHS100*50 | B/5 | 1.8 | +4.566 | +4.654 | 125
TH | C250SD-C300SD/SHS125*125-RHS100*50 | B/5 | 1.8 | +4.561 | +4.649 | 125
PLATE | C350SD/SHS100*100-SHS125*125 | PL/1968 | 7 | +4.197 | +4.700 | 128
PLATE | C300SD/SHS100*100-SHS125*125 | PL/1964 | 6.2 | +4.223 | +4.700 | 99
PLATE | C250SD/SHS100*100-SHS125*125 | PL/1960 | 3.9 | +4.322 | +4.700 | 79
TH | C350SD>/SHS100*100-SHS125*125 | B/5 | 1.8 | +4.570 | +4.658 | 125
TH | C300SD-C350SD/SHS100*100-SHS125*125 | B/5 | 1.8 | +4.566 | +4.654 | 125
TH | C250SD-C300SD/SHS100*100-SHS125*125 | B/5 | 1.8 | +4.561 | +4.649 | 125
PLATE | C200SD/RHS150*50-RHS150*100 | PL/1830 | 2.7 | +4.432 | +4.700 | 79
TH | C200SD-C250SD/RHS150*50-RHS150*100 | B/5 | 1.8 | +4.549 | +4.636 | 125
PLATE | C200SD/SHS75*75-SHS100*100 | PL/1956 | 2.2 | +4.427 | +4.700 | 79
TH | C200SD-C250SD/SHS75*75-SHS100*100 | B/5 | 1.8 | +4.549 | +4.636 | 125
PLATE | C150SD/RHS150*50-RHS150*100 | PL/1824 | 2.4 | +4.442 | +4.700 | 67
TH | C150SD-C200SD/RHS150*50-RHS150*100 | B/5 | 1.8 | +4.553 | +4.640 | 125
PLATE | C150SD/RHS100*50-RHS150*50 | PL/1822 | 2.1 | +4.442 | +4.700 | 67
TH | C150SD-C200SD/RHS100*50-RHS150*50 | B/5 | 1.8 | +4.553 | +4.640 | 125
PLATE | C150SD/SHS75*75-SHS100*100 | PL/1971 | 1.9 | +4.442 | +4.700 | 67
TH | C150SD-C200SD/SHS75*75-SHS100*100 | B/5 | 1.8 | +4.553 | +4.640 | 125
PLATE | C150SD/SHS50*50-SHS75*75 | PL/1951 | 1.8 | +4.442 | +4.700 | 67
TH | C150SD-C200SD/SHS50*50-SHS75*75 | B/5 | 1.8 | +4.553 | +4.640 | 125
PLATE | C150SD/SHS75*75 | PL/1949 | 2.1 | +4.767 | +5.064 | 265.836
TH | C350SD>/RHS250*150> | B/5 | 1.8 | +5.146 | +5.234 | 125
TH | C300SD-C350SD/RHS250*150> | B/5 | 1.8 | +5.145 | +5.233 | 125
PLATE | C350SD/RHS250*150> | PL/1853 | 9 | +4.567 | +5.138 | 128
PLATE | C300SD/RHS250*150> | PL/1841 | 8.3 | +4.576 | +5.133 | 99
TH | C350SD>/RHS200*100-RHS250*150 | B/5 | 1.8 | +5.141 | +5.229 | 125
TH | C300SD-C350SD/RHS200*100-RHS250*150 | B/5 | 1.8 | +5.140 | +5.228 | 125
TH | C250SD-C300SD/RHS200*100-RHS250*150 | B/5 | 1.8 | +5.139 | +5.227 | 125
PLATE | C350SD/RHS200*100-RHS250*150 | PL/1857 | 8.6 | +4.561 | +5.133 | 128
PLATE | C300SD/RHS200*100-RHS250*150 | PL/1845 | 7.7 | +4.571 | +5.128 | 99
PLATE | C250SD/RHS200*100 | PL/1835 | 4.9 | +4.681 | +5.103 | 79
TH | C350SD>/RHS150*100-RHS200*100 | B/5 | 1.8 | +5.136 | +5.223 | 125
TH | C300SD-C350SD/RHS150*100-RHS200*100 | B/5 | 1.8 | +5.135 | +5.223 | 125
TH | C250SD-C300SD/RHS150*100-RHS200*100 | B/5 | 1.8 | +5.134 | +5.222 | 125
PLATE | C350SD/RHS150*100-RHS200*100 | PL/1855 | 8 | +4.556 | +5.128 | 128
PLATE | C300SD/RHS150*100-RHS200*100 | PL/1843 | 7.2 | +4.566 | +5.123 | 99
PLATE | C250SD/RHS150*100 | PL/1833 | 4.5 | +4.675 | +5.097 | 79
TH | C200SD-C250SD/RHS150*50-RHS150*100 | B/5 | 1.8 | +5.133 | +5.221 | 125
TH | C150SD-C200SD/RHS150*50-RHS150*100 | B/5 | 1.8 | +5.133 | +5.221 | 125
PLATE | C200SD/RHS150*50 | PL/1829 | 2.8 | +4.770 | +5.077 | 79
PLATE | C150SD/RHS150*50 | PL/1823 | 2.4 | +4.775 | +5.072 | 67
TH | C150SD-C200SD/RHS100*50-RHS150*50 | B/5 | 1.8 | +5.127 | +5.215 | 125
PLATE | C150SD/RHS100*50 | PL/1821 | 2.2 | +4.770 | +5.067 | 67
TH | C350SD>/SHS125*125-RHS100*50 | B/5 | 1.8 | +5.133 | +5.221 | 125
TH | C300SD-C350SD/SHS125*125-RHS100*50 | B/5 | 1.8 | +5.132 | +5.220 | 125
TH | C250SD-C300SD/SHS125*125-RHS100*50 | B/5 | 1.8 | +5.131 | +5.219 | 125
PLATE | C350SD/SHS125*125-RHS100*50 | PL/1709 | 7.7 | +4.553 | +5.125 | 128
PLATE | C300SD/SHS125*125-RHS100*50 | PL/1705 | 6.8 | +4.563 | +5.120 | 99
PLATE | C250SD/SHS125*125 | PL/1697 | 4.3 | +4.673 | +5.095 | 79
TH | C350SD>/SHS100*100-SHS125*125 | B/5 | 1.8 | +5.130 | +5.218 | 125
TH | C300SD-C350SD/SHS100*100-SHS125*125 | B/5 | 1.8 | +5.129 | +5.217 | 125
TH | C250SD-C300SD/SHS100*100-SHS125*125 | B/5 | 1.8 | +5.129 | +5.216 | 125
PLATE | C350SD/SHS100*100-SHS125*125 | PL/1967 | 7.4 | +4.546 | +5.123 | 128
PLATE | C300SD/SHS100*100-SHS125*125 | PL/1963 | 6.6 | +4.566 | +5.117 | 99
PLATE | C250SD/SHS100*100 | PL/1959 | 4.1 | +4.660 | +5.092 | 79
TH | C200SD-C250SD/SHS75*75-SHS100*100 | B/5 | 1.8 | +5.125 | +5.213 | 125
TH | C150SD-C200SD/SHS75*75-SHS100*100 | B/5 | 1.8 | +5.125 | +5.213 | 125
PLATE | C200SD/SHS75*75 | PL/1955 | 2.4 | +4.757 | +5.069 | 79
TH | C150SD-C200SD/SHS50*50-SHS75*75 | B/5 | 1.8 | +5.122 | +5.210 | 125
PLATE | C150SD/SHS50*50 | PL/1950 | 1.9 | +4.764 | +5.061 | 67
COLUMN | C350SD>/RHS250*150 | Z/2190 | 155.6 | +0.000 | +5.203 | 150
COLUMN | C350SD>/RHS200*100 | Z/2189 | 113.9 | +0.000 | +5.163 | 100
COLUMN | C350SD>/RHS150*100 | Z/2188 | 93.6 | +0.000 | +5.163 | 100
COLUMN | C350SD>/SHS125*125 | Z/2187 | 93.6 | +0.000 | +5.163 | 125
COLUMN | C350SD>/SHS100*100 | Z/2186 | 73.4 | +0.000 | +5.163 | 100
RAFTER | C350SD>/RHS250*150> | Z/2177 | 11.5 | +4.827 | +5.471 | 125
RAFTER | C350SD>/RHS200*100-RHS250*150 | Z/2177 | 11.5 | +4.816 | +5.459 | 125
RAFTER | C350SD>/RHS150*100-RHS200*100 | Z/2177 | 11.5 | +4.804 | +5.447 | 125
RAFTER | C350SD>/SHS125*125-RHS100*50 | Z/2177 | 11.5 | +4.798 | +5.441 | 125
RAFTER | C350SD>/SHS100*100-SHS125*125 | Z/2177 | 11.5 | +4.792 | +5.436 | 125
PLATE | C350SD>/RHS250*150> | PL/1245 | 9.8 | +4.643 | +5.322 | 128
PLATE | C350SD>/RHS200*100-RHS250*150 | PL/1241 | 9.2 | +4.632 | +5.310 | 128
PLATE | C350SD>/RHS150*100-RHS200*100 | PL/1240 | 8.6 | +4.620 | +5.299 | 128
PLATE | C350SD>/SHS125*125-RHS100*50 | PL/1242 | 8.3 | +4.614 | +5.293 | 128
PLATE | C350SD>/SHS100*100-SHS125*125 | PL/1239 | 8 | +4.603 | +5.287 | 128
COLUMN | C300SD-C350SD/RHS250*150 | Z/2136 | 154.4 | +0.000 | +5.163 | 150
COLUMN | C300SD-C350SD/RHS200*100 | Z/2135 | 113.9 | +0.000 | +5.163 | 100
COLUMN | C300SD-C350SD/RHS150*100 | Z/2134 | 93.6 | +0.000 | +5.163 | 100
COLUMN | C300SD-C350SD/SHS125*125 | Z/2133 | 93.6 | +0.000 | +5.163 | 125
COLUMN | C300SD-C350SD/SHS100*100 | Z/2132 | 73.4 | +0.000 | +5.163 | 100
RAFTER | C300SD-C350SD/RHS250*150> | Z/2111 | 10.3 | +4.861 | +5.480 | 96
RAFTER | C300SD-C350SD/RHS200*100-RHS250*150 | Z/2111 | 10.3 | +4.849 | +5.469 | 96
RAFTER | C300SD-C350SD/RHS150*100-RHS200*100 | Z/2111 | 10.3 | +4.838 | +5.457 | 96
RAFTER | C300SD-C350SD/SHS125*125-RHS100*50 | Z/2111 | 10.3 | +4.832 | +5.451 | 96
RAFTER | C300SD-C350SD/SHS100*100-SHS125*125 | Z/2111 | 10.3 | +4.826 | +5.445 | 96
PLATE | C300SD-C350SD/RHS250*150> | PL/1225 | 8.7 | +4.647 | +5.310 | 99
PLATE | C300SD-C350SD/RHS200*100-RHS250*150 | PL/1221 | 8.3 | +4.635 | +5.299 | 99
PLATE | C300SD-C350SD/RHS150*100-RHS200*100 | PL/1220 | 7.7 | +4.623 | +5.287 | 99
PLATE | C300SD-C350SD/SHS125*125-RHS100*50 | PL/1223 | 7.4 | +4.618 | +5.281 | 99
PLATE | C300SD-C350SD/SHS100*100-SHS125*125 | PL/1219 | 7.2 | +4.617 | +5.275 | 99
COLUMN | C250SD-C300SD/RHS200*100 | Z/2076 | 113.9 | +0.000 | +5.163 | 100
COLUMN | C250SD-C300SD/RHS150*100 | Z/2075 | 93.6 | +0.000 | +5.163 | 100
COLUMN | C250SD-C300SD/SHS125*125 | Z/2074 | 93.6 | +0.000 | +5.163 | 125
COLUMN | C250SD-C300SD/SHS100*100 | Z/2073 | 73.4 | +0.000 | +5.163 | 100
RAFTER | C250SD-C300SD/RHS200*100-RHS250*150 | Z/2056 | 7 | +4.880 | +5.477 | 76
RAFTER | C250SD-C300SD/RHS150*100-RHS200*100 | Z/2056 | 7 | +4.868 | +5.466 | 76
RAFTER | C250SD-C300SD/SHS125*125-RHS100*50 | Z/2056 | 7 | +4.862 | +5.460 | 76
RAFTER | C250SD-C300SD/SHS100*100-SHS125*125 | Z/2056 | 7 | +4.857 | +5.454 | 76
PLATE | C250SD-C300SD/RHS200*100-RHS250*150 | PL/1203 | 5.2 | +4.739 | +5.239 | 79
PLATE | C250SD-C300SD/RHS150*100 | PL/1202 | 4.9 | +4.727 | +5.227 | 79
PLATE | C250SD-C300SD/SHS125*125 | PL/1205 | 4.7 | +4.721 | +5.222 | 79
PLATE | C250SD-C300SD/SHS100*100 | PL/1201 | 4.5 | +4.706 | +5.216 | 79
COLUMN | C200SD-C250SD/RHS150*50 | Z/2027 | 72.6 | +0.000 | +5.113 | 50
COLUMN | C200SD-C250SD/SHS75*75 | Z/2026 | 52.6 | +0.000 | +5.113 | 75
RAFTER | C200SD-C250SD/RHS150*50-RHS150*100 | Z/2041 | 6.5 | +4.903 | +5.476 | 76
RAFTER | C200SD-C250SD/SHS75*75-SHS100*100 | Z/2041 | 6.5 | +4.885 | +5.458 | 76
PLATE | C200SD-C250SD/RHS150*50 | PL/1187 | 3 | +4.815 | +5.180 | 79
PLATE | C200SD-C250SD/SHS75*75 | PL/1189 | 2.6 | +4.793 | +5.162 | 79
COLUMN | C150SD-C200SD/RHS150*50 | Z/1799 | 73.4 | +0.000 | +5.163 | 50
COLUMN | C150SD-C200SD/RHS100*50 | Z/1798 | 53.1 | +0.000 | +5.163 | 50
COLUMN | C150SD-C200SD/SHS75*75 | Z/1790 | 52.6 | +0.000 | +5.113 | 75
COLUMN | C150SD-C200SD/SHS50*50 | Z/1789 | 32.7 | +0.000 | +5.113 | 50
RAFTER | C150SD-C200SD/RHS150*50-RHS150*100 | Z/1521 | 5.4 | +4.937 | +5.478 | 64
RAFTER | C150SD-C200SD/RHS100*50-RHS150*50 | Z/1521 | 5.4 | +4.925 | +5.466 | 64
RAFTER | C150SD-C200SD/SHS75*75-SHS100*100 | Z/1521 | 5.4 | +4.920 | +5.461 | 64
RAFTER | C150SD-C200SD/SHS50*50-SHS75*75 | Z/1521 | 5.4 | +4.914 | +5.455 | 64
PLATE | C150SD-C200SD/RHS150*50 | PL/1179 | 2.7 | +4.814 | +5.168 | 67
PLATE | C150SD-C200SD/RHS100*50 | PL/1178 | 2.4 | +4.802 | +5.156 | 67
PLATE | C150SD-C200SD/SHS75*75 | PL/1181 | 2.2 | +4.796 | +5.150 | 67
PLATE | C150SD-C200SD/SHS50*50 | PL/1177 | 2.1 | +4.790 | +5.144 | 67
COLUMN | C350SD>/RHS250*150 | Z/1888 | 154.1 | +0.000 | +5.153 | 150
COLUMN | C350SD>/RHS200*100 | Z/1887 | 112.8 | +0.000 | +5.113 | 100
COLUMN | C350SD>/RHS150*100 | Z/1886 | 92.7 | +0.000 | +5.113 | 100
COLUMN | C350SD>/SHS125*125 | Z/1885 | 92.7 | +0.000 | +5.113 | 125
COLUMN | C350SD>/SHS100*100 | Z/1883 | 72.6 | +0.000 | +5.113 | 100
RAFTER | C350SD>/RHS250*150> | Z/1884 | 9.2 | +4.768 | +5.293 | 125
RAFTER | C350SD>/RHS200*100-RHS250*150 | Z/1884 | 9.2 | +4.760 | +5.285 | 125
RAFTER | C350SD>/RHS150*100-RHS200*100 | Z/1884 | 9.2 | +4.752 | +5.277 | 125
RAFTER | C350SD>/SHS125*125-RHS100*50 | Z/1884 | 9.2 | +4.748 | +5.273 | 125
RAFTER | C350SD>/SHS100*100-SHS125*125 | Z/1884 | 9.2 | +4.743 | +5.269 | 125
PLATE | C350SD>/RHS250*150> | PL/1244 | 9.4 | +4.600 | +5.231 | 128
PLATE | C350SD>/RHS200*100-RHS250*150 | PL/1238 | 9 | +4.592 | +5.222 | 128
PLATE | C350SD>/RHS150*100-RHS200*100 | PL/1237 | 8.3 | +4.584 | +5.214 | 128
PLATE | C350SD>/SHS125*125-RHS100*50 | PL/1243 | 8 | +4.580 | +5.210 | 128
PLATE | C350SD>/SHS100*100-SHS125*125 | PL/1236 | 7.8 | +4.571 | +5.206 | 128
COLUMN | C300SD-C350SD/RHS250*150 | Z/1870 | 154.4 | +0.000 | +5.163 | 150
COLUMN | C300SD-C350SD/RHS200*100 | Z/1869 | 113.9 | +0.000 | +5.163 | 100
COLUMN | C300SD-C350SD/RHS150*100 | Z/1868 | 93.6 | +0.000 | +5.163 | 100
COLUMN | C300SD-C350SD/SHS125*125 | Z/1867 | 93.6 | +0.000 | +5.163 | 125
COLUMN | C300SD-C350SD/SHS100*100 | Z/1865 | 73.4 | +0.000 | +5.163 | 100
RAFTER | C300SD-C350SD/RHS250*150> | Z/1866 | 8.3 | +4.807 | +5.298 | 96
RAFTER | C300SD-C350SD/RHS200*100-RHS250*150 | Z/1866 | 8.3 | +4.799 | +5.290 | 96
RAFTER | C300SD-C350SD/RHS150*100-RHS200*100 | Z/1866 | 8.3 | +4.791 | +5.282 | 96
RAFTER | C300SD-C350SD/SHS125*125-RHS100*50 | Z/1866 | 8.3 | +4.787 | +5.278 | 96
RAFTER | C300SD-C350SD/SHS100*100-SHS125*125 | Z/1866 | 8.3 | +4.783 | +5.274 | 96
PLATE | C300SD-C350SD/RHS250*150> | PL/1224 | 8.6 | +4.608 | +5.222 | 99
PLATE | C300SD-C350SD/RHS200*100-RHS250*150 | PL/1218 | 8 | +4.599 | +5.214 | 99
PLATE | C300SD-C350SD/RHS150*100-RHS200*100 | PL/1217 | 7.4 | +4.591 | +5.206 | 99
PLATE | C300SD-C350SD/SHS125*125-RHS100*50 | PL/1222 | 7.2 | +4.587 | +5.202 | 99
PLATE | C300SD-C350SD/SHS100*100-SHS125*125 | PL/1216 | 6.8 | +4.588 | +5.198 | 99
COLUMN | C250SD-C300SD/SHS100*100 | Z/1848 | 72.6 | +0.000 | +5.113 | 100
RAFTER | C250SD-C300SD/SHS100*100-SHS125*125 | Z/1849 | 5.7 | +4.819 | +5.278 | 76
COLUMN | C250SD-C300SD/RHS200*100 | Z/1852 | 112.8 | +0.000 | +5.113 | 100
COLUMN | C250SD-C300SD/RHS150*100 | Z/1851 | 92.7 | +0.000 | +5.113 | 100
COLUMN | C250SD-C300SD/SHS125*125 | Z/1850 | 92.7 | +0.000 | +5.113 | 125
RAFTER | C250SD-C300SD/RHS200*100-RHS250*150 | Z/1849 | 5.7 | +4.835 | +5.294 | 76
RAFTER | C250SD-C300SD/RHS150*100-RHS200*100 | Z/1849 | 5.7 | +4.827 | +5.286 | 76
RAFTER | C250SD-C300SD/SHS125*125-RHS100*50 | Z/1849 | 5.7 | +4.823 | +5.282 | 76
PLATE | C250SD-C300SD/SHS100*100 | PL/1198 | 4.3 | +4.680 | +5.155 | 79
PLATE | C250SD-C300SD/RHS200*100 | PL/1200 | 5.2 | +4.706 | +5.171 | 79
PLATE | C250SD-C300SD/RHS150*100 | PL/1199 | 4.7 | +4.698 | +5.163 | 79
PLATE | C250SD-C300SD/SHS125*125 | PL/1204 | 4.5 | +4.694 | +5.159 | 79
COLUMN | C200SD-C250SD/RHS150*50 | Z/1836 | 72.6 | +0.000 | +5.113 | 50
COLUMN | C200SD-C250SD/SHS75*75 | Z/1835 | 52.6 | +0.000 | +5.113 | 75
RAFTER | C200SD-C250SD/RHS150*50-RHS150*100 | Z/1618 | 5.4 | +4.867 | +5.291 | 76
RAFTER | C200SD-C250SD/SHS75*75-SHS100*100 | Z/1618 | 5.4 | +4.855 | +5.279 | 76
PLATE | C200SD-C250SD/RHS150*50 | PL/1186 | 3 | +4.790 | +5.128 | 79
PLATE | C200SD-C250SD/SHS75*75 | PL/1188 | 2.4 | +4.773 | +5.116 | 79
COLUMN | C150SD-C200SD/RHS150*50 | Z/1829 | 72.6 | +0.000 | +5.113 | 50
COLUMN | C150SD-C200SD/RHS100*50 | Z/1828 | 52.6 | +0.000 | +5.113 | 50
COLUMN | C150SD-C200SD/SHS75*75 | Z/1827 | 52.1 | +0.000 | +5.063 | 75
COLUMN | C150SD-C200SD/SHS50*50 | Z/1825 | 32.4 | +0.000 | +5.063 | 50
RAFTER | C150SD-C200SD/RHS150*50-RHS150*100 | Z/1518 | 3 | +4.907 | +5.211 | 64
RAFTER | C150SD-C200SD/RHS100*50-RHS150*50 | Z/1518 | 3 | +4.899 | +5.203 | 64
RAFTER | C150SD-C200SD/SHS75*75-SHS100*100 | Z/1518 | 3 | +4.895 | +5.199 | 64
RAFTER | C150SD-C200SD/SHS50*50-SHS75*75 | Z/1518 | 3 | +4.891 | +5.195 | 64
PLATE | C150SD-C200SD/RHS150*50 | PL/1176 | 2.6 | +4.792 | +5.120 | 67
PLATE | C150SD-C200SD/RHS100*50 | PL/1175 | 2.3 | +4.784 | +5.112 | 67
PLATE | C150SD-C200SD/SHS75*75 | PL/1180 | 2.2 | +4.780 | +5.108 | 67
PLATE | C150SD-C200SD/SHS50*50 | PL/1174 | 1.9 | +4.776 | +5.104 | 67
RAFTER | C350SD>/RHS250*150> | Z/1878 | 9 | +4.745 | +5.241 | 125
RAFTER | C350SD>/RHS200*100-RHS250*150 | Z/1878 | 9 | +4.738 | +5.234 | 125
RAFTER | C350SD>/RHS150*100-RHS200*100 | Z/1878 | 9 | +4.732 | +5.228 | 125
RAFTER | C350SD>/SHS125*125-RHS100*50 | Z/1878 | 9 | +4.728 | +5.224 | 125
RAFTER | C350SD>/SHS100*100-SHS125*125 | Z/1878 | 9 | +4.725 | +5.221 | 125
COLUMN | C350SD>/RHS250*150 | Z/1882 | 154.1 | +0.000 | +5.153 | 150
COLUMN | C350SD>/RHS200*100 | Z/1881 | 112.8 | +0.000 | +5.113 | 100
COLUMN | C350SD>/RHS150*100 | Z/1880 | 92.7 | +0.000 | +5.113 | 100
COLUMN | C350SD>/SHS125*125 | Z/1879 | 92.7 | +0.000 | +5.113 | 125
COLUMN | C350SD>/SHS100*100 | Z/1877 | 72.6 | +0.000 | +5.113 | 100
PLATE | C350SD>/RHS250*150> | PL/1159 | 9.4 | +4.583 | +5.192 | 128
PLATE | C350SD>/RHS200*100-RHS250*150 | PL/1129 | 8.7 | +4.577 | +5.185 | 128
PLATE | C350SD>/RHS150*100-RHS200*100 | PL/1128 | 8.3 | +4.570 | +5.178 | 128
PLATE | C350SD>/SHS125*125-RHS100*50 | PL/1150 | 7.8 | +4.567 | +5.175 | 128
PLATE | C350SD>/SHS100*100-SHS125*125 | PL/1127 | 7.7 | +4.558 | +5.172 | 128
RAFTER | C300SD-C350SD/RHS250*150> | Z/1860 | 8 | +4.787 | +5.245 | 96
RAFTER | C300SD-C350SD/RHS200*100-RHS250*150 | Z/1860 | 8 | +4.780 | +5.238 | 96
RAFTER | C300SD-C350SD/RHS150*100-RHS200*100 | Z/1860 | 8 | +4.773 | +5.231 | 96
RAFTER | C300SD-C350SD/SHS125*125-RHS100*50 | Z/1860 | 8 | +4.770 | +5.228 | 96
RAFTER | C300SD-C350SD/SHS100*100-SHS125*125 | Z/1860 | 8 | +4.766 | +5.224 | 96
COLUMN | C300SD-C350SD/RHS250*150 | Z/1864 | 154.4 | +0.000 | +5.163 | 150
COLUMN | C300SD-C350SD/RHS200*100 | Z/1863 | 113.9 | +0.000 | +5.163 | 100
COLUMN | C300SD-C350SD/RHS150*100 | Z/1862 | 93.6 | +0.000 | +5.163 | 100
COLUMN | C300SD-C350SD/SHS125*125 | Z/1861 | 93.6 | +0.000 | +5.163 | 125
COLUMN | C300SD-C350SD/SHS100*100 | Z/1859 | 73.4 | +0.000 | +5.163 | 100
PLATE | C300SD-C350SD/RHS250*150> | PL/1069 | 8.6 | +4.592 | +5.185 | 99
PLATE | C300SD-C350SD/RHS200*100-RHS250*150 | PL/1039 | 7.8 | +4.585 | +5.178 | 99
PLATE | C300SD-C350SD/RHS150*100-RHS200*100 | PL/1038 | 7.4 | +4.578 | +5.172 | 99
PLATE | C300SD-C350SD/SHS125*125-RHS100*50 | PL/1060 | 7.2 | +4.575 | +5.168 | 99
PLATE | C300SD-C350SD/SHS100*100-SHS125*125 | PL/1037 | 6.6 | +4.577 | +5.165 | 99
RAFTER | C250SD-C300SD/RHS200*100-RHS250*150 | Z/1844 | 5.4 | +4.818 | +5.241 | 76
RAFTER | C250SD-C300SD/RHS150*100-RHS200*100 | Z/1844 | 5.4 | +4.811 | +5.234 | 76
RAFTER | C250SD-C300SD/SHS125*125-RHS100*50 | Z/1844 | 5.4 | +4.808 | +5.231 | 76
RAFTER | C250SD-C300SD/SHS100*100-SHS125*125 | Z/1844 | 5.4 | +4.804 | +5.227 | 76
COLUMN | C250SD-C300SD/RHS200*100 | Z/1847 | 112.8 | +0.000 | +5.113 | 100
COLUMN | C250SD-C300SD/RHS150*100 | Z/1846 | 92.7 | +0.000 | +5.113 | 100
COLUMN | C250SD-C300SD/SHS125*125 | Z/1845 | 92.7 | +0.000 | +5.113 | 125
COLUMN | C250SD-C300SD/SHS100*100 | Z/1843 | 72.6 | +0.000 | +5.113 | 100
PLATE | C250SD-C300SD/RHS200*100 | PL/964 | 4.9 | +4.693 | +5.142 | 79
PLATE | C250SD-C300SD/RHS150*100 | PL/957 | 4.7 | +4.687 | +5.135 | 79
PLATE | C250SD-C300SD/SHS125*125 | PL/979 | 4.5 | +4.683 | +5.132 | 79
PLATE | C250SD-C300SD/SHS100*100 | PL/956 | 4.3 | +4.670 | +5.129 | 79
RAFTER | C200SD-C250SD/RHS150*50-RHS150*100 | Z/1617 | 5.2 | +4.854 | +5.238 | 76
COLUMN | C200SD-C250SD/RHS150*50 | Z/1834 | 71.9 | +0.000 | +5.063 | 50
COLUMN | C200SD-C250SD/SHS75*75 | Z/1833 | 52.1 | +0.000 | +5.063 | 75
RAFTER | C200SD-C250SD/SHS75*75-SHS100*100 | Z/1617 | 5.2 | +4.844 | +5.228 | 76
PLATE | C200SD-C250SD/RHS150*50 | PL/902 | 3 | +4.780 | +5.107 | 79
PLATE | C200SD-C250SD/SHS75*75 | PL/911 | 2.4 | +4.765 | +5.097 | 79
RAFTER | C150SD-C200SD/RHS150*50-RHS150*100 | Z/1515 | 3.3 | +4.896 | +5.196 | 64
RAFTER | C150SD-C200SD/RHS100*50-RHS150*50 | Z/1515 | 3.3 | +4.889 | +5.189 | 64
RAFTER | C150SD-C200SD/SHS75*75-SHS100*100 | Z/1515 | 3.3 | +4.886 | +5.186 | 64
COLUMN | C150SD-C200SD/RHS150*50 | Z/1824 | 71.9 | +0.000 | +5.063 | 50
COLUMN | C150SD-C200SD/RHS100*50 | Z/1811 | 52.1 | +0.000 | +5.063 | 50
COLUMN | C150SD-C200SD/SHS75*75 | Z/1810 | 52.1 | +0.000 | +5.063 | 75
COLUMN | C150SD-C200SD/SHS50*50 | Z/1797 | 32.4 | +0.000 | +5.063 | 50
RAFTER | C150SD-C200SD/SHS50*50-SHS75*75 | Z/1515 | 3.3 | +4.883 | +5.182 | 64
PLATE | C150SD-C200SD/RHS150*50 | PL/850 | 2.6 | +4.783 | +5.100 | 302.139
PLATE | C150SD-C200SD/RHS100*50 | PL/849 | 2.3 | +4.777 | +5.093 | 67
PLATE | C150SD-C200SD/SHS75*75 | PL/871 | 2.1 | +4.773 | +5.090 | 67
PLATE | C150SD-C200SD/SHS50*50 | PL/848 | 1.9 | +4.770 | +5.086 | 67
2 x RAFTER |  | Z/2176 | 9.4 | +4.210 | +4.683 | 125
RAFTER | C350SD>/RHS200*100-RHS250*150 | Z/2176 | 9.4 | +4.210 | +4.683 | 125
RAFTER | C350SD>/RHS150*100-RHS200*100 | Z/2176 | 9.4 | +4.210 | +4.683 | 125
RAFTER | C350SD>/SHS125*125-RHS100*50 | Z/2176 | 9.4 | +4.210 | +4.683 | 125
RAFTER | C350SD>/SHS100*100-SHS125*125 | Z/2176 | 9.4 | +4.210 | +4.683 | 125
RAFTER | C350SD>/RHS250*150> | Z/1818 | 9 | +4.724 | +5.191 | 125
RAFTER | C350SD>/RHS200*100-RHS250*150 | Z/1818 | 9 | +4.718 | +5.185 | 125
RAFTER | C350SD>/RHS150*100-RHS200*100 | Z/1818 | 9 | +4.713 | +5.180 | 125
RAFTER | C350SD>/SHS125*125-RHS100*50 | Z/1818 | 9 | +4.710 | +5.177 | 125
RAFTER | C350SD>/SHS100*100-SHS125*125 | Z/1818 | 9 | +4.708 | +5.175 | 125
PLATE |  | PL/1158 | 8.7 | +4.202 | +4.700 | 128
PLATE | C350SD>/RHS200*100-RHS250*150 | PL/1126 | 8 | +4.202 | +4.700 | 128
PLATE | C350SD>/RHS150*100-RHS200*100 | PL/1124 | 7.4 | +4.202 | +4.700 | 128
PLATE | C350SD>/SHS125*125-RHS100*50 | PL/1149 | 7.2 | +4.202 | +4.700 | 128
PLATE | C350SD>/SHS100*100-SHS125*125 | PL/1122 | 7 | +4.197 | +4.700 | 128
PLATE | C350SD>/RHS250*150> | PL/1157 | 9.2 | +4.567 | +5.153 | 128
PLATE | C350SD>/RHS200*100-RHS250*150 | PL/1125 | 8.6 | +4.561 | +5.148 | 128
PLATE | C350SD>/RHS150*100-RHS200*100 | PL/1123 | 8 | +4.556 | +5.143 | 128
PLATE | C350SD>/SHS125*125-RHS100*50 | PL/1148 | 7.8 | +4.553 | +5.140 | 128
PLATE | C350SD>/SHS100*100-SHS125*125 | PL/1121 | 7.4 | +4.546 | +5.137 | 128
2 x RAFTER |  | Z/2110 | 8.6 | +4.248 | +4.685 | 96
RAFTER | C300SD-C350SD/RHS200*100-RHS250*150 | Z/2110 | 8.6 | +4.248 | +4.685 | 96
RAFTER | C300SD-C350SD/RHS150*100-RHS200*100 | Z/2110 | 8.6 | +4.248 | +4.685 | 96
RAFTER | C300SD-C350SD/SHS125*125-RHS100*50 | Z/2110 | 8.6 | +4.248 | +4.685 | 96
RAFTER | C300SD-C350SD/SHS100*100-SHS125*125 | Z/2110 | 8.6 | +4.248 | +4.685 | 96
RAFTER | C300SD-C350SD/RHS250*150> | Z/1804 | 8 | +4.767 | +5.193 | 96
RAFTER | C300SD-C350SD/RHS200*100-RHS250*150 | Z/1804 | 8 | +4.762 | +5.188 | 96
RAFTER | C300SD-C350SD/RHS150*100-RHS200*100 | Z/1804 | 8 | +4.756 | +5.182 | 96
RAFTER | C300SD-C350SD/SHS125*125-RHS100*50 | Z/1804 | 8 | +4.754 | +5.180 | 96
RAFTER | C300SD-C350SD/SHS100*100-SHS125*125 | Z/1804 | 8 | +4.751 | +5.177 | 96
PLATE |  | PL/1068 | 7.8 | +4.218 | +4.700 | 99
PLATE | C300SD-C350SD/RHS200*100-RHS250*150 | PL/1036 | 7.4 | +4.218 | +4.700 | 99
PLATE | C300SD-C350SD/RHS150*100-RHS200*100 | PL/1034 | 6.8 | +4.218 | +4.700 | 99
PLATE | C300SD-C350SD/SHS125*125-RHS100*50 | PL/1059 | 6.5 | +4.218 | +4.700 | 99
PLATE | C300SD-C350SD/SHS100*100-SHS125*125 | PL/1032 | 6.2 | +4.223 | +4.700 | 99
PLATE | C300SD-C350SD/RHS250*150> | PL/1067 | 8.3 | +4.577 | +5.148 | 99
PLATE | C300SD-C350SD/RHS200*100-RHS250*150 | PL/1035 | 7.8 | +4.571 | +5.143 | 99
PLATE | C300SD-C350SD/RHS150*100-RHS200*100 | PL/1033 | 7.2 | +4.566 | +5.137 | 99
PLATE | C300SD-C350SD/SHS125*125-RHS100*50 | PL/1058 | 7 | +4.563 | +5.135 | 99
PLATE | C300SD-C350SD/SHS100*100-SHS125*125 | PL/1031 | 6.6 | +4.566 | +5.132 | 99
RAFTER | C250SD-C300SD/RHS200*100-RHS250*150 | Z/2055 | 6 | +4.283 | +4.687 | 76
RAFTER | C250SD-C300SD/RHS150*100-RHS200*100 | Z/2055 | 6 | +4.283 | +4.687 | 76
RAFTER | C250SD-C300SD/SHS125*125-RHS100*50 | Z/2055 | 6 | +4.283 | +4.687 | 76
RAFTER | C250SD-C300SD/SHS100*100-SHS125*125 | Z/2055 | 6 | +4.283 | +4.687 | 76
RAFTER | C250SD-C300SD/RHS200*100-RHS250*150 | Z/1791 | 5.4 | +4.802 | +5.189 | 76
RAFTER | C250SD-C300SD/RHS150*100-RHS200*100 | Z/1791 | 5.4 | +4.796 | +5.184 | 76
RAFTER | C250SD-C300SD/SHS125*125-RHS100*50 | Z/1791 | 5.4 | +4.794 | +5.181 | 76
RAFTER | C250SD-C300SD/SHS100*100-SHS125*125 | Z/1791 | 5.4 | +4.791 | +5.179 | 76
PLATE | C250SD-C300SD/RHS200*100-RHS250*150 | PL/955 | 4.7 | +4.332 | +4.700 | 79
PLATE | C250SD-C300SD/RHS150*100-RHS200*100 | PL/953 | 4.3 | +4.332 | +4.700 | 79
PLATE | C250SD-C300SD/SHS125*125-RHS100*50 | PL/978 | 4.1 | +4.332 | +4.700 | 79
PLATE | C250SD-C300SD/SHS100*100-SHS125*125 | PL/951 | 3.9 | +4.322 | +4.700 | 79
PLATE | C250SD-C300SD/RHS200*100 | PL/954 | 4.9 | +4.681 | +5.113 | 79
PLATE | C250SD-C300SD/RHS150*100 | PL/952 | 4.5 | +4.675 | +5.108 | 79
PLATE | C250SD-C300SD/SHS125*125 | PL/977 | 4.3 | +4.673 | +5.105 | 79
PLATE | C250SD-C300SD/SHS100*100 | PL/950 | 4.1 | +4.660 | +5.103 | 79
RAFTER | C200SD-C250SD/RHS150*50-RHS150*100 | Z/2040 | 5.7 | +4.322 | +4.689 | 76
RAFTER | C200SD-C250SD/SHS75*75-SHS100*100 | Z/2040 | 5.7 | +4.322 | +4.689 | 76
RAFTER | C200SD-C250SD/RHS150*50-RHS150*100 | Z/1786 | 4.9 | +4.841 | +5.186 | 76
RAFTER | C200SD-C250SD/SHS75*75-SHS100*100 | Z/1786 | 4.9 | +4.833 | +5.178 | 76
PLATE | C200SD-C250SD/RHS150*50-RHS150*100 | PL/901 | 2.7 | +4.432 | +4.700 | 79
PLATE | C200SD-C250SD/SHS75*75-SHS100*100 | PL/910 | 2.3 | +4.427 | +4.700 | 79
PLATE | C200SD-C250SD/RHS150*50 | PL/900 | 2.8 | +4.770 | +5.085 | 79
PLATE | C200SD-C250SD/SHS75*75 | PL/909 | 2.4 | +4.757 | +5.077 | 79
RAFTER | C150SD-C200SD/RHS150*50-RHS150*100 | Z/1775 | 4.9 | +4.362 | +4.691 | 64
RAFTER | C150SD-C200SD/RHS100*50-RHS150*50 | Z/1775 | 4.9 | +4.362 | +4.691 | 64
RAFTER | C150SD-C200SD/SHS75*75-SHS100*100 | Z/1775 | 4.9 | +4.362 | +4.691 | 64
RAFTER | C150SD-C200SD/SHS50*50-SHS75*75 | Z/1775 | 4.9 | +4.362 | +4.691 | 64
RAFTER | C150SD-C200SD/SHS75*75-SHS100*100 | Z/1514 | 3.6 | +4.877 | +5.160 | 64
RAFTER | C150SD-C200SD/RHS150*50-RHS150*100 | Z/1514 | 3.6 | +4.885 | +5.168 | 64
RAFTER | C150SD-C200SD/RHS100*50-RHS150*50 | Z/1514 | 3.6 | +4.880 | +5.163 | 64
RAFTER | C150SD-C200SD/SHS50*50-SHS75*75 | Z/1514 | 3.6 | +4.875 | +5.157 | 64
PLATE | C150SD-C200SD/RHS150*50-RHS150*100 | PL/847 | 2.4 | +4.442 | +4.700 | 67
PLATE | C150SD-C200SD/RHS100*50-RHS150*50 | PL/845 | 2.1 | +4.442 | +4.700 | 67
PLATE | C150SD-C200SD/SHS75*75-SHS100*100 | PL/870 | 1.9 | +4.442 | +4.700 | 67
PLATE | C150SD-C200SD/SHS50*50-SHS75*75 | PL/843 | 1.8 | +4.442 | +4.700 | 67
PLATE | C150SD-C200SD/SHS75*75 | PL/869 | 2.1 | +4.767 | +5.072 | 264.773
PLATE | C150SD-C200SD/RHS150*50 | PL/846 | 2.4 | +4.775 | +5.080 | 67
PLATE | C150SD-C200SD/RHS100*50 | PL/844 | 2.3 | +4.770 | +5.074 | 67
PLATE | C150SD-C200SD/SHS50*50 | PL/842 | 1.9 | +4.764 | +5.069 | 67
COLUMN | C350SD>/SHS100*100-SHS125*125 | Z/2214 | 79.8 | +0.000 | +5.613 | 100
COLUMN | C350SD>/SHS125*125-RHS100*50 | Z/2217 | 101.8 | +0.000 | +5.613 | 125
COLUMN | C350SD>/RHS150*100-RHS200*100 | Z/2219 | 101.8 | +0.000 | +5.613 | 100
COLUMN | C350SD>/RHS200*100-RHS250*150 | Z/2221 | 123.8 | +0.000 | +5.613 | 100
2 x COLUMN |  | Z/2223 | 169.1 | +0.000 | +5.653 | 150
COLUMN | C350SD>/RHS250*150 | Z/2222 | 155.6 | +0.000 | +5.203 | 150
COLUMN | C350SD>/RHS200*100 | Z/2220 | 113.9 | +0.000 | +5.163 | 100
COLUMN | C350SD>/RHS150*100 | Z/2218 | 93.6 | +0.000 | +5.163 | 100
COLUMN | C350SD>/SHS125*125 | Z/2215 | 93.6 | +0.000 | +5.163 | 125
COLUMN | C350SD>/SHS100*100 | Z/2213 | 73.4 | +0.000 | +5.163 | 100
RAFTER | C350SD>/RHS250*150> | Z/2180 | 43.7 | +4.703 | +5.506 | 125
RAFTER | C350SD>/RHS200*100-RHS250*150 | Z/2232 | 44 | +4.699 | +5.506 | 125
RAFTER | C350SD>/RHS150*100-RHS200*100 | Z/2231 | 44.4 | +4.695 | +5.506 | 125
RAFTER | C350SD>/SHS125*125-RHS100*50 | Z/2216 | 44.6 | +4.694 | +5.506 | 125
RAFTER | C350SD>/SHS100*100-SHS125*125 | Z/2230 | 44.8 | +4.692 | +5.506 | 125
PLATE |  | PL/1161 | 8.7 | +5.018 | +5.516 | 128
PLATE | C350SD>/RHS250*150> | PL/1160 | 9 | +4.550 | +5.115 | 128
PLATE | C350SD>/RHS200*100-RHS250*150 | PL/1135 | 8 | +5.018 | +5.516 | 128
PLATE | C350SD>/RHS200*100-RHS250*150 | PL/1134 | 8.6 | +4.546 | +5.111 | 128
PLATE | C350SD>/RHS150*100-RHS200*100 | PL/1133 | 7.4 | +5.018 | +5.516 | 128
PLATE | C350SD>/RHS150*100-RHS200*100 | PL/1132 | 7.8 | +4.542 | +5.107 | 128
PLATE | C350SD>/SHS125*125-RHS100*50 | PL/1152 | 7.2 | +5.018 | +5.516 | 128
PLATE | C350SD>/SHS125*125-RHS100*50 | PL/1151 | 7.7 | +4.540 | +5.105 | 128
PLATE | C350SD>/SHS100*100-SHS125*125 | PL/1131 | 7 | +5.013 | +5.516 | 128
PLATE | C350SD>/SHS100*100-SHS125*125 | PL/1130 | 7.4 | +4.533 | +5.103 | 128
COLUMN | C300SD-C350SD/SHS100*100-SHS125*125 | Z/2158 | 81.2 | +0.000 | +5.713 | 100
COLUMN | C300SD-C350SD/SHS125*125-RHS100*50 | Z/2160 | 103.6 | +0.000 | +5.713 | 125
COLUMN | C300SD-C350SD/RHS150*100-RHS200*100 | Z/2162 | 103.6 | +0.000 | +5.713 | 100
COLUMN | C300SD-C350SD/RHS200*100-RHS250*150 | Z/2164 | 126 | +0.000 | +5.713 | 100
2 x COLUMN |  | Z/2166 | 170.9 | +0.000 | +5.713 | 150
COLUMN | C300SD-C350SD/RHS250*150 | Z/2165 | 154.4 | +0.000 | +5.163 | 150
COLUMN | C300SD-C350SD/RHS200*100 | Z/2163 | 113.9 | +0.000 | +5.163 | 100
COLUMN | C300SD-C350SD/RHS150*100 | Z/2161 | 93.6 | +0.000 | +5.163 | 100
COLUMN | C300SD-C350SD/SHS125*125 | Z/2159 | 93.6 | +0.000 | +5.163 | 125
COLUMN | C300SD-C350SD/SHS100*100 | Z/2157 | 73.4 | +0.000 | +5.163 | 100
RAFTER | C300SD-C350SD/RHS250*150> | Z/2114 | 36.9 | +4.749 | +5.507 | 96
RAFTER | C300SD-C350SD/RHS200*100-RHS250*150 | Z/2126 | 37.3 | +4.745 | +5.507 | 96
RAFTER | C300SD-C350SD/RHS150*100-RHS200*100 | Z/2125 | 37.6 | +4.741 | +5.507 | 96
RAFTER | C300SD-C350SD/SHS125*125-RHS100*50 | Z/2117 | 37.7 | +4.739 | +5.507 | 96
RAFTER | C300SD-C350SD/SHS100*100-SHS125*125 | Z/2124 | 37.9 | +4.737 | +5.507 | 96
PLATE |  | PL/1075 | 7.8 | +5.033 | +5.516 | 99
PLATE | C300SD-C350SD/RHS250*150> | PL/1074 | 8.3 | +4.561 | +5.111 | 99
PLATE | C300SD-C350SD/RHS200*100-RHS250*150 | PL/1057 | 7.4 | +5.033 | +5.516 | 99
PLATE | C300SD-C350SD/RHS200*100-RHS250*150 | PL/1056 | 7.7 | +4.557 | +5.107 | 99
PLATE | C300SD-C350SD/RHS150*100-RHS200*100 | PL/1055 | 6.8 | +5.033 | +5.516 | 99
PLATE | C300SD-C350SD/RHS150*100-RHS200*100 | PL/1054 | 7.2 | +4.554 | +5.103 | 99
PLATE | C300SD-C350SD/SHS125*125-RHS100*50 | PL/1066 | 6.5 | +5.033 | +5.516 | 99
PLATE | C300SD-C350SD/SHS125*125-RHS100*50 | PL/1065 | 6.8 | +4.552 | +5.101 | 99
PLATE | C300SD-C350SD/SHS100*100-SHS125*125 | PL/1053 | 6.2 | +5.038 | +5.516 | 99
PLATE | C300SD-C350SD/SHS100*100-SHS125*125 | PL/1052 | 6.5 | +4.555 | +5.099 | 99
COLUMN | C250SD-C300SD/SHS100*100-SHS125*125 | Z/2094 | 79.8 | +0.000 | +5.613 | 100
COLUMN | C250SD-C300SD/SHS125*125-RHS100*50 | Z/2096 | 101.8 | +0.000 | +5.613 | 125
COLUMN | C250SD-C300SD/RHS150*100-RHS200*100 | Z/2098 | 101.8 | +0.000 | +5.613 | 100
COLUMN | C250SD-C300SD/RHS200*100-RHS250*150 | Z/2100 | 123.8 | +0.000 | +5.613 | 100
COLUMN | C250SD-C300SD/RHS200*100 | Z/2099 | 113.9 | +0.000 | +5.163 | 100
COLUMN | C250SD-C300SD/RHS150*100 | Z/2097 | 93.6 | +0.000 | +5.163 | 100
COLUMN | C250SD-C300SD/SHS125*125 | Z/2095 | 93.6 | +0.000 | +5.163 | 125
COLUMN | C250SD-C300SD/SHS100*100 | Z/2093 | 73.4 | +0.000 | +5.163 | 100
RAFTER | C250SD-C300SD/RHS200*100-RHS250*150 | Z/2068 | 24.1 | +4.786 | +5.508 | 76
RAFTER | C250SD-C300SD/RHS150*100-RHS200*100 | Z/2067 | 24.3 | +4.782 | +5.508 | 76
RAFTER | C250SD-C300SD/SHS125*125-RHS100*50 | Z/2059 | 24.4 | +4.780 | +5.508 | 76
RAFTER | C250SD-C300SD/SHS100*100-SHS125*125 | Z/2066 | 24.4 | +4.778 | +5.508 | 76
PLATE | C250SD-C300SD/RHS200*100-RHS250*150 | PL/963 | 4.7 | +5.148 | +5.516 | 79
PLATE | C250SD-C300SD/RHS200*100 | PL/962 | 4.9 | +4.668 | +5.085 | 79
PLATE | C250SD-C300SD/RHS150*100-RHS200*100 | PL/961 | 4.3 | +5.148 | +5.516 | 79
PLATE | C250SD-C300SD/RHS150*100 | PL/960 | 4.5 | +4.664 | +5.081 | 79
PLATE | C250SD-C300SD/SHS125*125-RHS100*50 | PL/981 | 3.9 | +5.148 | +5.516 | 79
PLATE | C250SD-C300SD/SHS125*125 | PL/980 | 4.1 | +4.662 | +5.079 | 79
PLATE | C250SD-C300SD/SHS100*100-SHS125*125 | PL/959 | 3.9 | +5.138 | +5.516 | 79
PLATE | C250SD-C300SD/SHS100*100 | PL/958 | 4.1 | +4.650 | +5.077 | 79
COLUMN | C200SD-C250SD/RHS150*50-RHS150*100 | Z/2039 | 81.2 | +0.000 | +5.713 | 50
COLUMN | C200SD-C250SD/RHS150*50 | Z/2038 | 72.6 | +0.000 | +5.113 | 50
COLUMN | C200SD-C250SD/SHS75*75-SHS100*100 | Z/2037 | 58.8 | +0.000 | +5.713 | 75
COLUMN | C200SD-C250SD/SHS75*75 | Z/2036 | 52.6 | +0.000 | +5.113 | 75
RAFTER | C200SD-C250SD/RHS150*50-RHS150*100 | Z/2047 | 21.8 | +4.829 | +5.509 | 76
RAFTER | C200SD-C250SD/SHS75*75-SHS100*100 | Z/2044 | 22 | +4.823 | +5.509 | 76
PLATE | C200SD-C250SD/RHS150*50-RHS150*100 | PL/899 | 2.7 | +5.248 | +5.516 | 79
PLATE | C200SD-C250SD/RHS150*50 | PL/898 | 2.8 | +4.760 | +5.064 | 79
PLATE | C200SD-C250SD/SHS75*75-SHS100*100 | PL/908 | 2.2 | +5.243 | +5.516 | 79
PLATE | C200SD-C250SD/SHS75*75 | PL/907 | 2.4 | +4.749 | +5.058 | 79
COLUMN | C150SD-C200SD/RHS150*50-RHS150*100 | Z/1871 | 81.2 | +0.000 | +5.713 | 50
COLUMN | C150SD-C200SD/RHS150*50 | Z/1857 | 73.4 | +0.000 | +5.163 | 50
COLUMN | C150SD-C200SD/RHS100*50-RHS150*50 | Z/1856 | 58.8 | +0.000 | +5.713 | 50
COLUMN | C150SD-C200SD/RHS100*50 | Z/1855 | 53.1 | +0.000 | +5.163 | 50
COLUMN | C150SD-C200SD/SHS75*75-SHS100*100 | Z/1854 | 58.2 | +0.000 | +5.663 | 75
COLUMN | C150SD-C200SD/SHS75*75 | Z/1853 | 52.6 | +0.000 | +5.113 | 75
COLUMN | C150SD-C200SD/SHS50*50-SHS75*75 | Z/1841 | 36.2 | +0.000 | +5.663 | 50
COLUMN | C150SD-C200SD/SHS50*50 | Z/1840 | 32.7 | +0.000 | +5.113 | 50
RAFTER | C150SD-C200SD/RHS150*50-RHS150*100 | Z/2020 | 17.3 | +4.875 | +5.511 | 64
RAFTER | C150SD-C200SD/RHS100*50-RHS150*50 | Z/2019 | 17.4 | +4.871 | +5.511 | 64
RAFTER | C150SD-C200SD/SHS75*75-SHS100*100 | Z/1778 | 17.4 | +4.869 | +5.511 | 64
RAFTER | C150SD-C200SD/SHS50*50-SHS75*75 | Z/2018 | 17.6 | +4.867 | +5.511 | 64
PLATE | C150SD-C200SD/RHS150*50-RHS150*100 | PL/862 | 2.4 | +5.258 | +5.516 | 67
PLATE | C150SD-C200SD/RHS150*50 | PL/861 | 2.4 | +4.767 | +5.060 | 67
PLATE | C150SD-C200SD/RHS100*50-RHS150*50 | PL/860 | 2.1 | +5.258 | +5.516 | 67
PLATE | C150SD-C200SD/RHS100*50 | PL/859 | 2.2 | +4.763 | +5.056 | 67
PLATE | C150SD-C200SD/SHS75*75-SHS100*100 | PL/875 | 1.9 | +5.258 | +5.516 | 67
PLATE | C150SD-C200SD/SHS75*75 | PL/874 | 2.1 | +4.761 | +5.054 | 67
PLATE | C150SD-C200SD/SHS50*50-SHS75*75 | PL/858 | 1.8 | +5.258 | +5.516 | 67
PLATE | C150SD-C200SD/SHS50*50 | PL/857 | 1.9 | +4.759 | +5.052 | 67
COLUMN | C350SD>/SHS100*100-SHS125*125 | Z/2203 | 77.6 | +0.000 | +5.463 | 100
COLUMN | C350SD>/SHS125*125-RHS100*50 | Z/2206 | 99.1 | +0.000 | +5.463 | 125
COLUMN | C350SD>/RHS150*100-RHS200*100 | Z/2208 | 99.1 | +0.000 | +5.463 | 100
COLUMN | C350SD>/RHS200*100-RHS250*150 | Z/2210 | 120.5 | +0.000 | +5.463 | 100
2 x COLUMN |  | Z/2212 | 164.6 | +0.000 | +5.503 | 150
COLUMN | C350SD>/RHS250*150 | Z/2211 | 155.6 | +0.000 | +5.203 | 150
COLUMN | C350SD>/RHS200*100 | Z/2209 | 113.9 | +0.000 | +5.163 | 100
COLUMN | C350SD>/RHS150*100 | Z/2207 | 93.6 | +0.000 | +5.163 | 100
COLUMN | C350SD>/SHS125*125 | Z/2204 | 93.6 | +0.000 | +5.163 | 125
COLUMN | C350SD>/SHS100*100 | Z/2202 | 73.4 | +0.000 | +5.163 | 100
RAFTER | C350SD>/RHS250*150> | Z/2179 | 43 | +4.678 | +5.278 | 125
RAFTER | C350SD>/RHS200*100-RHS250*150 | Z/2229 | 43.4 | +4.676 | +5.278 | 125
RAFTER | C350SD>/RHS150*100-RHS200*100 | Z/2228 | 43.8 | +4.674 | +5.278 | 125
RAFTER | C350SD>/SHS125*125-RHS100*50 | Z/2205 | 44 | +4.673 | +5.278 | 125
RAFTER | C350SD>/SHS100*100-SHS125*125 | Z/2227 | 44.2 | +4.672 | +5.278 | 125
PLATE |  | PL/1165 | 8.6 | +4.784 | +5.282 | 128
PLATE | C350SD>/RHS250*150> | PL/1164 | 8.7 | +4.529 | +5.064 | 128
PLATE | C350SD>/RHS200*100-RHS250*150 | PL/1147 | 8 | +4.784 | +5.282 | 128
PLATE | C350SD>/RHS200*100-RHS250*150 | PL/1146 | 8.3 | +4.527 | +5.062 | 128
PLATE | C350SD>/RHS150*100-RHS200*100 | PL/1145 | 7.4 | +4.784 | +5.282 | 128
PLATE | C350SD>/RHS150*100-RHS200*100 | PL/1144 | 7.7 | +4.524 | +5.059 | 128
PLATE | C350SD>/SHS125*125-RHS100*50 | PL/1156 | 7.2 | +4.784 | +5.282 | 128
PLATE | C350SD>/SHS125*125-RHS100*50 | PL/1155 | 7.4 | +4.523 | +5.058 | 128
PLATE | C350SD>/SHS100*100-SHS125*125 | PL/1143 | 6.8 | +4.779 | +5.282 | 128
PLATE | C350SD>/SHS100*100-SHS125*125 | PL/1142 | 7.2 | +4.517 | +5.057 | 128
COLUMN | C300SD-C350SD/SHS100*100-SHS125*125 | Z/2148 | 77.6 | +0.000 | +5.463 | 100
COLUMN | C300SD-C350SD/SHS125*125-RHS100*50 | Z/2150 | 99.1 | +0.000 | +5.463 | 125
COLUMN | C300SD-C350SD/RHS150*100-RHS200*100 | Z/2152 | 99.1 | +0.000 | +5.463 | 100
COLUMN | C300SD-C350SD/RHS200*100-RHS250*150 | Z/2154 | 120.5 | +0.000 | +5.463 | 100
2 x COLUMN |  | Z/2156 | 163.4 | +0.000 | +5.463 | 150
COLUMN | C300SD-C350SD/RHS250*150 | Z/2155 | 154.4 | +0.000 | +5.163 | 150
COLUMN | C300SD-C350SD/RHS200*100 | Z/2153 | 113.9 | +0.000 | +5.163 | 100
COLUMN | C300SD-C350SD/RHS150*100 | Z/2151 | 93.6 | +0.000 | +5.163 | 100
COLUMN | C300SD-C350SD/SHS125*125 | Z/2149 | 93.6 | +0.000 | +5.163 | 125
COLUMN | C300SD-C350SD/SHS100*100 | Z/2147 | 73.4 | +0.000 | +5.163 | 100
RAFTER | C300SD-C350SD/RHS250*150> | Z/2113 | 36.4 | +4.726 | +5.278 | 96
RAFTER | C300SD-C350SD/RHS200*100-RHS250*150 | Z/2123 | 36.7 | +4.724 | +5.278 | 96
RAFTER | C300SD-C350SD/RHS150*100-RHS200*100 | Z/2122 | 37 | +4.722 | +5.278 | 96
RAFTER | C300SD-C350SD/SHS125*125-RHS100*50 | Z/2116 | 37.2 | +4.721 | +5.278 | 96
RAFTER | C300SD-C350SD/SHS100*100-SHS125*125 | Z/2121 | 37.3 | +4.720 | +5.278 | 96
PLATE |  | PL/1073 | 7.8 | +4.799 | +5.282 | 99
PLATE | C300SD-C350SD/RHS250*150> | PL/1072 | 8 | +4.542 | +5.062 | 99
PLATE | C300SD-C350SD/RHS200*100-RHS250*150 | PL/1051 | 7.4 | +4.799 | +5.282 | 99
PLATE | C300SD-C350SD/RHS200*100-RHS250*150 | PL/1050 | 7.4 | +4.540 | +5.059 | 99
PLATE | C300SD-C350SD/RHS150*100-RHS200*100 | PL/1049 | 6.8 | +4.799 | +5.282 | 99
PLATE | C300SD-C350SD/RHS150*100-RHS200*100 | PL/1048 | 7 | +4.537 | +5.057 | 99
PLATE | C300SD-C350SD/SHS125*125-RHS100*50 | PL/1064 | 6.5 | +4.799 | +5.282 | 99
PLATE | C300SD-C350SD/SHS125*125-RHS100*50 | PL/1063 | 6.6 | +4.536 | +5.056 | 99
PLATE | C300SD-C350SD/SHS100*100-SHS125*125 | PL/1047 | 6.2 | +4.804 | +5.282 | 99
PLATE | C300SD-C350SD/SHS100*100-SHS125*125 | PL/1046 | 6.5 | +4.540 | +5.055 | 99
COLUMN | C250SD-C300SD/SHS125*125-RHS100*50 | Z/2088 | 100 | +0.000 | +5.513 | 125
COLUMN | C250SD-C300SD/SHS100*100-SHS125*125 | Z/2086 | 78.3 | +0.000 | +5.513 | 100
COLUMN | C250SD-C300SD/RHS150*100-RHS200*100 | Z/2090 | 100 | +0.000 | +5.513 | 100
COLUMN | C250SD-C300SD/RHS200*100-RHS250*150 | Z/2092 | 121.6 | +0.000 | +5.513 | 100
COLUMN | C250SD-C300SD/RHS200*100 | Z/2091 | 113.9 | +0.000 | +5.163 | 100
COLUMN | C250SD-C300SD/RHS150*100 | Z/2089 | 93.6 | +0.000 | +5.163 | 100
COLUMN | C250SD-C300SD/SHS125*125 | Z/2087 | 93.6 | +0.000 | +5.163 | 125
COLUMN | C250SD-C300SD/SHS100*100 | Z/2085 | 73.4 | +0.000 | +5.163 | 100
RAFTER | C250SD-C300SD/RHS200*100-RHS250*150 | Z/2065 | 23.8 | +4.767 | +5.278 | 76
RAFTER | C250SD-C300SD/RHS150*100-RHS200*100 | Z/2064 | 24 | +4.765 | +5.278 | 76
RAFTER | C250SD-C300SD/SHS125*125-RHS100*50 | Z/2058 | 24.1 | +4.764 | +5.278 | 76
RAFTER | C250SD-C300SD/SHS100*100-SHS125*125 | Z/2063 | 24.3 | +4.763 | +5.278 | 76
PLATE | C250SD-C300SD/RHS200*100-RHS250*150 | PL/976 | 4.7 | +4.913 | +5.281 | 79
PLATE | C250SD-C300SD/RHS200*100 | PL/975 | 4.9 | +4.652 | +5.047 | 79
PLATE | C250SD-C300SD/RHS150*100-RHS200*100 | PL/974 | 4.1 | +4.913 | +5.281 | 79
PLATE | C250SD-C300SD/RHS150*100 | PL/973 | 4.3 | +4.650 | +5.045 | 79
PLATE | C250SD-C300SD/SHS125*125-RHS100*50 | PL/985 | 3.9 | +4.913 | +5.281 | 79
PLATE | C250SD-C300SD/SHS125*125 | PL/984 | 4.1 | +4.649 | +5.044 | 79
PLATE | C250SD-C300SD/SHS100*100-SHS125*125 | PL/972 | 3.9 | +4.903 | +5.281 | 79
PLATE | C250SD-C300SD/SHS100*100 | PL/971 | 3.9 | +4.638 | +5.043 | 79
COLUMN | C200SD-C250SD/SHS75*75-SHS100*100 | Z/2033 | 56.2 | +0.000 | +5.463 | 75
COLUMN | C200SD-C250SD/RHS150*50-RHS150*100 | Z/2035 | 77.6 | +0.000 | +5.463 | 50
COLUMN | C200SD-C250SD/RHS150*50 | Z/2034 | 72.6 | +0.000 | +5.113 | 50
COLUMN | C200SD-C250SD/SHS75*75 | Z/2032 | 52.6 | +0.000 | +5.113 | 75
RAFTER | C200SD-C250SD/RHS150*50-RHS150*100 | Z/2046 | 21.4 | +4.814 | +5.279 | 76
RAFTER | C200SD-C250SD/SHS75*75-SHS100*100 | Z/2043 | 21.6 | +4.810 | +5.279 | 76
PLATE | C200SD-C250SD/RHS150*50-RHS150*100 | PL/897 | 2.7 | +5.013 | +5.281 | 79
PLATE | C200SD-C250SD/RHS150*50 | PL/896 | 2.7 | +4.747 | +5.035 | 79
PLATE | C200SD-C250SD/SHS75*75-SHS100*100 | PL/906 | 2.2 | +5.008 | +5.281 | 79
PLATE | C200SD-C250SD/SHS75*75 | PL/905 | 2.3 | +4.739 | +5.032 | 79
COLUMN | C150SD-C200SD/SHS50*50-SHS75*75 | Z/1817 | 34.3 | +0.000 | +5.363 | 50
COLUMN | C150SD-C200SD/SHS75*75-SHS100*100 | Z/1831 | 55.2 | +0.000 | +5.363 | 75
COLUMN | C150SD-C200SD/RHS100*50-RHS150*50 | Z/1837 | 55.7 | +0.000 | +5.413 | 50
COLUMN | C150SD-C200SD/RHS150*50-RHS150*100 | Z/1839 | 76.9 | +0.000 | +5.413 | 50
COLUMN | C150SD-C200SD/RHS150*50 | Z/1838 | 73.4 | +0.000 | +5.163 | 50
COLUMN | C150SD-C200SD/RHS100*50 | Z/1832 | 53.1 | +0.000 | +5.163 | 50
COLUMN | C150SD-C200SD/SHS75*75 | Z/1826 | 52.6 | +0.000 | +5.113 | 75
COLUMN | C150SD-C200SD/SHS50*50 | Z/1816 | 32.7 | +0.000 | +5.113 | 50
RAFTER | C150SD-C200SD/RHS150*50-RHS150*100 | Z/2008 | 17 | +4.862 | +5.279 | 64
RAFTER | C150SD-C200SD/RHS100*50-RHS150*50 | Z/2004 | 17.1 | +4.860 | +5.279 | 64
RAFTER | C150SD-C200SD/SHS75*75-SHS100*100 | Z/1777 | 17.1 | +4.859 | +5.279 | 64
RAFTER | C150SD-C200SD/SHS50*50-SHS75*75 | Z/1875 | 17.3 | +4.858 | +5.279 | 64
PLATE | C150SD-C200SD/RHS150*50-RHS150*100 | PL/856 | 2.4 | +5.024 | +5.281 | 67
PLATE | C150SD-C200SD/RHS150*50 | PL/855 | 2.4 | +4.756 | +5.033 | 67
PLATE | C150SD-C200SD/RHS100*50-RHS150*50 | PL/854 | 2.1 | +5.024 | +5.281 | 67
PLATE | C150SD-C200SD/RHS100*50 | PL/853 | 2.2 | +4.754 | +5.031 | 67
PLATE | C150SD-C200SD/SHS75*75-SHS100*100 | PL/873 | 1.9 | +5.024 | +5.281 | 67
PLATE | C150SD-C200SD/SHS75*75 | PL/872 | 1.9 | +4.752 | +5.030 | 67
PLATE | C150SD-C200SD/SHS50*50-SHS75*75 | PL/852 | 1.8 | +5.024 | +5.281 | 67
PLATE | C150SD-C200SD/SHS50*50 | PL/851 | 1.9 | +4.751 | +5.029 | 67
2 x COLUMN |  | Z/2201 | 167.6 | +0.000 | +5.603 | 150
COLUMN | C350SD>/RHS250*150 | Z/2200 | 155.6 | +0.000 | +5.203 | 150
COLUMN | C350SD>/RHS200*100-RHS250*150 | Z/2199 | 122.7 | +0.000 | +5.563 | 100
COLUMN | C350SD>/RHS200*100 | Z/2198 | 113.9 | +0.000 | +5.163 | 100
COLUMN | C350SD>/RHS150*100-RHS200*100 | Z/2197 | 100.9 | +0.000 | +5.563 | 100
COLUMN | C350SD>/RHS150*100 | Z/2196 | 93.6 | +0.000 | +5.163 | 100
COLUMN | C350SD>/SHS125*125-RHS100*50 | Z/2195 | 100.9 | +0.000 | +5.563 | 125
COLUMN | C350SD>/SHS125*125 | Z/2193 | 93.6 | +0.000 | +5.163 | 125
COLUMN | C350SD>/SHS100*100-SHS125*125 | Z/2192 | 79 | +0.000 | +5.563 | 100
COLUMN | C350SD>/SHS100*100 | Z/2191 | 73.4 | +0.000 | +5.163 | 100
RAFTER | C350SD>/RHS250*150> | Z/2178 | 43 | +4.667 | +5.167 | 125
RAFTER | C350SD>/RHS200*100-RHS250*150 | Z/2226 | 43.3 | +4.665 | +5.167 | 125
RAFTER | C350SD>/RHS150*100-RHS200*100 | Z/2225 | 43.7 | +4.664 | +5.167 | 125
RAFTER | C350SD>/SHS125*125-RHS100*50 | Z/2194 | 44 | +4.663 | +5.167 | 125
RAFTER | C350SD>/SHS100*100-SHS125*125 | Z/2224 | 44.1 | +4.663 | +5.167 | 125
PLATE |  | PL/1163 | 8.6 | +4.670 | +5.168 | 128
PLATE | C350SD>/RHS250*150> | PL/1162 | 8.7 | +4.518 | +5.038 | 128
PLATE | C350SD>/RHS200*100-RHS250*150 | PL/1141 | 8 | +4.670 | +5.168 | 128
PLATE | C350SD>/RHS200*100-RHS250*150 | PL/1140 | 8 | +4.517 | +5.037 | 128
PLATE | C350SD>/RHS150*100-RHS200*100 | PL/1139 | 7.4 | +4.670 | +5.168 | 128
PLATE | C350SD>/RHS150*100-RHS200*100 | PL/1138 | 7.7 | +4.516 | +5.036 | 128
PLATE | C350SD>/SHS125*125-RHS100*50 | PL/1154 | 7.2 | +4.670 | +5.168 | 128
PLATE | C350SD>/SHS125*125-RHS100*50 | PL/1153 | 7.4 | +4.515 | +5.035 | 128
PLATE | C350SD>/SHS100*100-SHS125*125 | PL/1137 | 6.8 | +4.665 | +5.168 | 128
PLATE | C350SD>/SHS100*100-SHS125*125 | PL/1136 | 7 | +4.509 | +5.034 | 128
2 x COLUMN |  | Z/2146 | 157.4 | +0.000 | +5.263 | 150
COLUMN | C300SD-C350SD/RHS250*150 | Z/2145 | 154.4 | +0.000 | +5.163 | 150
COLUMN | C300SD-C350SD/RHS200*100-RHS250*150 | Z/2144 | 116.1 | +0.000 | +5.263 | 100
COLUMN | C300SD-C350SD/RHS200*100 | Z/2143 | 113.9 | +0.000 | +5.163 | 100
COLUMN | C300SD-C350SD/RHS150*100-RHS200*100 | Z/2142 | 95.4 | +0.000 | +5.263 | 100
COLUMN | C300SD-C350SD/RHS150*100 | Z/2141 | 93.6 | +0.000 | +5.163 | 100
COLUMN | C300SD-C350SD/SHS125*125-RHS100*50 | Z/2140 | 95.4 | +0.000 | +5.263 | 125
COLUMN | C300SD-C350SD/SHS125*125 | Z/2139 | 93.6 | +0.000 | +5.163 | 125
COLUMN | C300SD-C350SD/SHS100*100-SHS125*125 | Z/2138 | 74.8 | +0.000 | +5.263 | 100
COLUMN | C300SD-C350SD/SHS100*100 | Z/2137 | 73.4 | +0.000 | +5.163 | 100
RAFTER | C300SD-C350SD/RHS250*150> | Z/2112 | 36.4 | +4.715 | +5.167 | 96
RAFTER | C300SD-C350SD/RHS200*100-RHS250*150 | Z/2120 | 36.6 | +4.714 | +5.167 | 96
RAFTER | C300SD-C350SD/RHS150*100-RHS200*100 | Z/2119 | 36.9 | +4.713 | +5.167 | 96
RAFTER | C300SD-C350SD/SHS125*125-RHS100*50 | Z/2115 | 37 | +4.712 | +5.167 | 96
RAFTER | C300SD-C350SD/SHS100*100-SHS125*125 | Z/2118 | 37.2 | +4.711 | +5.167 | 96
PLATE |  | PL/1071 | 7.8 | +4.685 | +5.168 | 99
PLATE | C300SD-C350SD/RHS250*150> | PL/1070 | 8 | +4.532 | +5.037 | 99
PLATE | C300SD-C350SD/RHS200*100-RHS250*150 | PL/1045 | 7.4 | +4.685 | +5.168 | 99
PLATE | C300SD-C350SD/RHS200*100-RHS250*150 | PL/1044 | 7.4 | +4.531 | +5.036 | 99
PLATE | C300SD-C350SD/RHS150*100-RHS200*100 | PL/1043 | 6.8 | +4.685 | +5.168 | 99
PLATE | C300SD-C350SD/RHS150*100-RHS200*100 | PL/1042 | 6.8 | +4.529 | +5.034 | 99
PLATE | C300SD-C350SD/SHS125*125-RHS100*50 | PL/1062 | 6.5 | +4.685 | +5.168 | 99
PLATE | C300SD-C350SD/SHS125*125-RHS100*50 | PL/1061 | 6.6 | +4.529 | +5.034 | 99
PLATE | C300SD-C350SD/SHS100*100-SHS125*125 | PL/1041 | 6.2 | +4.690 | +5.168 | 99
PLATE | C300SD-C350SD/SHS100*100 | PL/1040 | 6.3 | +4.533 | +5.033 | 99
COLUMN | C250SD-C300SD/RHS200*100-RHS250*150 | Z/2084 | 115 | +0.000 | +5.213 | 100
COLUMN | C250SD-C300SD/RHS200*100 | Z/2083 | 113.9 | +0.000 | +5.163 | 100
COLUMN | C250SD-C300SD/RHS150*100-RHS200*100 | Z/2082 | 94.5 | +0.000 | +5.213 | 100
COLUMN | C250SD-C300SD/RHS150*100 | Z/2081 | 93.6 | +0.000 | +5.163 | 100
COLUMN | C250SD-C300SD/SHS125*125-RHS100*50 | Z/2080 | 94.5 | +0.000 | +5.213 | 125
COLUMN | C250SD-C300SD/SHS125*125 | Z/2079 | 93.6 | +0.000 | +5.163 | 125
COLUMN | C250SD-C300SD/SHS100*100-SHS125*125 | Z/2078 | 74.1 | +0.000 | +5.213 | 100
COLUMN | C250SD-C300SD/SHS100*100 | Z/2077 | 73.4 | +0.000 | +5.163 | 100
PLATE | C250SD-C300SD/RHS200*100-RHS250*150 | PL/970 | 4.7 | +4.800 | +5.168 | 79
PLATE | C250SD-C300SD/RHS200*100 | PL/969 | 4.7 | +4.644 | +5.028 | 79
PLATE | C250SD-C300SD/RHS150*100-RHS200*100 | PL/968 | 4.1 | +4.800 | +5.168 | 79
PLATE | C250SD-C300SD/RHS150*100 | PL/967 | 4.3 | +4.643 | +5.027 | 79
PLATE | C250SD-C300SD/SHS125*125-RHS100*50 | PL/983 | 3.9 | +4.800 | +5.168 | 79
PLATE | C250SD-C300SD/SHS125*125 | PL/982 | 4.1 | +4.642 | +5.026 | 79
PLATE | C250SD-C300SD/SHS100*100-SHS125*125 | PL/966 | 3.9 | +4.790 | +5.168 | 79
PLATE | C250SD-C300SD/SHS100*100 | PL/965 | 3.9 | +4.631 | +5.025 | 79
RAFTER | C250SD-C300SD/RHS200*100-RHS250*150 | Z/2062 | 23.8 | +4.758 | +5.166 | 76
RAFTER | C250SD-C300SD/RHS150*100-RHS200*100 | Z/2061 | 24 | +4.757 | +5.166 | 76
RAFTER | C250SD-C300SD/SHS125*125-RHS100*50 | Z/2057 | 24 | +4.756 | +5.166 | 76
RAFTER | C250SD-C300SD/SHS100*100-SHS125*125 | Z/2060 | 24.1 | +4.756 | +5.166 | 76
COLUMN | C200SD-C250SD/RHS150*50-RHS150*100 | Z/2031 | 75 | +0.000 | +5.280 | 50
COLUMN | C200SD-C250SD/RHS150*50 | Z/2030 | 72.6 | +0.000 | +5.113 | 50
COLUMN | C200SD-C250SD/SHS75*75-SHS100*100 | Z/2029 | 54.3 | +0.000 | +5.280 | 75
COLUMN | C200SD-C250SD/SHS75*75 | Z/2028 | 52.6 | +0.000 | +5.113 | 75
RAFTER | C200SD-C250SD/RHS150*50-RHS150*100 | Z/2045 | 21.3 | +4.807 | +5.167 | 76
RAFTER | C200SD-C250SD/SHS75*75-SHS100*100 | Z/2042 | 21.6 | +4.805 | +5.167 | 76
PLATE | C200SD-C250SD/RHS150*50-RHS150*100 | PL/904 | 2.6 | +4.900 | +5.168 | 79
PLATE | C200SD-C250SD/RHS150*50 | PL/903 | 2.7 | +4.741 | +5.021 | 79
PLATE | C200SD-C250SD/SHS75*75-SHS100*100 | PL/913 | 2.2 | +4.895 | +5.168 | 79
PLATE | C200SD-C250SD/SHS75*75 | PL/912 | 2.3 | +4.734 | +5.019 | 79
COLUMN | C150SD-C200SD/RHS150*50-RHS150*100 | Z/1815 | 75.5 | +0.000 | +5.313 | 50
COLUMN | C150SD-C200SD/RHS150*50 | Z/1814 | 73.4 | +0.000 | +5.163 | 50
COLUMN | C150SD-C200SD/RHS100*50-RHS150*50 | Z/1813 | 54.6 | +0.000 | +5.313 | 50
COLUMN | C150SD-C200SD/RHS100*50 | Z/1812 | 53.1 | +0.000 | +5.163 | 50
COLUMN | C150SD-C200SD/SHS75*75-SHS100*100 | Z/1803 | 54.1 | +0.000 | +5.263 | 75
COLUMN | C150SD-C200SD/SHS75*75 | Z/1802 | 52.6 | +0.000 | +5.113 | 75
COLUMN | C150SD-C200SD/SHS50*50-SHS75*75 | Z/1801 | 33.6 | +0.000 | +5.263 | 50
COLUMN | C150SD-C200SD/SHS50*50 | Z/1800 | 32.7 | +0.000 | +5.113 | 50
RAFTER | C150SD-C200SD/RHS150*50-RHS150*100 | Z/1874 | 17 | +4.856 | +5.167 | 64
RAFTER | C150SD-C200SD/RHS100*50-RHS150*50 | Z/1873 | 17 | +4.855 | +5.167 | 64
RAFTER | C150SD-C200SD/SHS75*75-SHS100*100 | Z/1776 | 17.1 | +4.854 | +5.167 | 64
RAFTER | C150SD-C200SD/SHS50*50-SHS75*75 | Z/1872 | 17.1 | +4.854 | +5.167 | 64
PLATE | C150SD-C200SD/RHS150*50-RHS150*100 | PL/868 | 2.4 | +4.910 | +5.168 | 67
PLATE | C150SD-C200SD/RHS150*50 | PL/867 | 2.4 | +4.750 | +5.020 | 67
PLATE | C150SD-C200SD/RHS100*50-RHS150*50 | PL/866 | 2.1 | +4.910 | +5.168 | 67
PLATE | C150SD-C200SD/RHS100*50 | PL/865 | 2.1 | +4.749 | +5.018 | 67
PLATE | C150SD-C200SD/SHS75*75-SHS100*100 | PL/877 | 1.9 | +4.910 | +5.168 | 67
PLATE | C150SD-C200SD/SHS75*75 | PL/876 | 1.9 | +4.748 | +5.018 | 67
PLATE | C150SD-C200SD/SHS50*50-SHS75*75 | PL/864 | 1.8 | +4.910 | +5.168 | 67
PLATE | C150SD-C200SD/SHS50*50 | PL/863 | 1.8 | +4.748 | +5.017 | 67
PLATE | C250SD/SHS100*100 | PL/1192 | 4.3 | +4.680 | +5.155 | 79
PLATE |  | PL/1081 | 8.7 | +4.202 | +4.700 | 128
PLATE |  | PL/987 | 7.8 | +4.218 | +4.700 | 99
TH |  | B/5 | 1.8 | +4.545 | +4.635 | 125
TH |  | B/5 | 1.8 | +4.539 | +4.629 | 125
RAFTER | C350SD/RHS200*100-RHS250*150 | Z/2176 | 9.4 | +4.210 | +4.683 | 125
RAFTER | C300SD/RHS200*100-RHS250*150 | Z/2110 | 8.6 | +4.248 | +4.685 | 96
RAFTER | C250SD/RHS200*100-RHS250*150 | Z/2055 | 6 | +4.283 | +4.687 | 76
PLATE | C350SD/RHS200*100-RHS250*150 | PL/1111 | 8 | +4.202 | +4.700 | 128
PLATE | C300SD/RHS200*100-RHS250*150 | PL/1009 | 7.4 | +4.218 | +4.700 | 99
PLATE | C250SD/RHS200*100-RHS250*150 | PL/941 | 4.7 | +4.332 | +4.700 | 79
TH | C350SD>/RHS200*100-RHS250*150 | B/5 | 1.8 | +4.545 | +4.635 | 125
TH | C300SD-C350SD/RHS200*100-RHS250*150 | B/5 | 1.8 | +4.539 | +4.629 | 125
TH | C250SD-C300SD/RHS200*100-RHS250*150 | B/5 | 1.8 | +4.534 | +4.624 | 125
RAFTER | C350SD/RHS150*100-RHS200*100 | Z/2176 | 9.4 | +4.210 | +4.683 | 125
RAFTER | C300SD/RHS150*100-RHS200*100 | Z/2110 | 8.6 | +4.248 | +4.685 | 96
RAFTER | C250SD/RHS150*100-RHS200*100 | Z/2055 | 6 | +4.283 | +4.687 | 76
PLATE | C350SD/RHS150*100-RHS200*100 | PL/1109 | 7.4 | +4.202 | +4.700 | 128
PLATE | C300SD/RHS150*100-RHS200*100 | PL/1007 | 6.8 | +4.218 | +4.700 | 99
PLATE | C250SD/RHS150*100-RHS200*100 | PL/939 | 4.3 | +4.332 | +4.700 | 79
TH | C350SD>/RHS150*100-RHS200*100 | B/5 | 1.8 | +4.545 | +4.635 | 125
TH | C300SD-C350SD/RHS150*100-RHS200*100 | B/5 | 1.8 | +4.539 | +4.629 | 125
TH | C250SD-C300SD/RHS150*100-RHS200*100 | B/5 | 1.8 | +4.534 | +4.624 | 125
RAFTER | C350SD/SHS125*125-RHS100*50 | Z/2176 | 9.4 | +4.210 | +4.683 | 125
RAFTER | C300SD/SHS125*125-RHS100*50 | Z/2110 | 8.6 | +4.248 | +4.685 | 96
RAFTER | C250SD/SHS125*125-RHS100*50 | Z/2055 | 6 | +4.283 | +4.687 | 76
PLATE | C350SD/SHS125*125-RHS100*50 | PL/1090 | 7.2 | +4.202 | +4.700 | 128
PLATE | C300SD/SHS125*125-RHS100*50 | PL/996 | 6.5 | +4.218 | +4.700 | 99
PLATE | C250SD/SHS125*125-RHS100*50 | PL/919 | 4.1 | +4.332 | +4.700 | 79
TH | C350SD>/SHS125*125-RHS100*50 | B/5 | 1.8 | +4.545 | +4.635 | 125
TH | C300SD-C350SD/SHS125*125-RHS100*50 | B/5 | 1.8 | +4.539 | +4.629 | 125
TH | C250SD-C300SD/SHS125*125-RHS100*50 | B/5 | 1.8 | +4.534 | +4.624 | 125
RAFTER | C350SD/SHS100*100-SHS125*125 | Z/2176 | 9.4 | +4.210 | +4.683 | 125
RAFTER | C300SD/SHS100*100-SHS125*125 | Z/2110 | 8.6 | +4.248 | +4.685 | 96
RAFTER | C250SD/SHS100*100-SHS125*125 | Z/2055 | 6 | +4.283 | +4.687 | 76
PLATE | C350SD/SHS100*100-SHS125*125 | PL/1107 | 7 | +4.197 | +4.700 | 128
PLATE | C300SD/SHS100*100-SHS125*125 | PL/1005 | 6.2 | +4.223 | +4.700 | 99
PLATE | C250SD/SHS100*100-SHS125*125 | PL/937 | 3.9 | +4.322 | +4.700 | 79
TH | C350SD>/SHS100*100-SHS125*125 | B/5 | 1.8 | +4.545 | +4.635 | 125
TH | C300SD-C350SD/SHS100*100-SHS125*125 | B/5 | 1.8 | +4.539 | +4.629 | 125
TH | C250SD-C300SD/SHS100*100-SHS125*125 | B/5 | 1.8 | +4.534 | +4.624 | 125
RAFTER | C200SD/RHS150*50-RHS150*100 | Z/2040 | 5.7 | +4.322 | +4.689 | 76
PLATE | C200SD/RHS150*50-RHS150*100 | PL/890 | 2.7 | +4.432 | +4.700 | 79
TH | C200SD-C250SD/RHS150*50-RHS150*100 | B/5 | 1.8 | +4.519 | +4.609 | 125
RAFTER | C200SD/SHS75*75-SHS100*100 | Z/2040 | 5.7 | +4.322 | +4.689 | 76
PLATE | C200SD/SHS75*75-SHS100*100 | PL/881 | 2.3 | +4.427 | +4.700 | 79
TH | C200SD-C250SD/SHS75*75-SHS100*100 | B/5 | 1.8 | +4.519 | +4.609 | 125
RAFTER | C150SD/RHS150*50-RHS150*100 | Z/1775 | 4.9 | +4.362 | +4.691 | 64
PLATE | C150SD/RHS150*50-RHS150*100 | PL/822 | 2.4 | +4.442 | +4.700 | 67
TH | C150SD-C200SD/RHS150*50-RHS150*100 | B/5 | 1.8 | +4.523 | +4.614 | 125
RAFTER | C150SD/RHS100*50-RHS150*50 | Z/1775 | 4.9 | +4.362 | +4.691 | 64
PLATE | C150SD/RHS100*50-RHS150*50 | PL/820 | 2.1 | +4.442 | +4.700 | 67
TH | C150SD-C200SD/RHS100*50-RHS150*50 | B/5 | 1.8 | +4.523 | +4.614 | 125
RAFTER | C150SD/SHS75*75-SHS100*100 | Z/1775 | 4.9 | +4.362 | +4.691 | 64
PLATE | C150SD/SHS75*75-SHS100*100 | PL/769 | 1.9 | +4.442 | +4.700 | 67
TH | C150SD-C200SD/SHS75*75-SHS100*100 | B/5 | 1.8 | +4.523 | +4.614 | 125
COLUMN | C350SD/SHS100*100-SHS125*125 | Z/2214 | 79.8 | +0.000 | +5.613 | 100
COLUMN | C350SD/SHS125*125-RHS100*50 | Z/2217 | 101.8 | +0.000 | +5.613 | 125
COLUMN | C350SD/RHS150*100-RHS200*100 | Z/2219 | 101.8 | +0.000 | +5.613 | 100
COLUMN | C350SD/RHS200*100-RHS250*150 | Z/2221 | 123.8 | +0.000 | +5.613 | 100
COLUMN | C350SD/RHS250*150 | Z/2222 | 155.6 | +0.000 | +5.203 | 150
COLUMN | C350SD/RHS200*100 | Z/2220 | 113.9 | +0.000 | +5.163 | 100
COLUMN | C350SD/RHS150*100 | Z/2218 | 93.6 | +0.000 | +5.163 | 100
COLUMN | C350SD/SHS125*125 | Z/2215 | 93.6 | +0.000 | +5.163 | 125
