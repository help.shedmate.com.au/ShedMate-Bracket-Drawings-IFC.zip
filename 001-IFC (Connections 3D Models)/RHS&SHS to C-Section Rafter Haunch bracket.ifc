Properties of the parts of a building model (IFC2X3), part 3 of 5

# IfcElementAssembly (1642)
Name | ASSEMBLY_POSITION_CODE = Assembly/Cast unit position code | ASSEMBLY_POS = Assembly/Cast unit Mark | Assembly/Cast unit weight (kg) | Assembly/Cast unit bottom elevation | Assembly/Cast unit top elevation | Width (mm)
COLUMN | C350SD/SHS100*100 | Z/2213 | 73.4 | +0.000 | +5.163 | 100
COLUMN | C300SD/SHS100*100-SHS125*125 | Z/2158 | 81.2 | +0.000 | +5.713 | 100
COLUMN | C300SD/SHS125*125-RHS100*50 | Z/2160 | 103.6 | +0.000 | +5.713 | 125
COLUMN | C300SD/RHS150*100-RHS200*100 | Z/2162 | 103.6 | +0.000 | +5.713 | 100
COLUMN | C300SD/RHS200*100-RHS250*150 | Z/2164 | 126 | +0.000 | +5.713 | 100
COLUMN | C300SD/RHS250*150 | Z/2165 | 154.4 | +0.000 | +5.163 | 150
COLUMN | C300SD/RHS200*100 | Z/2163 | 113.9 | +0.000 | +5.163 | 100
COLUMN | C300SD/RHS150*100 | Z/2161 | 93.6 | +0.000 | +5.163 | 100
COLUMN | C300SD/SHS125*125 | Z/2159 | 93.6 | +0.000 | +5.163 | 125
COLUMN | C300SD/SHS100*100 | Z/2157 | 73.4 | +0.000 | +5.163 | 100
COLUMN | C250SD/SHS100*100-SHS125*125 | Z/2094 | 79.8 | +0.000 | +5.613 | 100
COLUMN | C250SD/SHS125*125-RHS100*50 | Z/2096 | 101.8 | +0.000 | +5.613 | 125
COLUMN | C250SD/RHS150*100-RHS200*100 | Z/2098 | 101.8 | +0.000 | +5.613 | 100
COLUMN | C250SD/RHS200*100-RHS250*150 | Z/2100 | 123.8 | +0.000 | +5.613 | 100
COLUMN | C250SD/RHS200*100 | Z/2099 | 113.9 | +0.000 | +5.163 | 100
COLUMN | C250SD/RHS150*100 | Z/2097 | 93.6 | +0.000 | +5.163 | 100
COLUMN | C250SD/SHS125*125 | Z/2095 | 93.6 | +0.000 | +5.163 | 125
COLUMN | C250SD/SHS100*100 | Z/2093 | 73.4 | +0.000 | +5.163 | 100
COLUMN | C200SD/RHS150*50-RHS150*100 | Z/2039 | 81.2 | +0.000 | +5.713 | 50
COLUMN | C200SD/RHS150*50 | Z/2038 | 72.6 | +0.000 | +5.113 | 50
COLUMN | C200SD/SHS75*75-SHS100*100 | Z/2037 | 58.8 | +0.000 | +5.713 | 75
COLUMN | C200SD/SHS75*75 | Z/2036 | 52.6 | +0.000 | +5.113 | 75
COLUMN | C150SD/RHS150*50-RHS150*100 | Z/1871 | 81.2 | +0.000 | +5.713 | 50
COLUMN | C150SD/RHS150*50 | Z/1857 | 73.4 | +0.000 | +5.163 | 50
COLUMN | C150SD/RHS100*50-RHS150*50 | Z/1856 | 58.8 | +0.000 | +5.713 | 50
COLUMN | C150SD/RHS100*50 | Z/1855 | 53.1 | +0.000 | +5.163 | 50
COLUMN | C150SD/SHS75*75-SHS100*100 | Z/1854 | 58.2 | +0.000 | +5.663 | 75
COLUMN | C150SD/SHS75*75 | Z/1853 | 52.6 | +0.000 | +5.113 | 75
COLUMN | C150SD/SHS50*50-SHS75*75 | Z/1841 | 36.2 | +0.000 | +5.663 | 50
COLUMN | C150SD/SHS50*50 | Z/1840 | 32.7 | +0.000 | +5.113 | 50
RAFTER | C350SD/RHS250*150> | Z/2180 | 43.7 | +4.703 | +5.506 | 125
RAFTER | C300SD/RHS250*150> | Z/2114 | 36.9 | +4.749 | +5.507 | 96
TH | C350SD>/RHS250*150> | B/5 | 1.8 | +5.126 | +5.212 | 125
TH | C300SD-C350SD/RHS250*150> | B/5 | 1.8 | +5.122 | +5.208 | 125
PLATE |  | PL/1084 | 8.7 | +5.018 | +5.516 | 128
PLATE |  | PL/994 | 7.8 | +5.033 | +5.516 | 99
PLATE | C350SD/RHS250*150> | PL/1083 | 9 | +4.550 | +5.115 | 128
PLATE | C300SD/RHS250*150> | PL/993 | 8.3 | +4.561 | +5.111 | 99
RAFTER | C350SD/RHS200*100-RHS250*150 | Z/2232 | 44 | +4.699 | +5.506 | 125
RAFTER | C300SD/RHS200*100-RHS250*150 | Z/2126 | 37.3 | +4.745 | +5.507 | 96
RAFTER | C250SD/RHS200*100-RHS250*150 | Z/2068 | 24.1 | +4.786 | +5.508 | 76
TH | C350SD>/RHS200*100-RHS250*150 | B/5 | 1.8 | +5.126 | +5.212 | 125
TH | C300SD-C350SD/RHS200*100-RHS250*150 | B/5 | 1.8 | +5.122 | +5.208 | 125
TH | C250SD-C300SD/RHS200*100-RHS250*150 | B/5 | 1.8 | +5.118 | +5.205 | 125
PLATE | C350SD/RHS200*100-RHS250*150 | PL/1120 | 8 | +5.018 | +5.516 | 128
PLATE | C300SD/RHS200*100-RHS250*150 | PL/1030 | 7.4 | +5.033 | +5.516 | 99
PLATE | C250SD/RHS200*100-RHS250*150 | PL/949 | 4.7 | +5.148 | +5.516 | 79
PLATE | C350SD/RHS200*100-RHS250*150 | PL/1119 | 8.6 | +4.546 | +5.111 | 128
PLATE | C300SD/RHS200*100-RHS250*150 | PL/1029 | 7.7 | +4.557 | +5.107 | 99
PLATE | C250SD/RHS200*100 | PL/948 | 4.9 | +4.668 | +5.085 | 79
RAFTER | C350SD/RHS150*100-RHS200*100 | Z/2231 | 44.4 | +4.695 | +5.506 | 125
RAFTER | C300SD/RHS150*100-RHS200*100 | Z/2125 | 37.6 | +4.741 | +5.507 | 96
RAFTER | C250SD/RHS150*100-RHS200*100 | Z/2067 | 24.3 | +4.782 | +5.508 | 76
TH | C350SD>/RHS150*100-RHS200*100 | B/5 | 1.8 | +5.126 | +5.212 | 125
TH | C300SD-C350SD/RHS150*100-RHS200*100 | B/5 | 1.8 | +5.122 | +5.208 | 125
TH | C250SD-C300SD/RHS150*100-RHS200*100 | B/5 | 1.8 | +5.118 | +5.205 | 125
PLATE | C350SD/RHS150*100-RHS200*100 | PL/1118 | 7.4 | +5.018 | +5.516 | 128
PLATE | C300SD/RHS150*100-RHS200*100 | PL/1028 | 6.8 | +5.033 | +5.516 | 99
PLATE | C250SD/RHS150*100-RHS200*100 | PL/947 | 4.3 | +5.148 | +5.516 | 79
PLATE | C350SD/RHS150*100-RHS200*100 | PL/1117 | 7.8 | +4.542 | +5.107 | 128
PLATE | C300SD/RHS150*100-RHS200*100 | PL/1027 | 7.2 | +4.554 | +5.103 | 99
PLATE | C250SD/RHS150*100 | PL/946 | 4.5 | +4.664 | +5.081 | 79
RAFTER | C350SD/SHS125*125-RHS100*50 | Z/2216 | 44.6 | +4.694 | +5.506 | 125
RAFTER | C300SD/SHS125*125-RHS100*50 | Z/2117 | 37.7 | +4.739 | +5.507 | 96
RAFTER | C250SD/SHS125*125-RHS100*50 | Z/2059 | 24.4 | +4.780 | +5.508 | 76
TH | C350SD>/SHS125*125-RHS100*50 | B/5 | 1.8 | +5.126 | +5.212 | 125
TH | C300SD-C350SD/SHS125*125-RHS100*50 | B/5 | 1.8 | +5.122 | +5.208 | 125
TH | C250SD-C300SD/SHS125*125-RHS100*50 | B/5 | 1.8 | +5.118 | +5.205 | 125
PLATE | C350SD/SHS125*125-RHS100*50 | PL/1093 | 7.2 | +5.018 | +5.516 | 128
PLATE | C300SD/SHS125*125-RHS100*50 | PL/1003 | 6.5 | +5.033 | +5.516 | 99
PLATE | C250SD/SHS125*125-RHS100*50 | PL/922 | 3.9 | +5.148 | +5.516 | 79
PLATE | C350SD/SHS125*125-RHS100*50 | PL/1092 | 7.7 | +4.540 | +5.105 | 128
PLATE | C300SD/SHS125*125-RHS100*50 | PL/1002 | 6.8 | +4.552 | +5.101 | 99
PLATE | C250SD/SHS125*125 | PL/921 | 4.1 | +4.662 | +5.079 | 79
RAFTER | C350SD/SHS100*100-SHS125*125 | Z/2230 | 44.8 | +4.692 | +5.506 | 125
RAFTER | C300SD/SHS100*100-SHS125*125 | Z/2124 | 37.9 | +4.737 | +5.507 | 96
RAFTER | C250SD/SHS100*100-SHS125*125 | Z/2066 | 24.4 | +4.778 | +5.508 | 76
TH | C350SD>/SHS100*100-SHS125*125 | B/5 | 1.8 | +5.126 | +5.212 | 125
TH | C300SD-C350SD/SHS100*100-SHS125*125 | B/5 | 1.8 | +5.122 | +5.208 | 125
TH | C250SD-C300SD/SHS100*100-SHS125*125 | B/5 | 1.8 | +5.118 | +5.205 | 125
PLATE | C350SD/SHS100*100-SHS125*125 | PL/1116 | 7 | +5.013 | +5.516 | 128
PLATE | C300SD/SHS100*100-SHS125*125 | PL/1026 | 6.2 | +5.038 | +5.516 | 99
PLATE | C250SD/SHS100*100-SHS125*125 | PL/945 | 3.9 | +5.138 | +5.516 | 79
PLATE | C350SD/SHS100*100-SHS125*125 | PL/1115 | 7.4 | +4.533 | +5.103 | 128
PLATE | C300SD/SHS100*100-SHS125*125 | PL/1025 | 6.5 | +4.555 | +5.099 | 99
PLATE | C250SD/SHS100*100 | PL/944 | 4.1 | +4.650 | +5.077 | 79
RAFTER | C200SD/RHS150*50-RHS150*100 | Z/2047 | 21.8 | +4.829 | +5.509 | 76
TH | C200SD-C250SD/RHS150*50-RHS150*100 | B/5 | 1.8 | +5.114 | +5.201 | 125
PLATE | C200SD/RHS150*50-RHS150*100 | PL/895 | 2.7 | +5.248 | +5.516 | 79
PLATE | C200SD/RHS150*50 | PL/894 | 2.8 | +4.760 | +5.064 | 79
RAFTER | C200SD/SHS75*75-SHS100*100 | Z/2044 | 22 | +4.823 | +5.509 | 76
TH | C200SD-C250SD/SHS75*75-SHS100*100 | B/5 | 1.8 | +5.114 | +5.201 | 125
PLATE | C200SD/SHS75*75-SHS100*100 | PL/886 | 2.2 | +5.243 | +5.516 | 79
PLATE | C200SD/SHS75*75 | PL/885 | 2.4 | +4.749 | +5.058 | 79
RAFTER | C150SD/RHS150*50-RHS150*100 | Z/2020 | 17.3 | +4.875 | +5.511 | 64
TH | C150SD-C200SD/RHS150*50-RHS150*100 | B/5 | 1.8 | +5.111 | +5.197 | 125
PLATE | C150SD/RHS150*50-RHS150*100 | PL/841 | 2.4 | +5.258 | +5.516 | 67
PLATE | C150SD/RHS150*50 | PL/840 | 2.4 | +4.767 | +5.060 | 67
RAFTER | C150SD/RHS100*50-RHS150*50 | Z/2019 | 17.4 | +4.871 | +5.511 | 64
TH | C150SD-C200SD/RHS100*50-RHS150*50 | B/5 | 1.8 | +5.111 | +5.197 | 125
PLATE | C150SD/RHS100*50-RHS150*50 | PL/839 | 2.1 | +5.258 | +5.516 | 67
PLATE | C150SD/RHS100*50 | PL/838 | 2.2 | +4.763 | +5.056 | 67
RAFTER | C150SD/SHS75*75-SHS100*100 | Z/1778 | 17.4 | +4.869 | +5.511 | 64
TH | C150SD-C200SD/SHS75*75-SHS100*100 | B/5 | 1.8 | +5.111 | +5.197 | 125
PLATE | C150SD/SHS75*75-SHS100*100 | PL/774 | 1.9 | +5.258 | +5.516 | 67
PLATE | C150SD/SHS75*75 | PL/773 | 2.1 | +4.761 | +5.054 | 67
COLUMN | C350SD/SHS100*100-SHS125*125 | Z/2203 | 77.6 | +0.000 | +5.463 | 100
COLUMN | C350SD/SHS125*125-RHS100*50 | Z/2206 | 99.1 | +0.000 | +5.463 | 125
COLUMN | C350SD/RHS150*100-RHS200*100 | Z/2208 | 99.1 | +0.000 | +5.463 | 100
COLUMN | C350SD/RHS200*100-RHS250*150 | Z/2210 | 120.5 | +0.000 | +5.463 | 100
COLUMN | C350SD/RHS250*150 | Z/2211 | 155.6 | +0.000 | +5.203 | 150
COLUMN | C350SD/RHS200*100 | Z/2209 | 113.9 | +0.000 | +5.163 | 100
COLUMN | C350SD/RHS150*100 | Z/2207 | 93.6 | +0.000 | +5.163 | 100
COLUMN | C350SD/SHS125*125 | Z/2204 | 93.6 | +0.000 | +5.163 | 125
COLUMN | C350SD/SHS100*100 | Z/2202 | 73.4 | +0.000 | +5.163 | 100
COLUMN | C300SD/SHS100*100-SHS125*125 | Z/2148 | 77.6 | +0.000 | +5.463 | 100
COLUMN | C300SD/SHS125*125-RHS100*50 | Z/2150 | 99.1 | +0.000 | +5.463 | 125
COLUMN | C300SD/RHS150*100-RHS200*100 | Z/2152 | 99.1 | +0.000 | +5.463 | 100
COLUMN | C300SD/RHS200*100-RHS250*150 | Z/2154 | 120.5 | +0.000 | +5.463 | 100
COLUMN | C300SD/RHS250*150 | Z/2155 | 154.4 | +0.000 | +5.163 | 150
COLUMN | C300SD/RHS200*100 | Z/2153 | 113.9 | +0.000 | +5.163 | 100
COLUMN | C300SD/RHS150*100 | Z/2151 | 93.6 | +0.000 | +5.163 | 100
COLUMN | C300SD/SHS125*125 | Z/2149 | 93.6 | +0.000 | +5.163 | 125
COLUMN | C300SD/SHS100*100 | Z/2147 | 73.4 | +0.000 | +5.163 | 100
COLUMN | C250SD/SHS125*125-RHS100*50 | Z/2088 | 100 | +0.000 | +5.513 | 125
COLUMN | C250SD/SHS100*100-SHS125*125 | Z/2086 | 78.3 | +0.000 | +5.513 | 100
COLUMN | C250SD/RHS150*100-RHS200*100 | Z/2090 | 100 | +0.000 | +5.513 | 100
COLUMN | C250SD/RHS200*100-RHS250*150 | Z/2092 | 121.6 | +0.000 | +5.513 | 100
COLUMN | C250SD/RHS200*100 | Z/2091 | 113.9 | +0.000 | +5.163 | 100
COLUMN | C250SD/RHS150*100 | Z/2089 | 93.6 | +0.000 | +5.163 | 100
COLUMN | C250SD/SHS125*125 | Z/2087 | 93.6 | +0.000 | +5.163 | 125
COLUMN | C250SD/SHS100*100 | Z/2085 | 73.4 | +0.000 | +5.163 | 100
COLUMN | C200SD/SHS75*75-SHS100*100 | Z/2033 | 56.2 | +0.000 | +5.463 | 75
COLUMN | C200SD/RHS150*50-RHS150*100 | Z/2035 | 77.6 | +0.000 | +5.463 | 50
COLUMN | C200SD/RHS150*50 | Z/2034 | 72.6 | +0.000 | +5.113 | 50
COLUMN | C200SD/SHS75*75 | Z/2032 | 52.6 | +0.000 | +5.113 | 75
COLUMN | C150SD/SHS50*50-SHS75*75 | Z/1817 | 34.3 | +0.000 | +5.363 | 50
COLUMN | C150SD/SHS75*75-SHS100*100 | Z/1831 | 55.2 | +0.000 | +5.363 | 75
COLUMN | C150SD/RHS100*50-RHS150*50 | Z/1837 | 55.7 | +0.000 | +5.413 | 50
COLUMN | C150SD/RHS150*50-RHS150*100 | Z/1839 | 76.9 | +0.000 | +5.413 | 50
COLUMN | C150SD/RHS150*50 | Z/1838 | 73.4 | +0.000 | +5.163 | 50
COLUMN | C150SD/RHS100*50 | Z/1832 | 53.1 | +0.000 | +5.163 | 50
COLUMN | C150SD/SHS75*75 | Z/1826 | 52.6 | +0.000 | +5.113 | 75
COLUMN | C150SD/SHS50*50 | Z/1816 | 32.7 | +0.000 | +5.113 | 50
RAFTER | C350SD/RHS250*150> | Z/2179 | 43 | +4.678 | +5.278 | 125
RAFTER | C300SD/RHS250*150> | Z/2113 | 36.4 | +4.726 | +5.278 | 96
TH | C350SD>/RHS250*150> | B/5 | 1.8 | +5.073 | +5.155 | 125
TH | C300SD-C350SD/RHS250*150> | B/5 | 1.8 | +5.071 | +5.153 | 125
PLATE |  | PL/1079 | 8.6 | +4.784 | +5.282 | 128
PLATE |  | PL/992 | 7.8 | +4.799 | +5.282 | 99
PLATE | C350SD/RHS250*150> | PL/1078 | 8.7 | +4.529 | +5.064 | 128
PLATE | C300SD/RHS250*150> | PL/991 | 8 | +4.542 | +5.062 | 99
RAFTER | C350SD/RHS200*100-RHS250*150 | Z/2229 | 43.4 | +4.676 | +5.278 | 125
RAFTER | C300SD/RHS200*100-RHS250*150 | Z/2123 | 36.7 | +4.724 | +5.278 | 96
RAFTER | C250SD/RHS200*100-RHS250*150 | Z/2065 | 23.8 | +4.767 | +5.278 | 76
TH | C350SD>/RHS200*100-RHS250*150 | B/5 | 1.8 | +5.073 | +5.155 | 125
TH | C300SD-C350SD/RHS200*100-RHS250*150 | B/5 | 1.8 | +5.071 | +5.153 | 125
TH | C250SD-C300SD/RHS200*100-RHS250*150 | B/5 | 1.8 | +5.069 | +5.150 | 125
PLATE | C350SD/RHS200*100-RHS250*150 | PL/1105 | 8 | +4.784 | +5.282 | 128
PLATE | C250SD/RHS200*100-RHS250*150 | PL/934 | 4.7 | +4.913 | +5.281 | 79
PLATE | C300SD/RHS200*100-RHS250*150 | PL/1024 | 7.4 | +4.799 | +5.282 | 99
PLATE | C350SD/RHS200*100-RHS250*150 | PL/1104 | 8.3 | +4.527 | +5.062 | 128
PLATE | C300SD/RHS200*100-RHS250*150 | PL/1023 | 7.4 | +4.540 | +5.059 | 99
PLATE | C250SD/RHS200*100 | PL/933 | 4.9 | +4.652 | +5.047 | 79
RAFTER | C350SD/RHS150*100-RHS200*100 | Z/2228 | 43.8 | +4.674 | +5.278 | 125
RAFTER | C300SD/RHS150*100-RHS200*100 | Z/2122 | 37 | +4.722 | +5.278 | 96
RAFTER | C250SD/RHS150*100-RHS200*100 | Z/2064 | 24 | +4.765 | +5.278 | 76
TH | C350SD>/RHS150*100-RHS200*100 | B/5 | 1.8 | +5.073 | +5.155 | 125
TH | C300SD-C350SD/RHS150*100-RHS200*100 | B/5 | 1.8 | +5.071 | +5.153 | 125
TH | C250SD-C300SD/RHS150*100-RHS200*100 | B/5 | 1.8 | +5.069 | +5.150 | 125
PLATE | C350SD/RHS150*100-RHS200*100 | PL/1103 | 7.4 | +4.784 | +5.282 | 128
PLATE | C250SD/RHS150*100-RHS200*100 | PL/932 | 4.1 | +4.913 | +5.281 | 79
PLATE | C300SD/RHS150*100-RHS200*100 | PL/1022 | 6.8 | +4.799 | +5.282 | 99
PLATE | C350SD/RHS150*100-RHS200*100 | PL/1102 | 7.7 | +4.524 | +5.059 | 128
PLATE | C300SD/RHS150*100-RHS200*100 | PL/1021 | 7 | +4.537 | +5.057 | 99
PLATE | C250SD/RHS150*100 | PL/931 | 4.3 | +4.650 | +5.045 | 79
RAFTER | C350SD/SHS125*125-RHS100*50 | Z/2205 | 44 | +4.673 | +5.278 | 125
RAFTER | C300SD/SHS125*125-RHS100*50 | Z/2116 | 37.2 | +4.721 | +5.278 | 96
RAFTER | C250SD/SHS125*125-RHS100*50 | Z/2058 | 24.1 | +4.764 | +5.278 | 76
TH | C350SD>/SHS125*125-RHS100*50 | B/5 | 1.8 | +5.073 | +5.155 | 125
TH | C300SD-C350SD/SHS125*125-RHS100*50 | B/5 | 1.8 | +5.071 | +5.153 | 125
TH | C250SD-C300SD/SHS125*125-RHS100*50 | B/5 | 1.8 | +5.069 | +5.150 | 125
PLATE | C350SD/SHS125*125-RHS100*50 | PL/1088 | 7.2 | +4.784 | +5.282 | 128
PLATE | C250SD/SHS125*125-RHS100*50 | PL/917 | 3.9 | +4.913 | +5.281 | 79
PLATE | C300SD/SHS125*125-RHS100*50 | PL/1001 | 6.5 | +4.799 | +5.282 | 99
PLATE | C350SD/SHS125*125-RHS100*50 | PL/1087 | 7.4 | +4.523 | +5.058 | 128
PLATE | C300SD/SHS125*125-RHS100*50 | PL/1000 | 6.6 | +4.536 | +5.056 | 99
PLATE | C250SD/SHS125*125 | PL/916 | 4.1 | +4.649 | +5.044 | 79
RAFTER | C350SD/SHS100*100-SHS125*125 | Z/2227 | 44.2 | +4.672 | +5.278 | 125
RAFTER | C300SD/SHS100*100-SHS125*125 | Z/2121 | 37.3 | +4.720 | +5.278 | 96
RAFTER | C250SD/SHS100*100-SHS125*125 | Z/2063 | 24.3 | +4.763 | +5.278 | 76
TH | C350SD>/SHS100*100-SHS125*125 | B/5 | 1.8 | +5.073 | +5.155 | 125
TH | C300SD-C350SD/SHS100*100-SHS125*125 | B/5 | 1.8 | +5.071 | +5.153 | 125
TH | C250SD-C300SD/SHS100*100-SHS125*125 | B/5 | 1.8 | +5.069 | +5.150 | 125
PLATE | C350SD/SHS100*100-SHS125*125 | PL/1101 | 6.8 | +4.779 | +5.282 | 128
PLATE | C250SD/SHS100*100-SHS125*125 | PL/930 | 3.9 | +4.903 | +5.281 | 79
PLATE | C300SD/SHS100*100-SHS125*125 | PL/1020 | 6.2 | +4.804 | +5.282 | 99
PLATE | C350SD/SHS100*100-SHS125*125 | PL/1100 | 7.2 | +4.517 | +5.057 | 128
PLATE | C300SD/SHS100*100-SHS125*125 | PL/1019 | 6.3 | +4.540 | +5.055 | 99
PLATE | C250SD/SHS100*100 | PL/929 | 3.9 | +4.638 | +5.043 | 79
RAFTER | C200SD/RHS150*50-RHS150*100 | Z/2046 | 21.4 | +4.814 | +5.279 | 76
TH | C200SD-C250SD/RHS150*50-RHS150*100 | B/5 | 1.8 | +5.067 | +5.149 | 125
PLATE | C200SD/RHS150*50-RHS150*100 | PL/893 | 2.7 | +5.013 | +5.281 | 79
PLATE | C200SD/RHS150*50 | PL/892 | 2.7 | +4.747 | +5.035 | 79
RAFTER | C200SD/SHS75*75-SHS100*100 | Z/2043 | 21.6 | +4.810 | +5.279 | 76
TH | C200SD-C250SD/SHS75*75-SHS100*100 | B/5 | 1.8 | +5.067 | +5.149 | 125
PLATE | C200SD/SHS75*75-SHS100*100 | PL/884 | 2.2 | +5.008 | +5.281 | 79
PLATE | C200SD/SHS75*75 | PL/883 | 2.3 | +4.739 | +5.032 | 79
RAFTER | C150SD/RHS150*50-RHS150*100 | Z/2008 | 17 | +4.862 | +5.279 | 64
RAFTER | C150SD/RHS100*50-RHS150*50 | Z/2004 | 17.1 | +4.860 | +5.279 | 64
TH | C150SD-C200SD/RHS150*50-RHS150*100 | B/5 | 1.8 | +5.065 | +5.146 | 125
PLATE | C150SD/RHS150*50-RHS150*100 | PL/835 | 2.4 | +5.024 | +5.281 | 67
PLATE | C150SD/RHS150*50 | PL/834 | 2.4 | +4.756 | +5.033 | 67
TH | C150SD-C200SD/RHS100*50-RHS150*50 | B/5 | 1.8 | +5.065 | +5.146 | 125
PLATE | C150SD/RHS100*50-RHS150*50 | PL/833 | 2.1 | +5.024 | +5.281 | 67
PLATE | C150SD/RHS100*50 | PL/832 | 2.2 | +4.754 | +5.031 | 67
RAFTER | C150SD/SHS75*75-SHS100*100 | Z/1777 | 17.1 | +4.859 | +5.279 | 64
TH | C150SD-C200SD/SHS75*75-SHS100*100 | B/5 | 1.8 | +5.065 | +5.146 | 125
PLATE | C150SD/SHS75*75-SHS100*100 | PL/772 | 1.9 | +5.024 | +5.281 | 67
PLATE | C150SD/SHS75*75 | PL/771 | 1.9 | +4.752 | +5.030 | 67
COLUMN | C350SD/RHS250*150 | Z/2200 | 155.6 | +0.000 | +5.203 | 150
COLUMN | C350SD/RHS200*100-RHS250*150 | Z/2199 | 122.7 | +0.000 | +5.563 | 100
COLUMN | C350SD/RHS200*100 | Z/2198 | 113.9 | +0.000 | +5.163 | 100
COLUMN | C350SD/RHS150*100-RHS200*100 | Z/2197 | 100.9 | +0.000 | +5.563 | 100
COLUMN | C350SD/RHS150*100 | Z/2196 | 93.6 | +0.000 | +5.163 | 100
COLUMN | C350SD/SHS125*125-RHS100*50 | Z/2195 | 100.9 | +0.000 | +5.563 | 125
COLUMN | C350SD/SHS125*125 | Z/2193 | 93.6 | +0.000 | +5.163 | 125
COLUMN | C350SD/SHS100*100-SHS125*125 | Z/2192 | 79 | +0.000 | +5.563 | 100
COLUMN | C350SD/SHS100*100 | Z/2191 | 73.4 | +0.000 | +5.163 | 100
COLUMN | C300SD/RHS250*150 | Z/2145 | 154.4 | +0.000 | +5.163 | 150
COLUMN | C300SD/RHS200*100-RHS250*150 | Z/2144 | 116.1 | +0.000 | +5.263 | 100
COLUMN | C300SD/RHS200*100 | Z/2143 | 113.9 | +0.000 | +5.163 | 100
COLUMN | C300SD/RHS150*100-RHS200*100 | Z/2142 | 95.4 | +0.000 | +5.263 | 100
COLUMN | C300SD/RHS150*100 | Z/2141 | 93.6 | +0.000 | +5.163 | 100
COLUMN | C300SD/SHS125*125-RHS100*50 | Z/2140 | 95.4 | +0.000 | +5.263 | 125
COLUMN | C300SD/SHS125*125 | Z/2139 | 93.6 | +0.000 | +5.163 | 125
COLUMN | C300SD/SHS100*100-SHS125*125 | Z/2138 | 74.8 | +0.000 | +5.263 | 100
COLUMN | C300SD/SHS100*100 | Z/2137 | 73.4 | +0.000 | +5.163 | 100
COLUMN | C250SD/RHS200*100-RHS250*150 | Z/2084 | 115 | +0.000 | +5.213 | 100
COLUMN | C250SD/RHS200*100 | Z/2083 | 113.9 | +0.000 | +5.163 | 100
COLUMN | C250SD/RHS150*100-RHS200*100 | Z/2082 | 94.5 | +0.000 | +5.213 | 100
COLUMN | C250SD/RHS150*100 | Z/2081 | 93.6 | +0.000 | +5.163 | 100
COLUMN | C250SD/SHS125*125-RHS100*50 | Z/2080 | 94.5 | +0.000 | +5.213 | 125
COLUMN | C250SD/SHS125*125 | Z/2079 | 93.6 | +0.000 | +5.163 | 125
COLUMN | C250SD/SHS100*100-SHS125*125 | Z/2078 | 74.1 | +0.000 | +5.213 | 100
COLUMN | C250SD/SHS100*100 | Z/2077 | 73.4 | +0.000 | +5.163 | 100
COLUMN | C200SD/RHS150*50-RHS150*100 | Z/2031 | 75 | +0.000 | +5.280 | 50
COLUMN | C200SD/RHS150*50 | Z/2030 | 72.6 | +0.000 | +5.113 | 50
COLUMN | C200SD/SHS75*75-SHS100*100 | Z/2029 | 54.3 | +0.000 | +5.280 | 75
COLUMN | C200SD/SHS75*75 | Z/2028 | 52.6 | +0.000 | +5.113 | 75
COLUMN | C150SD/RHS150*50-RHS150*100 | Z/1815 | 75.5 | +0.000 | +5.313 | 50
COLUMN | C150SD/RHS150*50 | Z/1814 | 73.4 | +0.000 | +5.163 | 50
COLUMN | C150SD/RHS100*50-RHS150*50 | Z/1813 | 54.6 | +0.000 | +5.313 | 50
COLUMN | C150SD/RHS100*50 | Z/1812 | 53.1 | +0.000 | +5.163 | 50
COLUMN | C150SD/SHS75*75-SHS100*100 | Z/1803 | 54.1 | +0.000 | +5.263 | 75
COLUMN | C150SD/SHS75*75 | Z/1802 | 52.6 | +0.000 | +5.113 | 75
COLUMN | C150SD/SHS50*50-SHS75*75 | Z/1801 | 33.6 | +0.000 | +5.263 | 50
COLUMN | C150SD/SHS50*50 | Z/1800 | 32.7 | +0.000 | +5.113 | 50
RAFTER | C350SD/RHS250*150> | Z/2178 | 43 | +4.667 | +5.167 | 125
RAFTER | C300SD/RHS250*150> | Z/2112 | 36.4 | +4.715 | +5.167 | 96
TH | C350SD>/RHS250*150> | B/5 | 1.8 | +5.041 | +5.120 | 125
TH | C300SD-C350SD/RHS250*150> | B/5 | 1.8 | +5.039 | +5.118 | 125
PLATE |  | PL/990 | 7.8 | +4.685 | +5.168 | 99
PLATE | C300SD/RHS250*150> | PL/989 | 8 | +4.532 | +5.037 | 99
PLATE |  | PL/1077 | 8.6 | +4.670 | +5.168 | 128
PLATE | C350SD/RHS250*150> | PL/1076 | 8.7 | +4.518 | +5.038 | 128
RAFTER | C350SD/RHS200*100-RHS250*150 | Z/2226 | 43.3 | +4.665 | +5.167 | 125
RAFTER | C300SD/RHS200*100-RHS250*150 | Z/2120 | 36.6 | +4.714 | +5.167 | 96
TH | C350SD>/RHS200*100-RHS250*150 | B/5 | 1.8 | +5.041 | +5.120 | 125
TH | C300SD-C350SD/RHS200*100-RHS250*150 | B/5 | 1.8 | +5.039 | +5.118 | 125
PLATE | C300SD/RHS200*100-RHS250*150 | PL/1018 | 7.4 | +4.685 | +5.168 | 99
PLATE | C300SD/RHS200*100-RHS250*150 | PL/1017 | 7.4 | +4.531 | +5.036 | 99
PLATE | C350SD/RHS200*100-RHS250*150 | PL/1099 | 8 | +4.670 | +5.168 | 128
PLATE | C350SD/RHS200*100-RHS250*150 | PL/1098 | 8 | +4.517 | +5.037 | 128
RAFTER | C350SD/RHS150*100-RHS200*100 | Z/2225 | 43.7 | +4.664 | +5.167 | 125
RAFTER | C300SD/RHS150*100-RHS200*100 | Z/2119 | 36.9 | +4.713 | +5.167 | 96
TH | C350SD>/RHS150*100-RHS200*100 | B/5 | 1.8 | +5.041 | +5.120 | 125
TH | C300SD-C350SD/RHS150*100-RHS200*100 | B/5 | 1.8 | +5.039 | +5.118 | 125
PLATE | C300SD/RHS150*100-RHS200*100 | PL/1016 | 6.8 | +4.685 | +5.168 | 99
PLATE | C300SD/RHS150*100-RHS200*100 | PL/1015 | 6.8 | +4.529 | +5.034 | 99
PLATE | C350SD/RHS150*100-RHS200*100 | PL/1097 | 7.4 | +4.670 | +5.168 | 128
PLATE | C350SD/RHS150*100-RHS200*100 | PL/1096 | 7.7 | +4.516 | +5.036 | 128
RAFTER | C350SD/SHS125*125-RHS100*50 | Z/2194 | 44 | +4.663 | +5.167 | 125
RAFTER | C300SD/SHS125*125-RHS100*50 | Z/2115 | 37 | +4.712 | +5.167 | 96
TH | C350SD>/SHS125*125-RHS100*50 | B/5 | 1.8 | +5.041 | +5.120 | 125
TH | C300SD-C350SD/SHS125*125-RHS100*50 | B/5 | 1.8 | +5.039 | +5.118 | 125
PLATE | C300SD/SHS125*125-RHS100*50 | PL/999 | 6.5 | +4.685 | +5.168 | 99
PLATE | C300SD/SHS125*125-RHS100*50 | PL/998 | 6.6 | +4.529 | +5.034 | 99
PLATE | C350SD/SHS125*125-RHS100*50 | PL/1086 | 7.2 | +4.670 | +5.168 | 128
PLATE | C350SD/SHS125*125-RHS100*50 | PL/1085 | 7.4 | +4.515 | +5.035 | 128
RAFTER | C350SD/SHS100*100-SHS125*125 | Z/2224 | 44.1 | +4.663 | +5.167 | 125
RAFTER | C300SD/SHS100*100-SHS125*125 | Z/2118 | 37.2 | +4.711 | +5.167 | 96
TH | C350SD>/SHS100*100-SHS125*125 | B/5 | 1.8 | +5.041 | +5.120 | 125
TH | C300SD-C350SD/SHS100*100-SHS125*125 | B/5 | 1.8 | +5.039 | +5.118 | 125
PLATE | C300SD/SHS100*100-SHS125*125 | PL/1014 | 6.2 | +4.690 | +5.168 | 99
PLATE | C300SD/SHS100*100 | PL/1013 | 6.3 | +4.533 | +5.033 | 99
PLATE | C350SD/SHS100*100-SHS125*125 | PL/1095 | 6.8 | +4.665 | +5.168 | 128
PLATE | C350SD/SHS100*100-SHS125*125 | PL/1094 | 7 | +4.509 | +5.034 | 128
PLATE | C250SD/RHS200*100-RHS250*150 | PL/928 | 4.7 | +4.800 | +5.168 | 79
PLATE | C250SD/RHS200*100 | PL/927 | 4.7 | +4.644 | +5.028 | 79
TH | C250SD-C300SD/RHS200*100-RHS250*150 | B/5 | 1.8 | +5.038 | +5.117 | 125
RAFTER | C250SD/RHS200*100-RHS250*150 | Z/2062 | 23.8 | +4.758 | +5.166 | 76
PLATE | C250SD/RHS150*100-RHS200*100 | PL/926 | 4.1 | +4.800 | +5.168 | 79
PLATE | C250SD/RHS150*100 | PL/925 | 4.3 | +4.643 | +5.027 | 79
TH | C250SD-C300SD/RHS150*100-RHS200*100 | B/5 | 1.8 | +5.038 | +5.117 | 125
RAFTER | C250SD/RHS150*100-RHS200*100 | Z/2061 | 24 | +4.757 | +5.166 | 76
PLATE | C250SD/SHS125*125-RHS100*50 | PL/915 | 3.9 | +4.800 | +5.168 | 79
PLATE | C250SD/SHS125*125 | PL/914 | 4.1 | +4.642 | +5.026 | 79
TH | C250SD-C300SD/SHS125*125-RHS100*50 | B/5 | 1.8 | +5.038 | +5.117 | 125
RAFTER | C250SD/SHS125*125-RHS100*50 | Z/2057 | 24 | +4.756 | +5.166 | 76
PLATE | C250SD/SHS100*100-SHS125*125 | PL/924 | 3.9 | +4.790 | +5.168 | 79
PLATE | C250SD/SHS100*100 | PL/923 | 3.9 | +4.631 | +5.025 | 79
TH | C250SD-C300SD/SHS100*100-SHS125*125 | B/5 | 1.8 | +5.038 | +5.117 | 125
RAFTER | C250SD/SHS100*100-SHS125*125 | Z/2060 | 24.1 | +4.756 | +5.166 | 76
RAFTER | C200SD/RHS150*50-RHS150*100 | Z/2045 | 21.3 | +4.807 | +5.167 | 76
TH | C200SD-C250SD/RHS150*50-RHS150*100 | B/5 | 1.8 | +5.037 | +5.116 | 125
PLATE | C200SD/RHS150*50-RHS150*100 | PL/888 | 2.6 | +4.900 | +5.168 | 79
PLATE | C200SD/RHS150*50 | PL/887 | 2.7 | +4.741 | +5.021 | 79
RAFTER | C200SD/SHS75*75-SHS100*100 | Z/2042 | 21.6 | +4.805 | +5.167 | 76
TH | C200SD-C250SD/SHS75*75-SHS100*100 | B/5 | 1.8 | +5.037 | +5.116 | 125
PLATE | C200SD/SHS75*75-SHS100*100 | PL/879 | 2.2 | +4.895 | +5.168 | 79
PLATE | C200SD/SHS75*75 | PL/878 | 2.3 | +4.734 | +5.019 | 79
RAFTER | C150SD/RHS150*50-RHS150*100 | Z/1874 | 17 | +4.856 | +5.167 | 64
RAFTER | C150SD/RHS100*50-RHS150*50 | Z/1873 | 17 | +4.855 | +5.167 | 64
TH | C150SD-C200SD/RHS150*50-RHS150*100 | B/5 | 1.8 | +5.035 | +5.114 | 125
PLATE | C150SD/RHS150*50-RHS150*100 | PL/816 | 2.4 | +4.910 | +5.168 | 67
PLATE | C150SD/RHS150*50 | PL/815 | 2.4 | +4.750 | +5.020 | 67
TH | C150SD-C200SD/RHS100*50-RHS150*50 | B/5 | 1.8 | +5.035 | +5.114 | 125
PLATE | C150SD/RHS100*50-RHS150*50 | PL/814 | 2.1 | +4.910 | +5.168 | 67
PLATE | C150SD/RHS100*50 | PL/777 | 2.1 | +4.749 | +5.018 | 67
RAFTER | C150SD/SHS75*75-SHS100*100 | Z/1776 | 17.1 | +4.854 | +5.167 | 64
TH | C150SD-C200SD/SHS75*75-SHS100*100 | B/5 | 1.8 | +5.035 | +5.114 | 125
PLATE | C150SD/SHS75*75-SHS100*100 | PL/767 | 1.9 | +4.910 | +5.168 | 67
PLATE | C150SD/SHS75*75 | PL/766 | 1.9 | +4.748 | +5.018 | 67
RAFTER | C150SD/SHS50*50-SHS75*75 | Z/1775 | 4.9 | +4.362 | +4.691 | 64
PLATE | C150SD/SHS50*50-SHS75*75 | PL/818 | 1.8 | +4.442 | +4.700 | 67
TH | C150SD-C200SD/SHS50*50-SHS75*75 | B/5 | 1.8 | +4.523 | +4.614 | 125
RAFTER | C150SD/SHS50*50-SHS75*75 | Z/2018 | 17.6 | +4.867 | +5.511 | 64
TH | C150SD-C200SD/SHS50*50-SHS75*75 | B/5 | 1.8 | +5.111 | +5.197 | 125
PLATE | C150SD/SHS50*50-SHS75*75 | PL/837 | 1.8 | +5.258 | +5.516 | 67
PLATE | C150SD/SHS50*50 | PL/836 | 1.9 | +4.759 | +5.052 | 67
RAFTER | C150SD/SHS50*50-SHS75*75 | Z/1875 | 17.3 | +4.858 | +5.279 | 64
TH | C150SD-C200SD/SHS50*50-SHS75*75 | B/5 | 1.8 | +5.065 | +5.146 | 125
2 x THROUGH BOLTS | C250SD/SHS75*75-SHS100*100 | Z/65 | 0.2 | -0.119 | +0.031 | 16
PLATE | C150SD/SHS50*50-SHS75*75 | PL/831 | 1.8 | +5.024 | +5.281 | 67
PLATE | C150SD/SHS50*50 | PL/830 | 1.9 | +4.751 | +5.029 | 67
RAFTER | C150SD/SHS50*50-SHS75*75 | Z/1872 | 17.1 | +4.854 | +5.167 | 64
TH | C150SD-C200SD/SHS50*50-SHS75*75 | B/5 | 1.8 | +5.035 | +5.114 | 125
PLATE | C150SD/SHS50*50-SHS75*75 | PL/776 | 1.8 | +4.910 | +5.168 | 67
PLATE | C150SD/SHS50*50 | PL/775 | 1.8 | +4.748 | +5.017 | 67
COLUMN | C350SD/RHS250*150 | Z/2190 | 155.6 | +0.000 | +5.203 | 150
COLUMN | C350SD/RHS200*100 | Z/2189 | 113.9 | +0.000 | +5.163 | 100
COLUMN | C350SD/RHS150*100 | Z/2188 | 93.6 | +0.000 | +5.163 | 100
COLUMN | C350SD/SHS125*125 | Z/2187 | 93.6 | +0.000 | +5.163 | 125
COLUMN | C350SD/SHS100*100 | Z/2186 | 73.4 | +0.000 | +5.163 | 100
COLUMN | C300SD/RHS250*150 | Z/2136 | 154.4 | +0.000 | +5.163 | 150
COLUMN | C300SD/RHS200*100 | Z/2135 | 113.9 | +0.000 | +5.163 | 100
COLUMN | C300SD/RHS150*100 | Z/2134 | 93.6 | +0.000 | +5.163 | 100
COLUMN | C300SD/SHS125*125 | Z/2133 | 93.6 | +0.000 | +5.163 | 125
COLUMN | C300SD/SHS100*100 | Z/2132 | 73.4 | +0.000 | +5.163 | 100
COLUMN | C250SD/RHS200*100 | Z/2076 | 113.9 | +0.000 | +5.163 | 100
COLUMN | C250SD/RHS150*100 | Z/2075 | 93.6 | +0.000 | +5.163 | 100
COLUMN | C250SD/SHS125*125 | Z/2074 | 93.6 | +0.000 | +5.163 | 125
COLUMN | C250SD/SHS100*100 | Z/2073 | 73.4 | +0.000 | +5.163 | 100
COLUMN | C200SD/RHS150*50 | Z/2027 | 72.6 | +0.000 | +5.113 | 50
COLUMN | C200SD/SHS75*75 | Z/2026 | 52.6 | +0.000 | +5.113 | 75
COLUMN | C150SD/RHS150*50 | Z/1799 | 73.4 | +0.000 | +5.163 | 50
COLUMN | C150SD/RHS100*50 | Z/1798 | 53.1 | +0.000 | +5.163 | 50
COLUMN | C150SD/SHS75*75 | Z/1790 | 52.6 | +0.000 | +5.113 | 75
COLUMN | C150SD/SHS50*50 | Z/1789 | 32.7 | +0.000 | +5.113 | 50
RAFTER | C350SD/RHS250*150> | Z/2177 | 11.5 | +4.827 | +5.471 | 125
RAFTER | C300SD/RHS250*150> | Z/2111 | 10.3 | +4.861 | +5.480 | 96
TH | C350SD>/RHS250*150> | B/5 | 1.8 | +5.407 | +5.509 | 125
TH | C300SD-C350SD/RHS250*150> | B/5 | 1.8 | +5.409 | +5.511 | 125
PLATE | C350SD/RHS250*150> | PL/1227 | 9.8 | +4.643 | +5.322 | 128
PLATE | C300SD/RHS250*150> | PL/1207 | 8.7 | +4.647 | +5.310 | 99
RAFTER | C350SD/RHS200*100-RHS250*150 | Z/2177 | 11.5 | +4.816 | +5.459 | 125
RAFTER | C300SD/RHS200*100-RHS250*150 | Z/2111 | 10.3 | +4.849 | +5.469 | 96
RAFTER | C250SD/RHS200*100-RHS250*150 | Z/2056 | 7 | +4.880 | +5.477 | 76
TH | C350SD>/RHS200*100-RHS250*150 | B/5 | 1.8 | +5.396 | +5.498 | 125
TH | C300SD-C350SD/RHS200*100-RHS250*150 | B/5 | 1.8 | +5.398 | +5.500 | 125
TH | C250SD-C300SD/RHS200*100-RHS250*150 | B/5 | 1.8 | +5.399 | +5.501 | 125
PLATE | C350SD/RHS200*100-RHS250*150 | PL/1235 | 9.2 | +4.632 | +5.310 | 128
PLATE | C300SD/RHS200*100-RHS250*150 | PL/1215 | 8.3 | +4.635 | +5.299 | 99
PLATE | C250SD/RHS200*100-RHS250*150 | PL/1197 | 5.2 | +4.739 | +5.239 | 79
RAFTER | C350SD/RHS150*100-RHS200*100 | Z/2177 | 11.5 | +4.804 | +5.447 | 125
RAFTER | C300SD/RHS150*100-RHS200*100 | Z/2111 | 10.3 | +4.838 | +5.457 | 96
RAFTER | C250SD/RHS150*100-RHS200*100 | Z/2056 | 7 | +4.868 | +5.466 | 76
TH | C350SD>/RHS150*100-RHS200*100 | B/5 | 1.8 | +5.384 | +5.486 | 125
TH | C300SD-C350SD/RHS150*100-RHS200*100 | B/5 | 1.8 | +5.386 | +5.488 | 125
TH | C250SD-C300SD/RHS150*100-RHS200*100 | B/5 | 1.8 | +5.388 | +5.490 | 125
PLATE | C350SD/RHS150*100-RHS200*100 | PL/1234 | 8.6 | +4.620 | +5.299 | 128
PLATE | C300SD/RHS150*100-RHS200*100 | PL/1214 | 7.7 | +4.623 | +5.287 | 99
PLATE | C250SD/RHS150*100 | PL/1196 | 4.9 | +4.727 | +5.227 | 79
RAFTER | C350SD/SHS125*125-RHS100*50 | Z/2177 | 11.5 | +4.798 | +5.441 | 125
RAFTER | C300SD/SHS125*125-RHS100*50 | Z/2111 | 10.3 | +4.832 | +5.451 | 96
RAFTER | C250SD/SHS125*125-RHS100*50 | Z/2056 | 7 | +4.862 | +5.460 | 76
TH | C350SD>/SHS125*125-RHS100*50 | B/5 | 1.8 | +5.378 | +5.480 | 125
TH | C300SD-C350SD/SHS125*125-RHS100*50 | B/5 | 1.8 | +5.380 | +5.482 | 125
TH | C250SD-C300SD/SHS125*125-RHS100*50 | B/5 | 1.8 | +5.382 | +5.484 | 125
PLATE | C350SD/SHS125*125-RHS100*50 | PL/1229 | 8.3 | +4.614 | +5.293 | 128
PLATE | C300SD/SHS125*125-RHS100*50 | PL/1209 | 7.4 | +4.618 | +5.281 | 99
PLATE | C250SD/SHS125*125 | PL/1191 | 4.7 | +4.721 | +5.222 | 79
RAFTER | C350SD/SHS100*100-SHS125*125 | Z/2177 | 11.5 | +4.792 | +5.436 | 125
RAFTER | C300SD/SHS100*100-SHS125*125 | Z/2111 | 10.3 | +4.826 | +5.445 | 96
RAFTER | C250SD/SHS100*100-SHS125*125 | Z/2056 | 7 | +4.857 | +5.454 | 76
TH | C350SD>/SHS100*100-SHS125*125 | B/5 | 1.8 | +5.372 | +5.474 | 125
TH | C300SD-C350SD/SHS100*100-SHS125*125 | B/5 | 1.8 | +5.374 | +5.476 | 125
TH | C250SD-C300SD/SHS100*100-SHS125*125 | B/5 | 1.8 | +5.376 | +5.478 | 125
PLATE | C350SD/SHS100*100-SHS125*125 | PL/1233 | 8 | +4.603 | +5.287 | 128
PLATE | C300SD/SHS100*100-SHS125*125 | PL/1213 | 7.2 | +4.617 | +5.275 | 99
PLATE | C250SD/SHS100*100 | PL/1195 | 4.5 | +4.706 | +5.216 | 79
RAFTER | C200SD/RHS150*50-RHS150*100 | Z/2041 | 6.5 | +4.903 | +5.476 | 76
TH | C200SD-C250SD/RHS150*50-RHS150*100 | B/5 | 1.8 | +5.390 | +5.492 | 125
PLATE | C200SD/RHS150*50 | PL/1185 | 3 | +4.815 | +5.180 | 79
RAFTER | C200SD/SHS75*75-SHS100*100 | Z/2041 | 6.5 | +4.885 | +5.458 | 76
TH | C200SD-C250SD/SHS75*75-SHS100*100 | B/5 | 1.8 | +5.372 | +5.474 | 125
PLATE | C200SD/SHS75*75 | PL/1183 | 2.6 | +4.793 | +5.162 | 79
RAFTER | C150SD/RHS150*50-RHS150*100 | Z/1521 | 5.4 | +4.937 | +5.478 | 64
RAFTER | C150SD/RHS100*50-RHS150*50 | Z/1521 | 5.4 | +4.925 | +5.466 | 64
TH | C150SD-C200SD/RHS150*50-RHS150*100 | B/5 | 1.8 | +5.392 | +5.494 | 125
PLATE | C150SD/RHS150*50 | PL/1173 | 2.7 | +4.814 | +5.168 | 67
TH | C150SD-C200SD/RHS100*50-RHS150*50 | B/5 | 1.8 | +5.380 | +5.482 | 125
PLATE | C150SD/RHS100*50 | PL/1172 | 2.4 | +4.802 | +5.156 | 67
RAFTER | C150SD/SHS75*75-SHS100*100 | Z/1521 | 5.4 | +4.920 | +5.461 | 64
TH | C150SD-C200SD/SHS75*75-SHS100*100 | B/5 | 1.8 | +5.374 | +5.476 | 125
PLATE | C150SD/SHS75*75 | PL/1167 | 2.2 | +4.796 | +5.150 | 67
COLUMN | C350SD/RHS250*150 | Z/1888 | 154.1 | +0.000 | +5.153 | 150
COLUMN | C350SD/RHS200*100 | Z/1887 | 112.8 | +0.000 | +5.113 | 100
COLUMN | C350SD/RHS150*100 | Z/1886 | 92.7 | +0.000 | +5.113 | 100
COLUMN | C350SD/SHS125*125 | Z/1885 | 92.7 | +0.000 | +5.113 | 125
COLUMN | C350SD/SHS100*100 | Z/1883 | 72.6 | +0.000 | +5.113 | 100
COLUMN | C300SD/RHS250*150 | Z/1870 | 154.4 | +0.000 | +5.163 | 150
COLUMN | C300SD/RHS200*100 | Z/1869 | 113.9 | +0.000 | +5.163 | 100
COLUMN | C300SD/RHS150*100 | Z/1868 | 93.6 | +0.000 | +5.163 | 100
COLUMN | C300SD/SHS125*125 | Z/1867 | 93.6 | +0.000 | +5.163 | 125
COLUMN | C300SD/SHS100*100 | Z/1865 | 73.4 | +0.000 | +5.163 | 100
COLUMN | C250SD/RHS200*100 | Z/1852 | 112.8 | +0.000 | +5.113 | 100
COLUMN | C250SD/RHS150*100 | Z/1851 | 92.7 | +0.000 | +5.113 | 100
COLUMN | C250SD/SHS125*125 | Z/1850 | 92.7 | +0.000 | +5.113 | 125
COLUMN | C250SD/SHS100*100 | Z/1848 | 72.6 | +0.000 | +5.113 | 100
COLUMN | C200SD/RHS150*50 | Z/1836 | 72.6 | +0.000 | +5.113 | 50
COLUMN | C200SD/SHS75*75 | Z/1835 | 52.6 | +0.000 | +5.113 | 75
COLUMN | C150SD/RHS150*50 | Z/1829 | 72.6 | +0.000 | +5.113 | 50
COLUMN | C150SD/RHS100*50 | Z/1828 | 52.6 | +0.000 | +5.113 | 50
COLUMN | C150SD/SHS75*75 | Z/1827 | 52.1 | +0.000 | +5.063 | 75
COLUMN | C150SD/SHS50*50 | Z/1825 | 32.4 | +0.000 | +5.063 | 50
RAFTER | C350SD/RHS250*150> | Z/1884 | 9.2 | +4.768 | +5.293 | 125
RAFTER | C300SD/RHS250*150> | Z/1866 | 8.3 | +4.807 | +5.298 | 96
TH | C350SD>/RHS250*150> | B/5 | 1.8 | +5.247 | +5.343 | 125
TH | C300SD-C350SD/RHS250*150> | B/5 | 1.8 | +5.248 | +5.344 | 125
PLATE | C350SD/RHS250*150> | PL/1226 | 9.4 | +4.600 | +5.231 | 128
PLATE | C300SD/RHS250*150> | PL/1206 | 8.6 | +4.608 | +5.222 | 99
RAFTER | C350SD/RHS200*100-RHS250*150 | Z/1884 | 9.2 | +4.760 | +5.285 | 125
RAFTER | C300SD/RHS200*100-RHS250*150 | Z/1866 | 8.3 | +4.799 | +5.290 | 96
RAFTER | C250SD/RHS200*100-RHS250*150 | Z/1849 | 5.7 | +4.835 | +5.294 | 76
TH | C350SD>/RHS200*100-RHS250*150 | B/5 | 1.8 | +5.239 | +5.335 | 125
TH | C300SD-C350SD/RHS200*100-RHS250*150 | B/5 | 1.8 | +5.239 | +5.336 | 125
TH | C250SD-C300SD/RHS200*100-RHS250*150 | B/5 | 1.8 | +5.240 | +5.336 | 125
PLATE | C350SD/RHS200*100-RHS250*150 | PL/1232 | 9 | +4.592 | +5.222 | 128
PLATE | C300SD/RHS200*100-RHS250*150 | PL/1212 | 8 | +4.599 | +5.214 | 99
PLATE | C250SD/RHS200*100 | PL/1194 | 5.2 | +4.706 | +5.171 | 79
RAFTER | C350SD/RHS150*100-RHS200*100 | Z/1884 | 9.2 | +4.752 | +5.277 | 125
RAFTER | C300SD/RHS150*100-RHS200*100 | Z/1866 | 8.3 | +4.791 | +5.282 | 96
RAFTER | C250SD/RHS150*100-RHS200*100 | Z/1849 | 5.7 | +4.827 | +5.286 | 76
TH | C350SD>/RHS150*100-RHS200*100 | B/5 | 1.8 | +5.231 | +5.327 | 125
TH | C300SD-C350SD/RHS150*100-RHS200*100 | B/5 | 1.8 | +5.231 | +5.327 | 125
TH | C250SD-C300SD/RHS150*100-RHS200*100 | B/5 | 1.8 | +5.232 | +5.328 | 125
PLATE | C350SD/RHS150*100-RHS200*100 | PL/1231 | 8.3 | +4.584 | +5.214 | 128
PLATE | C300SD/RHS150*100-RHS200*100 | PL/1211 | 7.4 | +4.591 | +5.206 | 99
PLATE | C250SD/RHS150*100 | PL/1193 | 4.7 | +4.698 | +5.163 | 79
RAFTER | C350SD/SHS125*125-RHS100*50 | Z/1884 | 9.2 | +4.748 | +5.273 | 125
RAFTER | C300SD/SHS125*125-RHS100*50 | Z/1866 | 8.3 | +4.787 | +5.278 | 96
RAFTER | C250SD/SHS125*125-RHS100*50 | Z/1849 | 5.7 | +4.823 | +5.282 | 76
TH | C350SD>/SHS125*125-RHS100*50 | B/5 | 1.8 | +5.226 | +5.323 | 125
TH | C300SD-C350SD/SHS125*125-RHS100*50 | B/5 | 1.8 | +5.227 | +5.323 | 125
TH | C250SD-C300SD/SHS125*125-RHS100*50 | B/5 | 1.8 | +5.228 | +5.324 | 125
PLATE | C350SD/SHS125*125-RHS100*50 | PL/1228 | 8 | +4.580 | +5.210 | 128
PLATE | C300SD/SHS125*125-RHS100*50 | PL/1208 | 7.2 | +4.587 | +5.202 | 99
PLATE | C250SD/SHS125*125 | PL/1190 | 4.5 | +4.694 | +5.159 | 79
RAFTER | C350SD/SHS100*100-SHS125*125 | Z/1884 | 9.2 | +4.743 | +5.269 | 125
RAFTER | C300SD/SHS100*100-SHS125*125 | Z/1866 | 8.3 | +4.783 | +5.274 | 96
RAFTER | C250SD/SHS100*100-SHS125*125 | Z/1849 | 5.7 | +4.819 | +5.278 | 76
TH | C350SD>/SHS100*100-SHS125*125 | B/5 | 1.8 | +5.222 | +5.319 | 125
TH | C300SD-C350SD/SHS100*100-SHS125*125 | B/5 | 1.8 | +5.223 | +5.319 | 125
TH | C250SD-C300SD/SHS100*100-SHS125*125 | B/5 | 1.8 | +5.224 | +5.320 | 125
PLATE | C350SD/SHS100*100-SHS125*125 | PL/1230 | 7.8 | +4.571 | +5.206 | 128
PLATE | C300SD/SHS100*100-SHS125*125 | PL/1210 | 6.8 | +4.588 | +5.198 | 99
RAFTER | C200SD/RHS150*50-RHS150*100 | Z/1618 | 5.4 | +4.867 | +5.291 | 76
TH | C200SD-C250SD/RHS150*50-RHS150*100 | B/5 | 1.8 | +5.233 | +5.329 | 125
PLATE | C200SD/RHS150*50 | PL/1184 | 3 | +4.790 | +5.128 | 79
RAFTER | C150SD/RHS150*50-RHS150*100 | Z/1518 | 3 | +4.907 | +5.211 | 64
RAFTER | C150SD/RHS100*50-RHS150*50 | Z/1518 | 3 | +4.899 | +5.203 | 64
TH | C150SD-C200SD/RHS150*50-RHS150*100 | B/5 | 1.8 | +5.233 | +5.330 | 125
PLATE | C150SD/RHS150*50 | PL/1170 | 2.6 | +4.792 | +5.120 | 67
TH | C150SD-C200SD/RHS100*50-RHS150*50 | B/5 | 1.8 | +5.225 | +5.321 | 125
PLATE | C150SD/RHS100*50 | PL/1169 | 2.3 | +4.784 | +5.112 | 67
RAFTER | C150SD/SHS75*75-SHS100*100 | Z/1518 | 3 | +4.895 | +5.199 | 64
TH | C150SD-C200SD/SHS75*75-SHS100*100 | B/5 | 1.8 | +5.221 | +5.317 | 125
PLATE | C150SD/SHS75*75 | PL/1166 | 2.2 | +4.780 | +5.108 | 67
COLUMN | C350SD/RHS250*150 | Z/1882 | 154.1 | +0.000 | +5.153 | 150
COLUMN | C350SD/RHS200*100 | Z/1881 | 112.8 | +0.000 | +5.113 | 100
COLUMN | C350SD/RHS150*100 | Z/1880 | 92.7 | +0.000 | +5.113 | 100
COLUMN | C350SD/SHS125*125 | Z/1879 | 92.7 | +0.000 | +5.113 | 125
COLUMN | C350SD/SHS100*100 | Z/1877 | 72.6 | +0.000 | +5.113 | 100
COLUMN | C300SD/RHS250*150 | Z/1864 | 154.4 | +0.000 | +5.163 | 150
COLUMN | C300SD/RHS200*100 | Z/1863 | 113.9 | +0.000 | +5.163 | 100
COLUMN | C300SD/RHS150*100 | Z/1862 | 93.6 | +0.000 | +5.163 | 100
COLUMN | C300SD/SHS125*125 | Z/1861 | 93.6 | +0.000 | +5.163 | 125
COLUMN | C300SD/SHS100*100 | Z/1859 | 73.4 | +0.000 | +5.163 | 100
COLUMN | C250SD/RHS200*100 | Z/1847 | 112.8 | +0.000 | +5.113 | 100
COLUMN | C250SD/RHS150*100 | Z/1846 | 92.7 | +0.000 | +5.113 | 100
COLUMN | C250SD/SHS125*125 | Z/1845 | 92.7 | +0.000 | +5.113 | 125
COLUMN | C250SD/SHS100*100 | Z/1843 | 72.6 | +0.000 | +5.113 | 100
COLUMN | C200SD/RHS150*50 | Z/1834 | 71.9 | +0.000 | +5.063 | 50
COLUMN | C200SD/SHS75*75 | Z/1833 | 52.1 | +0.000 | +5.063 | 75
COLUMN | C150SD/RHS150*50 | Z/1824 | 71.9 | +0.000 | +5.063 | 50
COLUMN | C150SD/RHS100*50 | Z/1811 | 52.1 | +0.000 | +5.063 | 50
COLUMN | C150SD/SHS75*75 | Z/1810 | 52.1 | +0.000 | +5.063 | 75
COLUMN | C150SD/SHS50*50 | Z/1797 | 32.4 | +0.000 | +5.063 | 50
PLATE | C150SD/RHS150*50 | PL/825 | 2.6 | +4.783 | +5.100 | 302.139
RAFTER | C150SD/RHS150*50-RHS150*100 | Z/1515 | 3.3 | +4.896 | +5.196 | 64
RAFTER | C200SD/RHS150*50-RHS150*100 | Z/1617 | 5.2 | +4.854 | +5.238 | 76
TH | C150SD-C200SD/RHS150*50-RHS150*100 | B/5 | 1.8 | +5.189 | +5.283 | 125
TH | C200SD-C250SD/RHS150*50-RHS150*100 | B/5 | 1.8 | +5.189 | +5.282 | 125
PLATE | C200SD/RHS150*50 | PL/891 | 3 | +4.780 | +5.107 | 79
RAFTER | C150SD/RHS100*50-RHS150*50 | Z/1515 | 3.3 | +4.889 | +5.189 | 64
TH | C150SD-C200SD/RHS100*50-RHS150*50 | B/5 | 1.8 | +5.183 | +5.276 | 125
PLATE | C150SD/RHS100*50 | PL/824 | 2.3 | +4.777 | +5.093 | 67
RAFTER | C350SD/RHS250*150> | Z/1878 | 9 | +4.745 | +5.241 | 125
RAFTER | C300SD/RHS250*150> | Z/1860 | 8 | +4.787 | +5.245 | 96
TH | C350SD>/RHS250*150> | B/5 | 1.8 | +5.201 | +5.295 | 125
TH | C300SD-C350SD/RHS250*150> | B/5 | 1.8 | +5.202 | +5.295 | 125
PLATE | C350SD/RHS250*150> | PL/1082 | 9.4 | +4.583 | +5.192 | 128
PLATE | C300SD/RHS250*150> | PL/988 | 8.6 | +4.592 | +5.185 | 99
RAFTER | C350SD/RHS200*100-RHS250*150 | Z/1878 | 9 | +4.738 | +5.234 | 125
RAFTER | C300SD/RHS200*100-RHS250*150 | Z/1860 | 8 | +4.780 | +5.238 | 96
RAFTER | C250SD/RHS200*100-RHS250*150 | Z/1844 | 5.4 | +4.818 | +5.241 | 76
TH | C350SD>/RHS200*100-RHS250*150 | B/5 | 1.8 | +5.195 | +5.288 | 125
TH | C300SD-C350SD/RHS200*100-RHS250*150 | B/5 | 1.8 | +5.195 | +5.288 | 125
TH | C250SD-C300SD/RHS200*100-RHS250*150 | B/5 | 1.8 | +5.195 | +5.288 | 125
PLATE | C350SD/RHS200*100-RHS250*150 | PL/1114 | 8.7 | +4.577 | +5.185 | 128
PLATE | C300SD/RHS200*100-RHS250*150 | PL/1012 | 7.8 | +4.585 | +5.178 | 99
PLATE | C250SD/RHS200*100 | PL/935 | 4.9 | +4.693 | +5.142 | 79
RAFTER | C350SD/RHS150*100-RHS200*100 | Z/1878 | 9 | +4.732 | +5.228 | 125
RAFTER | C300SD/RHS150*100-RHS200*100 | Z/1860 | 8 | +4.773 | +5.231 | 96
RAFTER | C250SD/RHS150*100-RHS200*100 | Z/1844 | 5.4 | +4.811 | +5.234 | 76
TH | C350SD>/RHS150*100-RHS200*100 | B/5 | 1.8 | +5.188 | +5.281 | 125
TH | C300SD-C350SD/RHS150*100-RHS200*100 | B/5 | 1.8 | +5.188 | +5.282 | 125
TH | C250SD-C300SD/RHS150*100-RHS200*100 | B/5 | 1.8 | +5.188 | +5.282 | 125
PLATE | C350SD/RHS150*100-RHS200*100 | PL/1113 | 8.3 | +4.570 | +5.178 | 128
PLATE | C300SD/RHS150*100-RHS200*100 | PL/1011 | 7.4 | +4.578 | +5.172 | 99
PLATE | C250SD/RHS150*100 | PL/943 | 4.7 | +4.687 | +5.135 | 79
RAFTER | C350SD/SHS125*125-RHS100*50 | Z/1878 | 9 | +4.728 | +5.224 | 125
RAFTER | C300SD/SHS125*125-RHS100*50 | Z/1860 | 8 | +4.770 | +5.228 | 96
RAFTER | C250SD/SHS125*125-RHS100*50 | Z/1844 | 5.4 | +4.808 | +5.231 | 76
TH | C350SD>/SHS125*125-RHS100*50 | B/5 | 1.8 | +5.185 | +5.278 | 125
TH | C300SD-C350SD/SHS125*125-RHS100*50 | B/5 | 1.8 | +5.185 | +5.278 | 125
TH | C250SD-C300SD/SHS125*125-RHS100*50 | B/5 | 1.8 | +5.185 | +5.278 | 125
PLATE | C350SD/SHS125*125-RHS100*50 | PL/1091 | 7.8 | +4.567 | +5.175 | 128
PLATE | C300SD/SHS125*125-RHS100*50 | PL/997 | 7.2 | +4.575 | +5.168 | 99
PLATE | C250SD/SHS125*125 | PL/920 | 4.5 | +4.683 | +5.132 | 79
RAFTER | C350SD/SHS100*100-SHS125*125 | Z/1878 | 9 | +4.725 | +5.221 | 125
RAFTER | C300SD/SHS100*100-SHS125*125 | Z/1860 | 8 | +4.766 | +5.224 | 96
RAFTER | C250SD/SHS100*100-SHS125*125 | Z/1844 | 5.4 | +4.804 | +5.227 | 76
TH | C350SD>/SHS100*100-SHS125*125 | B/5 | 1.8 | +5.181 | +5.274 | 125
TH | C300SD-C350SD/SHS100*100-SHS125*125 | B/5 | 1.8 | +5.182 | +5.275 | 125
TH | C250SD-C300SD/SHS100*100-SHS125*125 | B/5 | 1.8 | +5.182 | +5.275 | 125
PLATE | C350SD/SHS100*100-SHS125*125 | PL/1112 | 7.7 | +4.558 | +5.172 | 128
PLATE | C300SD/SHS100*100-SHS125*125 | PL/1010 | 6.6 | +4.577 | +5.165 | 99
PLATE | C250SD/SHS100*100 | PL/942 | 4.3 | +4.670 | +5.129 | 79
RAFTER | C150SD/SHS75*75-SHS100*100 | Z/1515 | 3.3 | +4.886 | +5.186 | 64
TH | C150SD-C200SD/SHS75*75-SHS100*100 | B/5 | 1.8 | +5.179 | +5.273 | 125
PLATE | C150SD/SHS75*75 | PL/770 | 2.1 | +4.773 | +5.090 | 67
PLATE | C150SD/SHS75*75 | PL/768 | 2.1 | +4.767 | +5.072 | 264.773
RAFTER | C350SD/RHS250*150> | Z/1818 | 9 | +4.724 | +5.191 | 125
RAFTER | C300SD/RHS250*150> | Z/1804 | 8 | +4.767 | +5.193 | 96
TH | C350SD>/RHS250*150> | B/5 | 1.8 | +5.163 | +5.253 | 125
TH | C300SD-C350SD/RHS250*150> | B/5 | 1.8 | +5.163 | +5.253 | 125
PLATE | C350SD/RHS250*150> | PL/1080 | 9.2 | +4.567 | +5.153 | 128
PLATE | C300SD/RHS250*150> | PL/986 | 8.3 | +4.577 | +5.148 | 99
RAFTER | C350SD/RHS200*100-RHS250*150 | Z/1818 | 9 | +4.718 | +5.185 | 125
RAFTER | C300SD/RHS200*100-RHS250*150 | Z/1804 | 8 | +4.762 | +5.188 | 96
RAFTER | C250SD/RHS200*100-RHS250*150 | Z/1791 | 5.4 | +4.802 | +5.189 | 76
TH | C350SD>/RHS200*100-RHS250*150 | B/5 | 1.8 | +5.157 | +5.247 | 125
TH | C300SD-C350SD/RHS200*100-RHS250*150 | B/5 | 1.8 | +5.157 | +5.247 | 125
TH | C250SD-C300SD/RHS200*100-RHS250*150 | B/5 | 1.8 | +5.157 | +5.247 | 125
PLATE | C350SD/RHS200*100-RHS250*150 | PL/1110 | 8.6 | +4.561 | +5.148 | 128
PLATE | C300SD/RHS200*100-RHS250*150 | PL/1008 | 7.8 | +4.571 | +5.143 | 99
PLATE | C250SD/RHS200*100 | PL/940 | 4.9 | +4.681 | +5.113 | 79
RAFTER | C350SD/RHS150*100-RHS200*100 | Z/1818 | 9 | +4.713 | +5.180 | 125
RAFTER | C300SD/RHS150*100-RHS200*100 | Z/1804 | 8 | +4.756 | +5.182 | 96
RAFTER | C250SD/RHS150*100-RHS200*100 | Z/1791 | 5.4 | +4.796 | +5.184 | 76
TH | C350SD>/RHS150*100-RHS200*100 | B/5 | 1.8 | +5.152 | +5.242 | 125
TH | C300SD-C350SD/RHS150*100-RHS200*100 | B/5 | 1.8 | +5.152 | +5.242 | 125
TH | C250SD-C300SD/RHS150*100-RHS200*100 | B/5 | 1.8 | +5.152 | +5.242 | 125
PLATE | C350SD/RHS150*100-RHS200*100 | PL/1108 | 8 | +4.556 | +5.143 | 128
PLATE | C300SD/RHS150*100-RHS200*100 | PL/1006 | 7.2 | +4.566 | +5.137 | 99
PLATE | C250SD/RHS150*100 | PL/938 | 4.5 | +4.675 | +5.108 | 79
RAFTER | C200SD/RHS150*50-RHS150*100 | Z/1786 | 4.9 | +4.841 | +5.186 | 76
RAFTER | C150SD/RHS150*50-RHS150*100 | Z/1514 | 3.6 | +4.885 | +5.168 | 64
TH | C200SD-C250SD/RHS150*50-RHS150*100 | B/5 | 1.8 | +5.152 | +5.242 | 125
TH | C150SD-C200SD/RHS150*50-RHS150*100 | B/5 | 1.8 | +5.153 | +5.243 | 125
PLATE | C200SD/RHS150*50 | PL/889 | 2.8 | +4.770 | +5.085 | 79
PLATE | C150SD/RHS150*50 | PL/821 | 2.4 | +4.775 | +5.080 | 67
RAFTER | C150SD/RHS100*50-RHS150*50 | Z/1514 | 3.6 | +4.880 | +5.163 | 64
TH | C150SD-C200SD/RHS100*50-RHS150*50 | B/5 | 1.8 | +5.147 | +5.237 | 125
PLATE | C150SD/RHS100*50 | PL/819 | 2.3 | +4.770 | +5.074 | 67
RAFTER | C350SD/SHS125*125-RHS100*50 | Z/1818 | 9 | +4.710 | +5.177 | 125
RAFTER | C300SD/SHS125*125-RHS100*50 | Z/1804 | 8 | +4.754 | +5.180 | 96
RAFTER | C250SD/SHS125*125-RHS100*50 | Z/1791 | 5.4 | +4.794 | +5.181 | 76
TH | C350SD>/SHS125*125-RHS100*50 | B/5 | 1.8 | +5.149 | +5.239 | 125
TH | C300SD-C350SD/SHS125*125-RHS100*50 | B/5 | 1.8 | +5.149 | +5.239 | 125
TH | C250SD-C300SD/SHS125*125-RHS100*50 | B/5 | 1.8 | +5.149 | +5.239 | 125
PLATE | C350SD/SHS125*125-RHS100*50 | PL/1089 | 7.8 | +4.553 | +5.140 | 128
PLATE | C300SD/SHS125*125-RHS100*50 | PL/995 | 7 | +4.563 | +5.135 | 99
PLATE | C250SD/SHS125*125 | PL/918 | 4.3 | +4.673 | +5.105 | 79
RAFTER | C350SD/SHS100*100-SHS125*125 | Z/1818 | 9 | +4.708 | +5.175 | 125
RAFTER | C300SD/SHS100*100-SHS125*125 | Z/1804 | 8 | +4.751 | +5.177 | 96
RAFTER | C250SD/SHS100*100-SHS125*125 | Z/1791 | 5.4 | +4.791 | +5.179 | 76
TH | C350SD>/SHS100*100-SHS125*125 | B/5 | 1.8 | +5.147 | +5.237 | 125
TH | C300SD-C350SD/SHS100*100-SHS125*125 | B/5 | 1.8 | +5.147 | +5.237 | 125
TH | C250SD-C300SD/SHS100*100-SHS125*125 | B/5 | 1.8 | +5.147 | +5.237 | 125
PLATE | C350SD/SHS100*100-SHS125*125 | PL/1106 | 7.4 | +4.546 | +5.137 | 128
PLATE | C300SD/SHS100*100-SHS125*125 | PL/1004 | 6.6 | +4.566 | +5.132 | 99
PLATE | C250SD/SHS100*100 | PL/936 | 4.1 | +4.660 | +5.103 | 79
RAFTER | C200SD/SHS75*75-SHS100*100 | Z/1786 | 4.9 | +4.833 | +5.178 | 76
RAFTER | C150SD/SHS75*75-SHS100*100 | Z/1514 | 3.6 | +4.877 | +5.160 | 64
TH | C200SD-C250SD/SHS75*75-SHS100*100 | B/5 | 1.8 | +5.144 | +5.234 | 125
TH | C150SD-C200SD/SHS75*75-SHS100*100 | B/5 | 1.8 | +5.145 | +5.235 | 125
PLATE | C200SD/SHS75*75 | PL/880 | 2.4 | +4.757 | +5.077 | 79
TH | C150SD-C200SD/SHS50*50-SHS75*75 | B/5 | 1.8 | +5.369 | +5.471 | 125
RAFTER | C150SD/SHS50*50-SHS75*75 | Z/1521 | 5.4 | +4.914 | +5.455 | 64
PLATE | C150SD/SHS50*50 | PL/1171 | 2.1 | +4.790 | +5.144 | 67
RAFTER | C200SD/SHS75*75-SHS100*100 | Z/1618 | 5.4 | +4.855 | +5.279 | 76
RAFTER | C150SD/SHS50*50-SHS75*75 | Z/1518 | 3 | +4.891 | +5.195 | 64
TH | C200SD-C250SD/SHS75*75-SHS100*100 | B/5 | 1.8 | +5.220 | +5.317 | 125
TH | C150SD-C200SD/SHS50*50-SHS75*75 | B/5 | 1.8 | +5.217 | +5.313 | 125
PLATE | C200SD/SHS75*75 | PL/1182 | 2.4 | +4.773 | +5.116 | 79
PLATE | C150SD/SHS50*50 | PL/1168 | 1.9 | +4.776 | +5.104 | 67
RAFTER | C200SD/SHS75*75-SHS100*100 | Z/1617 | 5.2 | +4.844 | +5.228 | 76
RAFTER | C150SD/SHS50*50-SHS75*75 | Z/1515 | 3.3 | +4.883 | +5.182 | 64
TH | C200SD-C250SD/SHS75*75-SHS100*100 | B/5 | 1.8 | +5.179 | +5.272 | 125
TH | C150SD-C200SD/SHS50*50-SHS75*75 | B/5 | 1.8 | +5.176 | +5.269 | 125
PLATE | C200SD/SHS75*75 | PL/882 | 2.4 | +4.765 | +5.097 | 79
PLATE | C150SD/SHS50*50 | PL/823 | 1.9 | +4.770 | +5.086 | 67
RAFTER | C150SD/SHS50*50-SHS75*75 | Z/1514 | 3.6 | +4.875 | +5.157 | 64
TH | C150SD-C200SD/SHS50*50-SHS75*75 | B/5 | 1.8 | +5.142 | +5.232 | 125
PLATE | C150SD/SHS50*50 | PL/817 | 1.9 | +4.764 | +5.069 | 67

# IfcMechanicalFastener: Bolt assembly (1040)
In: Undefined
Material: 8.8S
Tekla Bolt - Washer type: HARD; Nut type: 8.8-HEX; Location: Site; Bolt standard: 8.8S
Name | NominalDiameter (mm) = Washer diameter (mm) = Bolt size (mm) | NominalLength (mm) = Bolt length (mm) | Washer count = Nut count = Bolt count | Washer name | Nut name | Slotted hole y (mm) | Slotted hole x (mm) | Bolt hole diameter (mm) | Bolt Name
52 x Bolt assembly | 12 | 100 | 4 | WASHERM12-HARD | NUTM12-8.8-HEX | 0 | 0 | 14 | BOLTM12*100
96 x Bolt assembly | 12 | 30 | 4 | WASHERM12-HARD | NUTM12-8.8-HEX | 8 | 4 | 14 | BOLTM12*30
26 x Bolt assembly | 12 | 75 | 4 | WASHERM12-HARD | NUTM12-8.8-HEX | 0 | 0 | 14 | BOLTM12*75
60 x Bolt assembly | 12 | 30 | 4 | WASHERM12-HARD | NUTM12-8.8-HEX | 0 | 0 | 14 | BOLTM12*30
104 x Bolt assembly | 16 | 130 | 6 | WASHERM16-HARD | NUTM16-8.8-HEX | 0 | 0 | 18 | BOLTM16*130
160 x Bolt assembly | 16 | 40 | 6 | WASHERM16-HARD | NUTM16-8.8-HEX | 4 | 0 | 18 | BOLTM16*40
100 x Bolt assembly | 16 | 40 | 6 | WASHERM16-HARD | NUTM16-8.8-HEX | 0 | 0 | 18 | BOLTM16*40
26 x Bolt assembly | 16 | 130 | 4 | WASHERM16-HARD | NUTM16-8.8-HEX | 0 | 0 | 18 | BOLTM16*130
64 x Bolt assembly | 16 | 35 | 4 | WASHERM16-HARD | NUTM16-8.8-HEX | 4 | 0 | 18 | BOLTM16*35
40 x Bolt assembly | 16 | 35 | 4 | WASHERM16-HARD | NUTM16-8.8-HEX | 0 | 0 | 18 | BOLTM16*35
52 x Bolt assembly | 16 | 160 | 8 | WASHERM16-HARD | NUTM16-8.8-HEX | 0 | 0 | 18 | BOLTM16*160
26 x Bolt assembly | 16 | 160 | 6 | WASHERM16-HARD | NUTM16-8.8-HEX | 0 | 0 | 18 | BOLTM16*160
78 x Bolt assembly | 12 | 75 | 6 | WASHERM12-HARD | NUTM12-8.8-HEX | 0 | 0 | 14 | BOLTM12*75
104 x Bolt assembly | 16 | 130 | 8 | WASHERM16-HARD | NUTM16-8.8-HEX | 0 | 0 | 18 | BOLTM16*130
52 x Bolt assembly | 16 | 180 | 8 | WASHERM16-HARD | NUTM16-8.8-HEX | 0 | 0 | 18 | BOLTM16*180

# IfcMember: C:150-24 (8)
In: Undefined
Description: C:150-24; Material: STEEL/G450
Tekla Common - Finish: 25 deg; Phase: 1; Class: 10
Tekla Quantity - Weight: 5.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.6 m2; Height: 152 mm; Width: 64 mm; Length: 954.3 mm
Pset_MemberCommon - LoadBearing: no; Reference: Z/1521
BaseQuantities - Length: 954.293 mm; OuterSurfaceArea: 0.592756 m2; GrossSurfaceArea: 0 m2; CrossSectionArea: 0.00071 m2; NetVolume: 0.000704039 m3; GrossVolume: 0.000677548 m3; NetWeight: 5.52671 kg; GrossWeight: 5.31875 kg
Name | Bottom elevation | Top elevation | Area per tons (m2)
RAFTER | +4.937 | +5.478 | 111.5
RAFTER | +4.925 | +5.466 | 111.5
RAFTER | +4.920 | +5.461 | 111.5
RAFTER | +4.914 | +5.455 | 111.5
RAFTER | +4.937 | +5.478 | 111.3
RAFTER | +4.925 | +5.466 | 111.3
RAFTER | +4.920 | +5.461 | 111.3
RAFTER | +4.914 | +5.455 | 111.3

# IfcMember: C:200-24 (4)
In: Undefined
Description: C:200-24; Material: STEEL/G450
Tekla Common - Finish: 25 deg; Phase: 1; Class: 10
Tekla Quantity - Weight: 6.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 110.3 m2; Net surface area: 0.6 m2; Height: 203 mm; Width: 76 mm; Length: 921.1 mm
Pset_MemberCommon - LoadBearing: no; Reference: Z/2041
BaseQuantities - Length: 921.139 mm; OuterSurfaceArea: 0.719979 m2; GrossSurfaceArea: 0 m2; CrossSectionArea: 0.000903 m2; NetVolume: 0.000856438 m3; GrossVolume: 0.000831788 m3; NetWeight: 6.72304 kg; GrossWeight: 6.52954 kg
Name | Bottom elevation | Top elevation
2 x RAFTER | +4.903 | +5.476
2 x RAFTER | +4.885 | +5.458

# IfcMember: C:250-24 (8)
In: Undefined
Description: C:250-24; Material: STEEL/G450
Tekla Common - Finish: 25 deg; Phase: 1; Class: 10
Tekla Quantity - Weight: 7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 110 m2; Net surface area: 0.8 m2; Height: 254 mm; Width: 76 mm; Length: 869.2 mm
Pset_MemberCommon - LoadBearing: no; Reference: Z/2056
BaseQuantities - Length: 869.216 mm; OuterSurfaceArea: 0.766662 m2; GrossSurfaceArea: 0 m2; CrossSectionArea: 0.001022 m2; NetVolume: 0.000912469 m3; GrossVolume: 0.000888339 m3; NetWeight: 7.16288 kg; GrossWeight: 6.97346 kg
Name | Bottom elevation | Top elevation
2 x RAFTER | +4.880 | +5.477
2 x RAFTER | +4.868 | +5.466
2 x RAFTER | +4.862 | +5.460
2 x RAFTER | +4.857 | +5.454

# IfcMember: C:300-30 (10)
In: Undefined
Description: C:300-30; Material: STEEL/G450
Tekla Common - Finish: 25 deg; Phase: 1; Class: 10
Tekla Quantity - Weight: 10.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.7 m2; Net surface area: 0.8 m2; Height: 300 mm; Width: 96 mm; Length: 822.4 mm
Pset_MemberCommon - LoadBearing: no; Reference: Z/2111
BaseQuantities - Length: 822.389 mm; OuterSurfaceArea: 0.901307 m2; GrossSurfaceArea: 0 m2; CrossSectionArea: 0.001593 m2; NetVolume: 0.00133967 m3; GrossVolume: 0.00131007 m3; NetWeight: 10.5164 kg; GrossWeight: 10.284 kg
Name | Bottom elevation | Top elevation
2 x RAFTER | +4.861 | +5.480
2 x RAFTER | +4.849 | +5.469
2 x RAFTER | +4.838 | +5.457
2 x RAFTER | +4.832 | +5.451
2 x RAFTER | +4.826 | +5.445

# IfcMember: C:350-30 (10)
In: Undefined
Description: C:350-30; Material: STEEL/G450
Tekla Common - Finish: 25 deg; Phase: 1; Class: 10
Tekla Quantity - Weight: 11.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.5 m2; Net surface area: 1 m2; Height: 350 mm; Width: 125 mm; Length: 771.5 mm
Pset_MemberCommon - LoadBearing: no; Reference: Z/2177
BaseQuantities - Length: 771.491 mm; OuterSurfaceArea: 1.00837 m2; GrossSurfaceArea: 0 m2; CrossSectionArea: 0.001905 m2; NetVolume: 0.00149978 m3; GrossVolume: 0.00146969 m3; NetWeight: 11.7733 kg; GrossWeight: 11.5371 kg
Name | Bottom elevation | Top elevation
2 x RAFTER | +4.827 | +5.471
2 x RAFTER | +4.816 | +5.459
2 x RAFTER | +4.804 | +5.447
2 x RAFTER | +4.798 | +5.441
2 x RAFTER | +4.792 | +5.436

# IfcPlate: PLT3*299.4 (2)
In: Undefined
Description: PLT3*299.4; Material: STEEL/450
Tekla Common - Bottom elevation: +5.024; Top elevation: +5.281; Phase: 1; Class: 11
Tekla Quantity - Weight: 1.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.9 m2; Net surface area: 0.2 m2; Height: 299.4 mm; Width: 3 mm; Length: 313.8 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 299.376 mm; NetArea: 0.156665 m2; GrossArea: 0.0939506 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000229431 m3; GrossVolume: 0.000229431 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/852
PLATE | PL/831

# IfcPlate: PLT3*302.1 (2)
In: Undefined
Description: PLT3*302.1; Material: STEEL/450
Tekla Common - Bottom elevation: +4.910; Top elevation: +5.168; Phase: 1; Class: 11
Tekla Quantity - Weight: 1.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.9 m2; Net surface area: 0.2 m2; Height: 302.1 mm; Width: 3 mm; Length: 313.1 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 302.137 mm; NetArea: 0.156504 m2; GrossArea: 0.0946009 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000229191 m3; GrossVolume: 0.000229191 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/864
PLATE | PL/776

# IfcPlate: PLT3*305.3 (8)
In: Undefined
Description: PLT3*305.3; Material: STEEL/450
Tekla Common - Bottom elevation: +4.442; Top elevation: +4.700; Phase: 1; Class: 11
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.2 m2; Height: 305.3 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 305.311 mm; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Weight (kg) | Area per tons (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
PLATE | PL/847 | 2.4 | 86.7 | 435.3 | 0.207336 | 0.132892 | 0.00030453
PLATE | PL/845 | 2.1 | 86.9 | 386.4 | 0.182036 | 0.11796 | 0.00026703
PLATE | PL/870 | 1.9 | 86.9 | 361.9 | 0.169386 | 0.110494 | 0.00024828
PLATE | PL/843 | 1.8 | 86.9 | 337.5 | 0.156736 | 0.103028 | 0.000229531
PLATE | PL/822 | 2.4 | 86.7 | 435.3 | 0.207336 | 0.132892 | 0.00030453
PLATE | PL/820 | 2.1 | 86.9 | 386.4 | 0.182036 | 0.11796 | 0.00026703
PLATE | PL/769 | 1.9 | 86.9 | 361.9 | 0.169386 | 0.110494 | 0.00024828
PLATE | PL/818 | 1.8 | 86.9 | 337.5 | 0.156736 | 0.103028 | 0.000229531

# IfcPlate: PLT3*307.2 (8)
In: Undefined
Description: PLT3*307.2; Material: STEEL/450
Tekla Common - Bottom elevation: +4.442; Top elevation: +4.700; Phase: 1; Class: 11
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.2 m2; Height: 307.2 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 307.176 mm; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Weight (kg) | Area per tons (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
PLATE | PL/1972 | 1.9 | 86.9 | 356.8 | 0.169434 | 0.109586 | 0.000248355
PLATE | PL/1953 | 1.8 | 86.9 | 332.1 | 0.156784 | 0.102023 | 0.000229605
PLATE | PL/1826 | 2.1 | 86.9 | 381.4 | 0.182084 | 0.117149 | 0.000267105
PLATE | PL/1828 | 2.4 | 86.7 | 430.6 | 0.207384 | 0.132275 | 0.000304604
PLATE | PL/1824 | 2.4 | 86.7 | 430.6 | 0.207384 | 0.132275 | 0.000304604
PLATE | PL/1822 | 2.1 | 86.9 | 381.4 | 0.182084 | 0.117149 | 0.000267105
PLATE | PL/1971 | 1.9 | 86.9 | 356.8 | 0.169434 | 0.109586 | 0.000248355
PLATE | PL/1951 | 1.8 | 86.9 | 332.1 | 0.156784 | 0.102023 | 0.000229605

# IfcPlate: PLT3*307.9 (8)
In: Undefined
Description: PLT3*307.9; Material: STEEL/450
Tekla Common - Bottom elevation: +5.258; Top elevation: +5.516; Phase: 1; Class: 11
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.2 m2; Height: 307.9 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 307.887 mm; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Weight (kg) | Area per tons (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
PLATE | PL/862 | 2.4 | 86.7 | 428.5 | 0.207396 | 0.131944 | 0.000304623
PLATE | PL/860 | 2.1 | 86.9 | 379.2 | 0.182096 | 0.116739 | 0.000267123
PLATE | PL/875 | 1.9 | 86.9 | 354.5 | 0.169445 | 0.109137 | 0.000248373
PLATE | PL/858 | 1.8 | 86.9 | 329.8 | 0.156795 | 0.101534 | 0.000229623
PLATE | PL/841 | 2.4 | 86.7 | 428.5 | 0.207396 | 0.131944 | 0.000304623
PLATE | PL/839 | 2.1 | 86.9 | 379.2 | 0.182096 | 0.116739 | 0.000267123
PLATE | PL/774 | 1.9 | 86.9 | 354.5 | 0.169445 | 0.109137 | 0.000248373
PLATE | PL/837 | 1.8 | 86.9 | 329.8 | 0.156795 | 0.101534 | 0.000229623

# IfcPlate: PLT3*313.1 (6)
In: Undefined
Description: PLT3*313.1; Material: STEEL/450
Tekla Common - Bottom elevation: +4.910; Top elevation: +5.168; Phase: 1; Class: 11
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.2 m2; Height: 313.1 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Weight (kg) | Area per tons (m2) | Length (mm) | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
PLATE | PL/868 | 2.4 | 86.7 | 402.1 | 313.106 | 0.207101 | 0.125911 | 0.000304187
PLATE | PL/866 | 2.1 | 86.9 | 352.1 | 313.106 | 0.181803 | 0.110256 | 0.000266689
PLATE | PL/877 | 1.9 | 86.9 | 327.1 | 313.105 | 0.169151 | 0.102429 | 0.000247937
PLATE | PL/816 | 2.4 | 86.7 | 402.1 | 313.106 | 0.207101 | 0.125911 | 0.000304187
PLATE | PL/814 | 2.1 | 86.9 | 352.1 | 313.106 | 0.181803 | 0.110256 | 0.000266689
PLATE | PL/767 | 1.9 | 86.9 | 327.1 | 313.105 | 0.169151 | 0.102429 | 0.000247937

# IfcPlate: PLT3*313.8 (6)
In: Undefined
Description: PLT3*313.8; Material: STEEL/450
Tekla Common - Bottom elevation: +5.024; Top elevation: +5.281; Phase: 1; Class: 11
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.2 m2; Height: 313.8 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 313.812 mm; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Weight (kg) | Area per tons (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
PLATE | PL/856 | 2.4 | 86.7 | 399.4 | 0.20726 | 0.125326 | 0.000304423
PLATE | PL/854 | 2.1 | 86.9 | 349.4 | 0.18196 | 0.109636 | 0.000266923
PLATE | PL/873 | 1.9 | 86.9 | 324.4 | 0.16931 | 0.10179 | 0.000248173
PLATE | PL/835 | 2.4 | 86.7 | 399.4 | 0.20726 | 0.125326 | 0.000304423
PLATE | PL/833 | 2.1 | 86.9 | 349.4 | 0.18196 | 0.109636 | 0.000266923
PLATE | PL/772 | 1.9 | 86.9 | 324.4 | 0.16931 | 0.10179 | 0.000248173

# IfcPlate: PLT3*315.5 (2)
In: Undefined
Description: PLT3*315.5; Material: STEEL/450
Tekla Common - Bottom elevation: +4.748; Top elevation: +5.017; Phase: 1; Class: 11
Tekla Quantity - Weight: 1.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.9 m2; Net surface area: 0.2 m2; Height: 315.5 mm; Width: 3 mm; Length: 323.2 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 315.539 mm; NetArea: 0.15989 m2; GrossArea: 0.101967 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000234194 m3; GrossVolume: 0.000234194 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/863
PLATE | PL/775

# IfcPlate: PLT3*319.9 (2)
In: Undefined
Description: PLT3*319.9; Material: STEEL/450
Tekla Common - Bottom elevation: +4.895; Top elevation: +5.168; Phase: 1; Class: 11
Tekla Quantity - Weight: 2.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.9 m2; Net surface area: 0.2 m2; Height: 319.9 mm; Width: 3 mm; Length: 342.5 mm
Pset_PlateCommon - LoadBearing: no
