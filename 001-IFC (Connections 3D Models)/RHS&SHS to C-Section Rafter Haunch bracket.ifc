Properties of the parts of a building model (IFC2X3), part 1 of 5

# File
Description: ViewDefinition[CoordinationView_V2.0, QuantityTakeOffAddOnView], Option [BaseQuantities:On], Option [GridExport:On], Option [Assemblies:On], Option [Bolts:On], Option [Rebars:On], Option [PourObjects:Off], Option [Welds:Off], Option [SurfaceTreatments:Off], Option [LocationBy:0], Option [ViewColors:Off], Option [SectionedSpine:Off], Option [PropertySets:On], Option [Export all:Off]
File name: 1.ifc
Time: 2026-07-16T22:35:59
Author: LAPTOP-2P0BGI6B\lablab
Organization: Structural Designer
Written by: IFC Database Version: Work
Made in: Tekla Structures 2019 Service Pack 13, IFC Export Version: 4.0.0.0 Oct 18 2021

# IfcBuildingStorey, Undefined
In: Undefined
Elevation: 0 mm

# IfcBeam: C:150-24 (72)
In: Undefined
Description: C:150-24; Material: STEEL/G450
Tekla Common - Phase: 1; Class: 10
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 152 mm; Width: 64 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Finish | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
8 x RAFTER | Z/1775 | 12 deg | +4.393 | +4.694 | 4.9 | 111.5 | 0.5 | 871.3 | 871.343 | 0.54136 | 0.000642842 | 5.04631
RAFTER | Z/1514 | 12 deg | +4.873 | +5.135 | 3.6 | 111.6 | 0.5 | 644 | 644.013 | 0.400506 | 0.000475127 | 3.72975
RAFTER | Z/1514 | 12 deg | +4.876 | +5.138 | 3.6 | 111.6 | 0.5 | 644 | 644.013 | 0.400506 | 0.000475127 | 3.72975
2 x RAFTER | Z/1514 | 12 deg | +4.879 | +5.140 | 3.6 | 111.6 | 0.3 | 644 | 644.013 | 0.400506 | 0.000475127 | 3.72975
2 x RAFTER | Z/1514 | 12 deg | +4.884 | +5.145 | 3.6 | 111.6 | 0.3 | 644 | 644.013 | 0.400506 | 0.000475127 | 3.72975
RAFTER | Z/1514 | 12 deg | +4.876 | +5.138 | 3.6 | 111.6 | 0.3 | 644 | 644.013 | 0.400506 | 0.000475127 | 3.72975
RAFTER | Z/1514 | 12 deg | +4.873 | +5.135 | 3.6 | 111.6 | 0.3 | 644 | 644.013 | 0.400506 | 0.000475127 | 3.72975
2 x RAFTER | Z/1518 | 18 deg | +4.907 | +5.211 | 3 | 111.6 | 0.3 | 515.8 | 515.783 | 0.321055 | 0.000380524 | 2.98711
2 x RAFTER | Z/1518 | 18 deg | +4.899 | +5.203 | 3 | 111.6 | 0.3 | 515.8 | 515.783 | 0.321055 | 0.000380524 | 2.98711
2 x RAFTER | Z/1518 | 18 deg | +4.895 | +5.199 | 3 | 111.6 | 0.3 | 515.8 | 515.783 | 0.321055 | 0.000380524 | 2.98711
2 x RAFTER | Z/1518 | 18 deg | +4.891 | +5.195 | 3 | 111.6 | 0.3 | 515.8 | 515.783 | 0.321055 | 0.000380524 | 2.98711
2 x RAFTER | Z/1515 | 15 deg | +4.896 | +5.196 | 3.3 | 111.6 | 0.3 | 591.2 | 591.173 | 0.367766 | 0.000436144 | 3.42373
2 x RAFTER | Z/1515 | 15 deg | +4.889 | +5.189 | 3.3 | 111.6 | 0.3 | 591.2 | 591.173 | 0.367766 | 0.000436144 | 3.42373
2 x RAFTER | Z/1515 | 15 deg | +4.886 | +5.186 | 3.3 | 111.6 | 0.3 | 591.2 | 591.173 | 0.367766 | 0.000436144 | 3.42373
2 x RAFTER | Z/1515 | 15 deg | +4.883 | +5.182 | 3.3 | 111.6 | 0.3 | 591.2 | 591.173 | 0.367766 | 0.000436144 | 3.42373
8 x RAFTER | Z/1775 | 12 deg | +4.362 | +4.691 | 4.9 | 111.5 | 0.5 | 871.3 | 871.343 | 0.54136 | 0.000642842 | 5.04631
2 x RAFTER | Z/1514 | 12 deg | +4.885 | +5.168 | 3.6 | 111.6 | 0.3 | 644 | 644.013 | 0.400506 | 0.000475127 | 3.72975
2 x RAFTER | Z/1514 | 12 deg | +4.880 | +5.163 | 3.6 | 111.6 | 0.3 | 644 | 644.013 | 0.400506 | 0.000475127 | 3.72975
2 x RAFTER | Z/1514 | 12 deg | +4.877 | +5.160 | 3.6 | 111.6 | 0.3 | 644 | 644.013 | 0.400506 | 0.000475127 | 3.72975
2 x RAFTER | Z/1514 | 12 deg | +4.875 | +5.157 | 3.6 | 111.6 | 0.3 | 644 | 644.013 | 0.400506 | 0.000475127 | 3.72975
2 x RAFTER | Z/2020 | 9 deg | +4.875 | +5.511 | 17.3 | 111.3 | 2 | 3102.5 | 3102.51 | 1.92379 | 0.00228891 | 17.9679
2 x RAFTER | Z/2019 | 9 deg | +4.871 | +5.511 | 17.4 | 111.3 | 2 | 3127.8 | 3127.82 | 1.93947 | 0.00230758 | 18.1145
2 x RAFTER | Z/1778 | 9 deg | +4.869 | +5.511 | 17.4 | 111.3 | 2 | 3140.5 | 3140.48 | 1.94732 | 0.00231692 | 18.1878
2 x RAFTER | Z/2018 | 9 deg | +4.867 | +5.511 | 17.6 | 111.3 | 2 | 3153.1 | 3153.13 | 1.95516 | 0.00232626 | 18.2611
2 x RAFTER | Z/2008 | 5 deg | +4.862 | +5.279 | 17 | 111.3 | 2 | 3045.6 | 3045.6 | 1.88853 | 0.00224692 | 17.6384
2 x RAFTER | Z/2004 | 5 deg | +4.860 | +5.279 | 17.1 | 111.3 | 2 | 3070.7 | 3070.69 | 1.90408 | 0.00226543 | 17.7837
2 x RAFTER | Z/1777 | 5 deg | +4.859 | +5.279 | 17.1 | 111.3 | 2 | 3083.2 | 3083.24 | 1.91185 | 0.00227469 | 17.8563
2 x RAFTER | Z/1875 | 5 deg | +4.858 | +5.279 | 17.3 | 111.3 | 2 | 3095.8 | 3095.79 | 1.91963 | 0.00228395 | 17.929
2 x RAFTER | Z/1874 | 3 deg | +4.856 | +5.167 | 17 | 111.3 | 2 | 3031.8 | 3031.77 | 1.87996 | 0.00223672 | 17.5583
2 x RAFTER | Z/1873 | 3 deg | +4.855 | +5.167 | 17 | 111.3 | 2 | 3056.8 | 3056.8 | 1.89547 | 0.00225519 | 17.7032
2 x RAFTER | Z/1776 | 3 deg | +4.854 | +5.167 | 17.1 | 111.3 | 2 | 3069.3 | 3069.32 | 1.90323 | 0.00226442 | 17.7757
2 x RAFTER | Z/1872 | 3 deg | +4.854 | +5.167 | 17.1 | 111.3 | 2 | 3081.8 | 3081.83 | 1.91098 | 0.00227365 | 17.8482

# IfcBeam: C:200-24 (36)
In: Undefined
Description: C:200-24; Material: STEEL/G450
Tekla Common - Phase: 1; Class: 10
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 203 mm; Width: 76 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Finish | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
4 x RAFTER | Z/2040 | 12 deg | +4.352 | +4.692 | 5.7 | 110.3 | 0.6 | 808.4 | 808.359 | 0.632056 | 0.00075158 | 5.8999
2 x RAFTER | Z/1786 | 12 deg | +4.831 | +5.154 | 4.9 | 110.3 | 0.6 | 707.1 | 707.109 | 0.553122 | 0.000657442 | 5.16092
2 x RAFTER | Z/1786 | 12 deg | +4.839 | +5.162 | 4.9 | 110.3 | 0.6 | 707.1 | 707.109 | 0.553122 | 0.000657442 | 5.16092
2 x RAFTER | Z/1618 | 18 deg | +4.867 | +5.291 | 5.4 | 110.3 | 0.6 | 747.4 | 747.399 | 0.584532 | 0.000694902 | 5.45498
2 x RAFTER | Z/1618 | 18 deg | +4.855 | +5.279 | 5.4 | 110.3 | 0.6 | 747.4 | 747.399 | 0.584532 | 0.000694902 | 5.45498
2 x RAFTER | Z/1617 | 15 deg | +4.854 | +5.238 | 5.2 | 110.3 | 0.6 | 726.1 | 726.099 | 0.567926 | 0.000675098 | 5.29952
2 x RAFTER | Z/1617 | 15 deg | +4.844 | +5.228 | 5.2 | 110.3 | 0.6 | 726.1 | 726.099 | 0.567926 | 0.000675098 | 5.29952
4 x RAFTER | Z/2040 | 12 deg | +4.322 | +4.689 | 5.7 | 110.3 | 0.6 | 808.4 | 808.359 | 0.632056 | 0.00075158 | 5.8999
2 x RAFTER | Z/1786 | 12 deg | +4.841 | +5.186 | 4.9 | 110.3 | 0.6 | 707.1 | 707.109 | 0.553122 | 0.000657442 | 5.16092
2 x RAFTER | Z/1786 | 12 deg | +4.833 | +5.178 | 4.9 | 110.3 | 0.6 | 707.1 | 707.109 | 0.553122 | 0.000657442 | 5.16092
2 x RAFTER | Z/2047 | 9 deg | +4.829 | +5.509 | 21.8 | 110.1 | 2.5 | 3068.6 | 3068.62 | 2.39416 | 0.00285308 | 22.3967
2 x RAFTER | Z/2044 | 9 deg | +4.823 | +5.509 | 22 | 110.1 | 2.5 | 3106.6 | 3106.59 | 2.42376 | 0.00288838 | 22.6738
2 x RAFTER | Z/2046 | 5 deg | +4.814 | +5.279 | 21.4 | 110.1 | 2.5 | 3015.5 | 3015.55 | 2.35278 | 0.00280374 | 22.0093
2 x RAFTER | Z/2043 | 5 deg | +4.810 | +5.279 | 21.6 | 110.1 | 2.5 | 3053.2 | 3053.2 | 2.38213 | 0.00283874 | 22.2841
2 x RAFTER | Z/2045 | 3 deg | +4.807 | +5.167 | 21.3 | 110.1 | 2.3 | 3003.6 | 3003.57 | 2.34344 | 0.0027926 | 21.9219
2 x RAFTER | Z/2042 | 3 deg | +4.805 | +5.167 | 21.6 | 110.1 | 2.5 | 3041.1 | 3041.12 | 2.37272 | 0.00282751 | 22.196

# IfcBeam: C:250-24 (72)
In: Undefined
Description: C:250-24; Material: STEEL/G450
Tekla Common - Phase: 1; Class: 10
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 254 mm; Width: 76 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Finish | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
8 x RAFTER | Z/2055 | 12 deg | +4.311 | +4.691 | 6 | 110 | 0.6 | 745.4 | 745.377 | 0.657733 | 0.000782467 | 6.14237
2 x RAFTER | Z/1791 | 12 deg | +4.789 | +5.155 | 5.4 | 110 | 0.6 | 670.2 | 670.197 | 0.591605 | 0.000703546 | 5.52284
2 x RAFTER | Z/1791 | 12 deg | +4.792 | +5.158 | 5.4 | 110 | 0.6 | 670.2 | 670.197 | 0.591605 | 0.000703546 | 5.52284
2 x RAFTER | Z/1791 | 12 deg | +4.794 | +5.160 | 5.4 | 110 | 0.6 | 670.2 | 670.197 | 0.591605 | 0.000703546 | 5.52284
2 x RAFTER | Z/1791 | 12 deg | +4.799 | +5.166 | 5.4 | 110 | 0.6 | 670.2 | 670.197 | 0.591605 | 0.000703546 | 5.52284
2 x RAFTER | Z/1849 | 18 deg | +4.835 | +5.294 | 5.7 | 110 | 0.6 | 704 | 704.007 | 0.621344 | 0.000739038 | 5.80145
2 x RAFTER | Z/1849 | 18 deg | +4.827 | +5.286 | 5.7 | 110 | 0.6 | 704 | 704.007 | 0.621344 | 0.000739038 | 5.80145
2 x RAFTER | Z/1849 | 18 deg | +4.823 | +5.282 | 5.7 | 110 | 0.6 | 704 | 704.007 | 0.621344 | 0.000739038 | 5.80145
2 x RAFTER | Z/1849 | 18 deg | +4.819 | +5.278 | 5.7 | 110 | 0.6 | 704 | 704.007 | 0.621344 | 0.000739038 | 5.80145
2 x RAFTER | Z/1844 | 15 deg | +4.818 | +5.241 | 5.4 | 110 | 0.6 | 686 | 686.037 | 0.605538 | 0.000720174 | 5.65337
2 x RAFTER | Z/1844 | 15 deg | +4.811 | +5.234 | 5.4 | 110 | 0.6 | 686 | 686.037 | 0.605538 | 0.000720174 | 5.65337
2 x RAFTER | Z/1844 | 15 deg | +4.808 | +5.231 | 5.4 | 110 | 0.6 | 686 | 686.037 | 0.605538 | 0.000720174 | 5.65337
2 x RAFTER | Z/1844 | 15 deg | +4.804 | +5.227 | 5.4 | 110 | 0.6 | 686 | 686.037 | 0.605538 | 0.000720174 | 5.65337
8 x RAFTER | Z/2055 | 12 deg | +4.283 | +4.687 | 6 | 110 | 0.6 | 745.4 | 745.377 | 0.657733 | 0.000782467 | 6.14237
2 x RAFTER | Z/1791 | 12 deg | +4.802 | +5.189 | 5.4 | 110 | 0.6 | 670.2 | 670.197 | 0.591605 | 0.000703546 | 5.52284
2 x RAFTER | Z/1791 | 12 deg | +4.796 | +5.184 | 5.4 | 110 | 0.6 | 670.2 | 670.197 | 0.591605 | 0.000703546 | 5.52284
2 x RAFTER | Z/1791 | 12 deg | +4.794 | +5.181 | 5.4 | 110 | 0.6 | 670.2 | 670.197 | 0.591605 | 0.000703546 | 5.52284
2 x RAFTER | Z/1791 | 12 deg | +4.791 | +5.179 | 5.4 | 110 | 0.6 | 670.2 | 670.197 | 0.591605 | 0.000703546 | 5.52284
2 x RAFTER | Z/2068 | 9 deg | +4.786 | +5.508 | 24.1 | 109.7 | 2.6 | 3009.4 | 3009.42 | 2.64918 | 0.00315917 | 24.7995
2 x RAFTER | Z/2067 | 9 deg | +4.782 | +5.508 | 24.3 | 109.7 | 2.7 | 3034.7 | 3034.73 | 2.67145 | 0.00318574 | 25.008
2 x RAFTER | Z/2059 | 9 deg | +4.780 | +5.508 | 24.4 | 109.7 | 2.7 | 3047.4 | 3047.39 | 2.68258 | 0.00319903 | 25.1124
2 x RAFTER | Z/2066 | 9 deg | +4.778 | +5.508 | 24.4 | 109.7 | 2.7 | 3060 | 3060.04 | 2.69371 | 0.0032123 | 25.2166
2 x RAFTER | Z/2065 | 5 deg | +4.767 | +5.278 | 23.8 | 109.7 | 2.6 | 2960.4 | 2960.4 | 2.60607 | 0.00310771 | 24.3955
2 x RAFTER | Z/2064 | 5 deg | +4.765 | +5.278 | 24 | 109.7 | 2.6 | 2985.5 | 2985.49 | 2.62813 | 0.00313405 | 24.6023
2 x RAFTER | Z/2058 | 5 deg | +4.764 | +5.278 | 24.1 | 109.7 | 2.6 | 2998 | 2998.04 | 2.63917 | 0.00314722 | 24.7057
2 x RAFTER | Z/2063 | 5 deg | +4.763 | +5.278 | 24.3 | 109.7 | 2.7 | 3010.6 | 3010.59 | 2.65021 | 0.00316039 | 24.8091
2 x RAFTER | Z/2062 | 3 deg | +4.758 | +5.166 | 23.8 | 109.7 | 2.6 | 2950.3 | 2950.33 | 2.59721 | 0.00309714 | 24.3125
2 x RAFTER | Z/2061 | 3 deg | +4.757 | +5.166 | 24 | 109.7 | 2.6 | 2975.4 | 2975.37 | 2.61923 | 0.00312342 | 24.5189
2 x RAFTER | Z/2057 | 3 deg | +4.756 | +5.166 | 24 | 109.7 | 2.6 | 2987.9 | 2987.88 | 2.63024 | 0.00313655 | 24.622
2 x RAFTER | Z/2060 | 3 deg | +4.756 | +5.166 | 24.1 | 109.7 | 2.6 | 3000.4 | 3000.4 | 2.64125 | 0.0031497 | 24.7251

# IfcBeam: C:300-30 (90)
In: Undefined
Description: C:300-30; Material: STEEL/G450
Tekla Common - Phase: 1; Class: 10
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 300 mm; Width: 96 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Finish | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
10 x RAFTER | Z/2110 | 12 deg | +4.274 | +4.689 | 8.6 | 87.7 | 0.8 | 688.6 | 688.569 | 0.755176 | 0.00112168 | 8.80518
2 x RAFTER | Z/1804 | 12 deg | +4.749 | +5.155 | 8 | 87.7 | 0.6 | 636.9 | 636.899 | 0.698752 | 0.00103751 | 8.14444
2 x RAFTER | Z/1804 | 12 deg | +4.751 | +5.157 | 8 | 87.7 | 0.6 | 636.9 | 636.899 | 0.698752 | 0.00103751 | 8.14444
2 x RAFTER | Z/1804 | 12 deg | +4.754 | +5.160 | 8 | 87.7 | 0.6 | 636.9 | 636.899 | 0.698752 | 0.00103751 | 8.14444
2 x RAFTER | Z/1804 | 12 deg | +4.759 | +5.165 | 8 | 87.7 | 0.6 | 636.9 | 636.899 | 0.698752 | 0.00103751 | 8.14444
2 x RAFTER | Z/1804 | 12 deg | +4.765 | +5.171 | 8 | 87.7 | 0.6 | 636.9 | 636.899 | 0.698752 | 0.00103751 | 8.14444
2 x RAFTER | Z/1866 | 18 deg | +4.807 | +5.298 | 8.3 | 87.7 | 0.6 | 664.9 | 664.879 | 0.729306 | 0.00108309 | 8.50224
2 x RAFTER | Z/1866 | 18 deg | +4.799 | +5.290 | 8.3 | 87.7 | 0.6 | 664.9 | 664.879 | 0.729306 | 0.00108309 | 8.50224
2 x RAFTER | Z/1866 | 18 deg | +4.791 | +5.282 | 8.3 | 87.7 | 0.6 | 664.9 | 664.879 | 0.729306 | 0.00108309 | 8.50224
2 x RAFTER | Z/1866 | 18 deg | +4.787 | +5.278 | 8.3 | 87.7 | 0.6 | 664.9 | 664.879 | 0.729306 | 0.00108309 | 8.50224
2 x RAFTER | Z/1866 | 18 deg | +4.783 | +5.274 | 8.3 | 87.7 | 0.6 | 664.9 | 664.879 | 0.729306 | 0.00108309 | 8.50224
2 x RAFTER | Z/1860 | 15 deg | +4.787 | +5.245 | 8 | 87.7 | 0.6 | 649.9 | 649.899 | 0.712948 | 0.00105869 | 8.31068
2 x RAFTER | Z/1860 | 15 deg | +4.780 | +5.238 | 8 | 87.7 | 0.6 | 649.9 | 649.899 | 0.712948 | 0.00105869 | 8.31068
2 x RAFTER | Z/1860 | 15 deg | +4.773 | +5.231 | 8 | 87.7 | 0.6 | 649.9 | 649.899 | 0.712948 | 0.00105869 | 8.31068
2 x RAFTER | Z/1860 | 15 deg | +4.770 | +5.228 | 8 | 87.7 | 0.6 | 649.9 | 649.899 | 0.712948 | 0.00105869 | 8.31068
2 x RAFTER | Z/1860 | 15 deg | +4.766 | +5.224 | 8 | 87.7 | 0.6 | 649.9 | 649.899 | 0.712948 | 0.00105869 | 8.31068
10 x RAFTER | Z/2110 | 12 deg | +4.248 | +4.685 | 8.6 | 87.7 | 0.8 | 688.6 | 688.569 | 0.755176 | 0.00112168 | 8.80518
2 x RAFTER | Z/1804 | 12 deg | +4.767 | +5.193 | 8 | 87.7 | 0.6 | 636.9 | 636.899 | 0.698752 | 0.00103751 | 8.14444
2 x RAFTER | Z/1804 | 12 deg | +4.762 | +5.188 | 8 | 87.7 | 0.6 | 636.9 | 636.899 | 0.698752 | 0.00103751 | 8.14444
2 x RAFTER | Z/1804 | 12 deg | +4.756 | +5.182 | 8 | 87.7 | 0.6 | 636.9 | 636.899 | 0.698752 | 0.00103751 | 8.14444
2 x RAFTER | Z/1804 | 12 deg | +4.754 | +5.180 | 8 | 87.7 | 0.6 | 636.9 | 636.899 | 0.698752 | 0.00103751 | 8.14444
2 x RAFTER | Z/1804 | 12 deg | +4.751 | +5.177 | 8 | 87.7 | 0.6 | 636.9 | 636.899 | 0.698752 | 0.00103751 | 8.14444
2 x RAFTER | Z/2114 | 9 deg | +4.749 | +5.507 | 36.9 | 87.5 | 3.2 | 2953.5 | 2953.52 | 3.2285 | 0.00481128 | 37.7686
2 x RAFTER | Z/2126 | 9 deg | +4.745 | +5.507 | 37.3 | 87.5 | 3.3 | 2978.8 | 2978.84 | 3.25615 | 0.00485253 | 38.0924
2 x RAFTER | Z/2125 | 9 deg | +4.741 | +5.507 | 37.6 | 87.5 | 3.3 | 3004.1 | 3004.15 | 3.28379 | 0.00489376 | 38.416
2 x RAFTER | Z/2117 | 9 deg | +4.739 | +5.507 | 37.7 | 87.5 | 3.3 | 3016.8 | 3016.8 | 3.2976 | 0.00491437 | 38.5778
2 x RAFTER | Z/2124 | 9 deg | +4.737 | +5.507 | 37.9 | 87.5 | 3.3 | 3029.5 | 3029.46 | 3.31143 | 0.00493499 | 38.7397
2 x RAFTER | Z/2113 | 5 deg | +4.726 | +5.278 | 36.4 | 87.5 | 3.2 | 2908.2 | 2908.19 | 3.179 | 0.00473744 | 37.1889
2 x RAFTER | Z/2123 | 5 deg | +4.724 | +5.278 | 36.7 | 87.5 | 3.2 | 2933.3 | 2933.28 | 3.2064 | 0.00477831 | 37.5098
2 x RAFTER | Z/2122 | 5 deg | +4.722 | +5.278 | 37 | 87.5 | 3.2 | 2958.4 | 2958.38 | 3.23381 | 0.0048192 | 37.8307
2 x RAFTER | Z/2116 | 5 deg | +4.721 | +5.278 | 37.2 | 87.5 | 3.2 | 2970.9 | 2970.92 | 3.2475 | 0.00483963 | 37.9911
2 x RAFTER | Z/2121 | 5 deg | +4.720 | +5.278 | 37.3 | 87.5 | 3.3 | 2983.5 | 2983.47 | 3.26121 | 0.00486007 | 38.1516
2 x RAFTER | Z/2112 | 3 deg | +4.715 | +5.167 | 36.4 | 87.5 | 3.2 | 2899.8 | 2899.85 | 3.16989 | 0.00472385 | 37.0823
2 x RAFTER | Z/2120 | 3 deg | +4.714 | +5.167 | 36.6 | 87.5 | 3.2 | 2924.9 | 2924.89 | 3.19724 | 0.00476465 | 37.4025
2 x RAFTER | Z/2119 | 3 deg | +4.713 | +5.167 | 36.9 | 87.5 | 3.2 | 2949.9 | 2949.92 | 3.22457 | 0.00480542 | 37.7225
2 x RAFTER | Z/2115 | 3 deg | +4.712 | +5.167 | 37 | 87.5 | 3.2 | 2962.4 | 2962.44 | 3.23824 | 0.00482581 | 37.8826
2 x RAFTER | Z/2118 | 3 deg | +4.711 | +5.167 | 37.2 | 87.5 | 3.3 | 2974.9 | 2974.95 | 3.2519 | 0.00484619 | 38.0426

# IfcBeam: C:350-30 (90)
In: Undefined
Description: C:350-30; Material: STEEL/G450
Tekla Common - Phase: 1; Class: 10
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 350 mm; Width: 125 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Finish | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
10 x RAFTER | Z/2176 | 12 deg | +4.234 | +4.688 | 9.4 | 87.5 | 0.8 | 626.8 | 626.821 | 0.820009 | 0.00121854 | 9.56554
2 x RAFTER | Z/1818 | 12 deg | +4.705 | +5.154 | 9 | 87.5 | 0.8 | 600.7 | 600.711 | 0.786014 | 0.00116778 | 9.16709
2 x RAFTER | Z/1818 | 12 deg | +4.708 | +5.157 | 9 | 87.5 | 0.8 | 600.7 | 600.711 | 0.786014 | 0.00116778 | 9.16709
2 x RAFTER | Z/1818 | 12 deg | +4.710 | +5.159 | 9 | 87.5 | 0.8 | 600.7 | 600.711 | 0.786014 | 0.00116778 | 9.16709
2 x RAFTER | Z/1818 | 12 deg | +4.716 | +5.165 | 9 | 87.5 | 0.8 | 600.7 | 600.711 | 0.786014 | 0.00116778 | 9.16709
2 x RAFTER | Z/1818 | 12 deg | +4.721 | +5.170 | 9 | 87.5 | 0.8 | 600.7 | 600.711 | 0.786014 | 0.00116778 | 9.16709
2 x RAFTER | Z/1884 | 18 deg | +4.768 | +5.293 | 9.2 | 87.5 | 0.8 | 622.4 | 622.351 | 0.814189 | 0.00120985 | 9.49733
2 x RAFTER | Z/1884 | 18 deg | +4.760 | +5.285 | 9.2 | 87.5 | 0.8 | 622.4 | 622.351 | 0.814189 | 0.00120985 | 9.49733
2 x RAFTER | Z/1884 | 18 deg | +4.752 | +5.277 | 9.2 | 87.5 | 0.8 | 622.4 | 622.351 | 0.814189 | 0.00120985 | 9.49733
2 x RAFTER | Z/1884 | 18 deg | +4.748 | +5.273 | 9.2 | 87.5 | 0.8 | 622.4 | 622.351 | 0.814189 | 0.00120985 | 9.49733
2 x RAFTER | Z/1884 | 18 deg | +4.743 | +5.269 | 9.2 | 87.5 | 0.8 | 622.4 | 622.351 | 0.814189 | 0.00120985 | 9.49733
2 x RAFTER | Z/1878 | 15 deg | +4.745 | +5.241 | 9 | 87.5 | 0.8 | 610.6 | 610.621 | 0.798917 | 0.00118705 | 9.31832
2 x RAFTER | Z/1878 | 15 deg | +4.738 | +5.234 | 9 | 87.5 | 0.8 | 610.6 | 610.621 | 0.798917 | 0.00118705 | 9.31832
2 x RAFTER | Z/1878 | 15 deg | +4.732 | +5.228 | 9 | 87.5 | 0.8 | 610.6 | 610.621 | 0.798917 | 0.00118705 | 9.31832
2 x RAFTER | Z/1878 | 15 deg | +4.728 | +5.224 | 9 | 87.5 | 0.8 | 610.6 | 610.621 | 0.798917 | 0.00118705 | 9.31832
2 x RAFTER | Z/1878 | 15 deg | +4.725 | +5.221 | 9 | 87.5 | 0.8 | 610.6 | 610.621 | 0.798917 | 0.00118705 | 9.31832
10 x RAFTER | Z/2176 | 12 deg | +4.210 | +4.683 | 9.4 | 87.5 | 0.8 | 626.8 | 626.821 | 0.820009 | 0.00121854 | 9.56554
2 x RAFTER | Z/1818 | 12 deg | +4.724 | +5.191 | 9 | 87.5 | 0.8 | 600.7 | 600.711 | 0.786014 | 0.00116778 | 9.16709
2 x RAFTER | Z/1818 | 12 deg | +4.718 | +5.185 | 9 | 87.5 | 0.8 | 600.7 | 600.711 | 0.786014 | 0.00116778 | 9.16709
2 x RAFTER | Z/1818 | 12 deg | +4.713 | +5.180 | 9 | 87.5 | 0.8 | 600.7 | 600.711 | 0.786014 | 0.00116778 | 9.16709
2 x RAFTER | Z/1818 | 12 deg | +4.710 | +5.177 | 9 | 87.5 | 0.8 | 600.7 | 600.711 | 0.786014 | 0.00116778 | 9.16709
2 x RAFTER | Z/1818 | 12 deg | +4.708 | +5.175 | 9 | 87.5 | 0.8 | 600.7 | 600.711 | 0.786014 | 0.00116778 | 9.16709
2 x RAFTER | Z/2180 | 9 deg | +4.703 | +5.506 | 43.7 | 87.2 | 3.8 | 2920.3 | 2920.29 | 3.80611 | 0.00567705 | 44.5648
2 x RAFTER | Z/2232 | 9 deg | +4.699 | +5.506 | 44 | 87.2 | 3.8 | 2945.6 | 2945.6 | 3.83906 | 0.00572625 | 44.9511
2 x RAFTER | Z/2231 | 9 deg | +4.695 | +5.506 | 44.4 | 87.2 | 3.9 | 2970.9 | 2970.92 | 3.87203 | 0.00577547 | 45.3374
2 x RAFTER | Z/2216 | 9 deg | +4.694 | +5.506 | 44.6 | 87.2 | 3.9 | 2983.6 | 2983.57 | 3.8885 | 0.00580006 | 45.5305
2 x RAFTER | Z/2230 | 9 deg | +4.692 | +5.506 | 44.8 | 87.2 | 3.9 | 2996.2 | 2996.23 | 3.90498 | 0.00582467 | 45.7237
2 x RAFTER | Z/2179 | 5 deg | +4.678 | +5.278 | 43 | 87.2 | 3.8 | 2878.7 | 2878.71 | 3.75197 | 0.00559622 | 43.9303
2 x RAFTER | Z/2229 | 5 deg | +4.676 | +5.278 | 43.4 | 87.2 | 3.8 | 2903.8 | 2903.81 | 3.78465 | 0.00564501 | 44.3133
2 x RAFTER | Z/2228 | 5 deg | +4.674 | +5.278 | 43.8 | 87.2 | 3.8 | 2928.9 | 2928.9 | 3.81732 | 0.00569378 | 44.6962
2 x RAFTER | Z/2205 | 5 deg | +4.673 | +5.278 | 44 | 87.2 | 3.8 | 2941.5 | 2941.45 | 3.83366 | 0.00571818 | 44.8877
2 x RAFTER | Z/2227 | 5 deg | +4.672 | +5.278 | 44.2 | 87.2 | 3.8 | 2954 | 2954 | 3.85 | 0.00574258 | 45.0792
2 x RAFTER | Z/2178 | 3 deg | +4.667 | +5.167 | 43 | 87.2 | 3.7 | 2872.2 | 2872.2 | 3.74349 | 0.00558356 | 43.8309
2 x RAFTER | Z/2226 | 3 deg | +4.665 | +5.167 | 43.3 | 87.2 | 3.8 | 2897.2 | 2897.23 | 3.77608 | 0.00563222 | 44.2129
2 x RAFTER | Z/2225 | 3 deg | +4.664 | +5.167 | 43.7 | 87.2 | 3.8 | 2922.3 | 2922.26 | 3.80867 | 0.00568088 | 44.5949
2 x RAFTER | Z/2194 | 3 deg | +4.663 | +5.167 | 44 | 87.2 | 3.8 | 2934.8 | 2934.78 | 3.82497 | 0.00570522 | 44.7859
2 x RAFTER | Z/2224 | 3 deg | +4.663 | +5.167 | 44.1 | 87.2 | 3.8 | 2947.3 | 2947.3 | 3.84127 | 0.00572955 | 44.977

# IfcBeam: TH:75-95 (200)
In: Undefined
Description: TH:75-95; Material: STEEL/300PLUS
Default - ASSEMBLY_POS: B/5
Tekla Common - Phase: 1; Class: 4
Tekla Quantity - Weight: 1.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 0 m2; Net surface area: 0.5 m2; Height: 75 mm; Width: 125 mm; Length: 1000 mm
Pset_BeamCommon - LoadBearing: no; Reference: B/5
BaseQuantities - Length: 1000 mm; OuterSurfaceArea: 4.5602e-07 m2; NetVolume: 0.000231901 m3; NetWeight: 1.82042 kg
Name | Bottom elevation | Top elevation
5 x TH | +4.570 | +4.658
5 x TH | +4.566 | +4.654
4 x TH | +4.561 | +4.649
2 x TH | +4.549 | +4.636
4 x TH | +4.553 | +4.640
TH | +5.146 | +5.234
TH | +5.145 | +5.233
TH | +5.141 | +5.229
TH | +5.140 | +5.228
TH | +5.139 | +5.227
TH | +5.136 | +5.223
TH | +5.135 | +5.223
TH | +5.134 | +5.222
3 x TH | +5.133 | +5.221
TH | +5.127 | +5.215
TH | +5.132 | +5.220
TH | +5.131 | +5.219
TH | +5.130 | +5.218
TH | +5.129 | +5.217
TH | +5.129 | +5.216
2 x TH | +5.125 | +5.213
TH | +5.122 | +5.210
5 x TH | +4.545 | +4.635
5 x TH | +4.539 | +4.629
4 x TH | +4.534 | +4.624
2 x TH | +4.519 | +4.609
4 x TH | +4.523 | +4.614
5 x TH | +5.126 | +5.212
5 x TH | +5.122 | +5.208
4 x TH | +5.118 | +5.205
2 x TH | +5.114 | +5.201
4 x TH | +5.111 | +5.197
5 x TH | +5.073 | +5.155
5 x TH | +5.071 | +5.153
4 x TH | +5.069 | +5.150
2 x TH | +5.067 | +5.149
4 x TH | +5.065 | +5.146
5 x TH | +5.041 | +5.120
5 x TH | +5.039 | +5.118
4 x TH | +5.038 | +5.117
2 x TH | +5.037 | +5.116
4 x TH | +5.035 | +5.114
TH | +5.407 | +5.509
TH | +5.409 | +5.511
TH | +5.396 | +5.498
TH | +5.398 | +5.500
TH | +5.399 | +5.501
TH | +5.384 | +5.486
TH | +5.386 | +5.488
TH | +5.388 | +5.490
TH | +5.378 | +5.480
2 x TH | +5.380 | +5.482
TH | +5.382 | +5.484
2 x TH | +5.372 | +5.474
2 x TH | +5.374 | +5.476
TH | +5.376 | +5.478
TH | +5.390 | +5.492
TH | +5.392 | +5.494
TH | +5.247 | +5.343
TH | +5.248 | +5.344
TH | +5.239 | +5.335
TH | +5.239 | +5.336
TH | +5.240 | +5.336
2 x TH | +5.231 | +5.327
TH | +5.232 | +5.328
TH | +5.226 | +5.323
TH | +5.227 | +5.323
TH | +5.228 | +5.324
TH | +5.222 | +5.319
TH | +5.223 | +5.319
TH | +5.224 | +5.320
TH | +5.233 | +5.329
TH | +5.233 | +5.330
TH | +5.225 | +5.321
TH | +5.221 | +5.317
TH | +5.189 | +5.283
TH | +5.189 | +5.282
TH | +5.183 | +5.276
TH | +5.201 | +5.295
TH | +5.202 | +5.295
3 x TH | +5.195 | +5.288
TH | +5.188 | +5.281
2 x TH | +5.188 | +5.282
3 x TH | +5.185 | +5.278
TH | +5.181 | +5.274
2 x TH | +5.182 | +5.275
TH | +5.179 | +5.273
2 x TH | +5.163 | +5.253
3 x TH | +5.157 | +5.247
4 x TH | +5.152 | +5.242
TH | +5.153 | +5.243
4 x TH | +5.147 | +5.237
3 x TH | +5.149 | +5.239
TH | +5.144 | +5.234
TH | +5.145 | +5.235
TH | +5.369 | +5.471
TH | +5.220 | +5.317
TH | +5.217 | +5.313
TH | +5.179 | +5.272
TH | +5.176 | +5.269
TH | +5.142 | +5.232

# IfcColumn: D16 (2)
In: Undefined
Description: D16; Material: STEEL/300
Default - ASSEMBLY_POS: Z/65
Tekla Common - Bottom elevation: -0.119; Top elevation: +0.031; Phase: 1; Class: 1
Tekla Quantity - Weight: 0.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 36.2 m2; Net surface area: 0 m2; Height: 16 mm; Width: 16 mm; Length: 150 mm
Pset_ColumnCommon - LoadBearing: no; Reference: Z/65
BaseQuantities - Length: 150 mm; OuterSurfaceArea: 0.00770956 m2; NetVolume: 0.0000271529 m3; NetWeight: 0.21315 kg

# IfcColumn: RHS:100x50x5.0 (26)
In: Undefined
Description: RHS:100x50x5.0; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Phase: 1; Class: 12
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 27.1 m2; Height: 100 mm; Width: 50 mm
Pset_ColumnCommon - LoadBearing: no
Name | Finish | Top elevation | ASSEMBLY_POS = Reference | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
4 x COLUMN | 12 deg | +5.163 | Z/1787 | 53.1 | 1.5 | 5163.1 | 5163.14 | 1.44052 | 0.0072284 | 56.7429
4 x COLUMN | 12 deg | +5.063 | Z/1780 | 52.1 | 1.5 | 5063.1 | 5063.14 | 1.41262 | 0.0070884 | 55.6439
2 x COLUMN | 25 deg | +5.163 | Z/1798 | 53.1 | 1.5 | 5163.1 | 5163.14 | 1.44052 | 0.0072284 | 56.7429
2 x COLUMN | 18 deg | +5.113 | Z/1828 | 52.6 | 1.5 | 5113.1 | 5113.14 | 1.42657 | 0.0071584 | 56.1934
2 x COLUMN | 15 deg | +5.063 | Z/1811 | 52.1 | 1.5 | 5063.1 | 5063.14 | 1.41262 | 0.0070884 | 55.6439
2 x COLUMN | 9 deg | +5.713 | Z/1856 | 58.8 | 1.7 | 5713.1 | 5713.14 | 1.59397 | 0.0079984 | 62.7874
2 x COLUMN | 9 deg | +5.163 | Z/1855 | 53.1 | 1.5 | 5163.1 | 5163.14 | 1.44052 | 0.0072284 | 56.7429
2 x COLUMN | 5 deg | +5.413 | Z/1837 | 55.7 | 1.6 | 5413.1 | 5413.14 | 1.51027 | 0.0075784 | 59.4904
2 x COLUMN | 5 deg | +5.163 | Z/1832 | 53.1 | 1.5 | 5163.1 | 5163.14 | 1.44052 | 0.0072284 | 56.7429
2 x COLUMN | 3 deg | +5.313 | Z/1813 | 54.6 | 1.6 | 5313.1 | 5313.14 | 1.48237 | 0.0074384 | 58.3914
2 x COLUMN | 3 deg | +5.163 | Z/1812 | 53.1 | 1.5 | 5163.1 | 5163.14 | 1.44052 | 0.0072284 | 56.7429

# IfcColumn: RHS:150x100x5.0 (78)
In: Undefined
Description: RHS:150x100x5.0; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Phase: 1; Class: 12
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 26.4 m2; Height: 150 mm; Width: 100 mm
Pset_ColumnCommon - LoadBearing: no
Name | Finish | Top elevation | ASSEMBLY_POS = Reference | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
4 x COLUMN | 12 deg | +5.163 | Z/2183 | 93.6 | 2.6 | 5163 | 5163.04 | 2.47309 | 0.0123913 | 97.2716
4 x COLUMN | 12 deg | +5.113 | Z/1821 | 92.7 | 2.5 | 5113 | 5113.04 | 2.44914 | 0.0122713 | 96.3296
4 x COLUMN | 12 deg | +5.163 | Z/2129 | 93.6 | 2.6 | 5162.8 | 5162.81 | 2.47299 | 0.0123907 | 97.2673
4 x COLUMN | 12 deg | +5.113 | Z/1807 | 92.7 | 2.5 | 5112.8 | 5112.81 | 2.44904 | 0.0122707 | 96.3253
4 x COLUMN | 12 deg | +5.163 | Z/2071 | 93.6 | 2.6 | 5163.3 | 5163.25 | 2.4732 | 0.0123918 | 97.2756
4 x COLUMN | 12 deg | +5.063 | Z/1794 | 91.8 | 2.5 | 5063.2 | 5063.25 | 2.4253 | 0.0121518 | 95.3916
2 x COLUMN | 25 deg | +5.163 | Z/2188 | 93.6 | 2.6 | 5163 | 5163.04 | 2.47309 | 0.0123913 | 97.2716
2 x COLUMN | 25 deg | +5.163 | Z/2134 | 93.6 | 2.6 | 5162.8 | 5162.81 | 2.47299 | 0.0123907 | 97.2673
2 x COLUMN | 25 deg | +5.163 | Z/2075 | 93.6 | 2.6 | 5163.3 | 5163.25 | 2.4732 | 0.0123918 | 97.2756
2 x COLUMN | 18 deg | +5.113 | Z/1886 | 92.7 | 2.5 | 5113 | 5113.04 | 2.44914 | 0.0122713 | 96.3296
2 x COLUMN | 18 deg | +5.163 | Z/1868 | 93.6 | 2.6 | 5162.8 | 5162.81 | 2.47299 | 0.0123907 | 97.2673
2 x COLUMN | 18 deg | +5.113 | Z/1851 | 92.7 | 2.5 | 5113.2 | 5113.25 | 2.44925 | 0.0122718 | 96.3336
2 x COLUMN | 15 deg | +5.113 | Z/1880 | 92.7 | 2.5 | 5113 | 5113.04 | 2.44914 | 0.0122713 | 96.3296
2 x COLUMN | 15 deg | +5.163 | Z/1862 | 93.6 | 2.6 | 5162.8 | 5162.81 | 2.47299 | 0.0123907 | 97.2673
2 x COLUMN | 15 deg | +5.113 | Z/1846 | 92.7 | 2.5 | 5113.2 | 5113.25 | 2.44925 | 0.0122718 | 96.3336
2 x COLUMN | 9 deg | +5.613 | Z/2219 | 101.8 | 2.8 | 5613 | 5613.04 | 2.68864 | 0.0134713 | 105.75
2 x COLUMN | 9 deg | +5.163 | Z/2218 | 93.6 | 2.6 | 5163 | 5163.04 | 2.47309 | 0.0123913 | 97.2716
2 x COLUMN | 9 deg | +5.713 | Z/2162 | 103.6 | 2.8 | 5712.8 | 5712.81 | 2.73644 | 0.0137107 | 107.629
2 x COLUMN | 9 deg | +5.163 | Z/2161 | 93.6 | 2.6 | 5162.8 | 5162.81 | 2.47299 | 0.0123907 | 97.2673
2 x COLUMN | 9 deg | +5.613 | Z/2098 | 101.8 | 2.8 | 5613.3 | 5613.25 | 2.68875 | 0.0134718 | 105.754
2 x COLUMN | 9 deg | +5.163 | Z/2097 | 93.6 | 2.6 | 5163.3 | 5163.25 | 2.4732 | 0.0123918 | 97.2756
2 x COLUMN | 5 deg | +5.463 | Z/2208 | 99.1 | 2.7 | 5463 | 5463.04 | 2.61679 | 0.0131113 | 102.924
2 x COLUMN | 5 deg | +5.163 | Z/2207 | 93.6 | 2.6 | 5163 | 5163.04 | 2.47309 | 0.0123913 | 97.2716
2 x COLUMN | 5 deg | +5.463 | Z/2152 | 99.1 | 2.7 | 5462.8 | 5462.81 | 2.61669 | 0.0131107 | 102.919
2 x COLUMN | 5 deg | +5.163 | Z/2151 | 93.6 | 2.6 | 5162.8 | 5162.81 | 2.47299 | 0.0123907 | 97.2673
2 x COLUMN | 5 deg | +5.513 | Z/2090 | 100 | 2.7 | 5513.3 | 5513.25 | 2.64085 | 0.0132318 | 103.87
2 x COLUMN | 5 deg | +5.163 | Z/2089 | 93.6 | 2.6 | 5163.3 | 5163.25 | 2.4732 | 0.0123918 | 97.2756
2 x COLUMN | 3 deg | +5.563 | Z/2197 | 100.9 | 2.8 | 5563 | 5563.04 | 2.66469 | 0.0133513 | 104.808
2 x COLUMN | 3 deg | +5.163 | Z/2196 | 93.6 | 2.6 | 5163 | 5163.04 | 2.47309 | 0.0123913 | 97.2716
2 x COLUMN | 3 deg | +5.263 | Z/2142 | 95.4 | 2.6 | 5262.8 | 5262.81 | 2.52089 | 0.0126307 | 99.1513
2 x COLUMN | 3 deg | +5.163 | Z/2141 | 93.6 | 2.6 | 5162.8 | 5162.81 | 2.47299 | 0.0123907 | 97.2673
2 x COLUMN | 3 deg | +5.213 | Z/2082 | 94.5 | 2.6 | 5213.3 | 5213.25 | 2.49715 | 0.0125118 | 98.2176
2 x COLUMN | 3 deg | +5.163 | Z/2081 | 93.6 | 2.6 | 5163.3 | 5163.25 | 2.4732 | 0.0123918 | 97.2756

# IfcColumn: RHS:150x50x5.0 (52)
In: Undefined
Description: RHS:150x50x5.0; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Phase: 1; Class: 12
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 26.7 m2; Height: 150 mm; Width: 50 mm
Pset_ColumnCommon - LoadBearing: no
Name | Finish | Top elevation | ASSEMBLY_POS = Reference | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
4 x COLUMN | 12 deg | +5.113 | Z/2025 | 72.6 | 2 | 5113.2 | 5113.16 | 1.93789 | 0.009715 | 76.2628
4 x COLUMN | 12 deg | +5.063 | Z/1785 | 71.9 | 2 | 5063.2 | 5063.16 | 1.91894 | 0.00962 | 75.517
4 x COLUMN | 12 deg | +5.163 | Z/1788 | 73.4 | 2 | 5163.1 | 5163.14 | 1.95683 | 0.00980997 | 77.0082
4 x COLUMN | 12 deg | +5.063 | Z/1781 | 71.9 | 2 | 5063.1 | 5063.14 | 1.91893 | 0.00961997 | 75.5167
2 x COLUMN | 25 deg | +5.113 | Z/2027 | 72.6 | 2 | 5113.2 | 5113.16 | 1.93789 | 0.009715 | 76.2628
2 x COLUMN | 25 deg | +5.163 | Z/1799 | 73.4 | 2 | 5163.1 | 5163.14 | 1.95683 | 0.00980997 | 77.0082
2 x COLUMN | 18 deg | +5.113 | Z/1836 | 72.6 | 2 | 5113.2 | 5113.16 | 1.93789 | 0.009715 | 76.2628
2 x COLUMN | 18 deg | +5.113 | Z/1829 | 72.6 | 2 | 5113.1 | 5113.14 | 1.93788 | 0.00971497 | 76.2625
2 x COLUMN | 15 deg | +5.063 | Z/1834 | 71.9 | 2 | 5063.2 | 5063.16 | 1.91894 | 0.00962 | 75.517
2 x COLUMN | 15 deg | +5.063 | Z/1824 | 71.9 | 2 | 5063.1 | 5063.14 | 1.91893 | 0.00961997 | 75.5167
2 x COLUMN | 9 deg | +5.713 | Z/2039 | 81.2 | 2.2 | 5713.2 | 5713.16 | 2.16529 | 0.010855 | 85.2118
2 x COLUMN | 9 deg | +5.113 | Z/2038 | 72.6 | 2 | 5113.2 | 5113.16 | 1.93789 | 0.009715 | 76.2628
2 x COLUMN | 9 deg | +5.713 | Z/1871 | 81.2 | 2.2 | 5713.1 | 5713.14 | 2.16528 | 0.010855 | 85.2115
2 x COLUMN | 9 deg | +5.163 | Z/1857 | 73.4 | 2 | 5163.1 | 5163.14 | 1.95683 | 0.00980997 | 77.0082
2 x COLUMN | 5 deg | +5.463 | Z/2035 | 77.6 | 2.1 | 5463.2 | 5463.16 | 2.07054 | 0.01038 | 81.483
2 x COLUMN | 5 deg | +5.113 | Z/2034 | 72.6 | 2 | 5113.2 | 5113.16 | 1.93789 | 0.009715 | 76.2628
2 x COLUMN | 5 deg | +5.413 | Z/1839 | 76.9 | 2.1 | 5413.1 | 5413.14 | 2.05158 | 0.010285 | 80.737
2 x COLUMN | 5 deg | +5.163 | Z/1838 | 73.4 | 2 | 5163.1 | 5163.14 | 1.95683 | 0.00980997 | 77.0082
2 x COLUMN | 3 deg | +5.280 | Z/2031 | 75 | 2.1 | 5279.8 | 5279.83 | 2.00106 | 0.0100317 | 78.7487
2 x COLUMN | 3 deg | +5.113 | Z/2030 | 72.6 | 2 | 5113.2 | 5113.16 | 1.93789 | 0.009715 | 76.2628
2 x COLUMN | 3 deg | +5.313 | Z/1815 | 75.5 | 2.1 | 5313.1 | 5313.14 | 2.01368 | 0.010095 | 79.2455
2 x COLUMN | 3 deg | +5.163 | Z/1814 | 73.4 | 2 | 5163.1 | 5163.14 | 1.95683 | 0.00980997 | 77.0082

# IfcColumn: RHS:200x100x5.0 (78)
In: Undefined
Description: RHS:200x100x5.0; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Phase: 1; Class: 12
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 26.2 m2; Height: 200 mm; Width: 100 mm
Pset_ColumnCommon - LoadBearing: no
Name | Finish | Top elevation | ASSEMBLY_POS = Reference | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
4 x COLUMN | 12 deg | +5.163 | Z/2184 | 113.9 | 3.1 | 5163 | 5163.04 | 2.9894 | 0.0149728 | 117.537
4 x COLUMN | 12 deg | +5.113 | Z/1822 | 112.8 | 3 | 5113 | 5113.04 | 2.96045 | 0.0148278 | 116.398
4 x COLUMN | 12 deg | +5.163 | Z/2130 | 113.9 | 3.1 | 5162.8 | 5162.81 | 2.98927 | 0.0149721 | 117.531
4 x COLUMN | 12 deg | +5.113 | Z/1808 | 112.8 | 3 | 5112.8 | 5112.81 | 2.96032 | 0.0148271 | 116.393
4 x COLUMN | 12 deg | +5.163 | Z/2072 | 113.9 | 3.1 | 5163.3 | 5163.25 | 2.98952 | 0.0149734 | 117.541
4 x COLUMN | 12 deg | +5.063 | Z/1795 | 111.7 | 3 | 5063.2 | 5063.25 | 2.93162 | 0.0146834 | 115.265
2 x COLUMN | 25 deg | +5.163 | Z/2189 | 113.9 | 3.1 | 5163 | 5163.04 | 2.9894 | 0.0149728 | 117.537
2 x COLUMN | 25 deg | +5.163 | Z/2135 | 113.9 | 3.1 | 5162.8 | 5162.81 | 2.98927 | 0.0149721 | 117.531
2 x COLUMN | 25 deg | +5.163 | Z/2076 | 113.9 | 3.1 | 5163.3 | 5163.25 | 2.98952 | 0.0149734 | 117.541
2 x COLUMN | 18 deg | +5.113 | Z/1887 | 112.8 | 3 | 5113 | 5113.04 | 2.96045 | 0.0148278 | 116.398
2 x COLUMN | 18 deg | +5.163 | Z/1869 | 113.9 | 3.1 | 5162.8 | 5162.81 | 2.98927 | 0.0149721 | 117.531
2 x COLUMN | 18 deg | +5.113 | Z/1852 | 112.8 | 3 | 5113.2 | 5113.25 | 2.96057 | 0.0148284 | 116.403
2 x COLUMN | 15 deg | +5.113 | Z/1881 | 112.8 | 3 | 5113 | 5113.04 | 2.96045 | 0.0148278 | 116.398
2 x COLUMN | 15 deg | +5.163 | Z/1863 | 113.9 | 3.1 | 5162.8 | 5162.81 | 2.98927 | 0.0149721 | 117.531
2 x COLUMN | 15 deg | +5.113 | Z/1847 | 112.8 | 3 | 5113.2 | 5113.25 | 2.96057 | 0.0148284 | 116.403
2 x COLUMN | 9 deg | +5.613 | Z/2221 | 123.8 | 3.3 | 5613 | 5613.04 | 3.24995 | 0.0162778 | 127.781
2 x COLUMN | 9 deg | +5.163 | Z/2220 | 113.9 | 3.1 | 5163 | 5163.04 | 2.9894 | 0.0149728 | 117.537
2 x COLUMN | 9 deg | +5.713 | Z/2164 | 126 | 3.4 | 5712.8 | 5712.81 | 3.30772 | 0.0165671 | 130.052
2 x COLUMN | 9 deg | +5.163 | Z/2163 | 113.9 | 3.1 | 5162.8 | 5162.81 | 2.98927 | 0.0149721 | 117.531
2 x COLUMN | 9 deg | +5.613 | Z/2100 | 123.8 | 3.3 | 5613.3 | 5613.25 | 3.25007 | 0.0162784 | 127.786
2 x COLUMN | 9 deg | +5.163 | Z/2099 | 113.9 | 3.1 | 5163.3 | 5163.25 | 2.98952 | 0.0149734 | 117.541
2 x COLUMN | 5 deg | +5.463 | Z/2210 | 120.5 | 3.3 | 5463 | 5463.04 | 3.1631 | 0.0158428 | 124.366
2 x COLUMN | 5 deg | +5.163 | Z/2209 | 113.9 | 3.1 | 5163 | 5163.04 | 2.9894 | 0.0149728 | 117.537
2 x COLUMN | 5 deg | +5.463 | Z/2154 | 120.5 | 3.3 | 5462.8 | 5462.81 | 3.16297 | 0.0158421 | 124.361
2 x COLUMN | 5 deg | +5.163 | Z/2153 | 113.9 | 3.1 | 5162.8 | 5162.81 | 2.98927 | 0.0149721 | 117.531
2 x COLUMN | 5 deg | +5.513 | Z/2092 | 121.6 | 3.3 | 5513.3 | 5513.25 | 3.19217 | 0.0159884 | 125.509
2 x COLUMN | 5 deg | +5.163 | Z/2091 | 113.9 | 3.1 | 5163.3 | 5163.25 | 2.98952 | 0.0149734 | 117.541
2 x COLUMN | 3 deg | +5.563 | Z/2199 | 122.7 | 3.3 | 5563 | 5563.04 | 3.221 | 0.0161328 | 126.643
2 x COLUMN | 3 deg | +5.163 | Z/2198 | 113.9 | 3.1 | 5163 | 5163.04 | 2.9894 | 0.0149728 | 117.537
2 x COLUMN | 3 deg | +5.263 | Z/2144 | 116.1 | 3.1 | 5262.8 | 5262.81 | 3.04717 | 0.0152621 | 119.808
2 x COLUMN | 3 deg | +5.163 | Z/2143 | 113.9 | 3.1 | 5162.8 | 5162.81 | 2.98927 | 0.0149721 | 117.531
2 x COLUMN | 3 deg | +5.213 | Z/2084 | 115 | 3.1 | 5213.3 | 5213.25 | 3.01847 | 0.0151184 | 118.68
2 x COLUMN | 3 deg | +5.163 | Z/2083 | 113.9 | 3.1 | 5163.3 | 5163.25 | 2.98952 | 0.0149734 | 117.541

# IfcColumn: RHS:250x150x5.0 (52)
In: Undefined
Description: RHS:250x150x5.0; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Phase: 1; Class: 12
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 26 m2; Height: 250 mm; Width: 150 mm
Pset_ColumnCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Finish | Top elevation | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
4 x COLUMN | Z/2185 | 12 deg | +5.203 | 155.6 | 4.1 | 5203 | 5203.04 | 4.05317 | 0.0202918 | 159.291
4 x COLUMN | Z/1823 | 12 deg | +5.153 | 154.1 | 4.1 | 5153 | 5153.04 | 4.01422 | 0.0200968 | 157.76
4 x COLUMN | Z/2131 | 12 deg | +5.163 | 154.4 | 4.1 | 5162.8 | 5162.81 | 4.02183 | 0.020135 | 158.059
4 x COLUMN | Z/1809 | 12 deg | +5.113 | 152.9 | 4.1 | 5112.8 | 5112.81 | 3.98288 | 0.01994 | 156.529
2 x COLUMN | Z/2190 | 25 deg | +5.203 | 155.6 | 4.1 | 5203 | 5203.04 | 4.05317 | 0.0202918 | 159.291
2 x COLUMN | Z/2136 | 25 deg | +5.163 | 154.4 | 4.1 | 5162.8 | 5162.81 | 4.02183 | 0.020135 | 158.059
2 x COLUMN | Z/1888 | 18 deg | +5.153 | 154.1 | 4.1 | 5153 | 5153.04 | 4.01422 | 0.0200968 | 157.76
2 x COLUMN | Z/1870 | 18 deg | +5.163 | 154.4 | 4.1 | 5162.8 | 5162.81 | 4.02183 | 0.020135 | 158.059
2 x COLUMN | Z/1882 | 15 deg | +5.153 | 154.1 | 4.1 | 5153 | 5153.04 | 4.01422 | 0.0200968 | 157.76
2 x COLUMN | Z/1864 | 15 deg | +5.163 | 154.4 | 4.1 | 5162.8 | 5162.81 | 4.02183 | 0.020135 | 158.059
2 x COLUMN | Z/2223 | 9 deg | +5.653 | 169.1 | 4.5 | 5653 | 5653.04 | 4.40372 | 0.0220468 | 173.068
2 x COLUMN | Z/2222 | 9 deg | +5.203 | 155.6 | 4.1 | 5203 | 5203.04 | 4.05317 | 0.0202918 | 159.291
2 x COLUMN | Z/2166 | 9 deg | +5.713 | 170.9 | 4.6 | 5712.8 | 5712.81 | 4.45028 | 0.02228 | 174.898
2 x COLUMN | Z/2165 | 9 deg | +5.163 | 154.4 | 4.1 | 5162.8 | 5162.81 | 4.02183 | 0.020135 | 158.059
2 x COLUMN | Z/2212 | 5 deg | +5.503 | 164.6 | 4.5 | 5503 | 5503.04 | 4.28687 | 0.0214618 | 168.475
2 x COLUMN | Z/2211 | 5 deg | +5.203 | 155.6 | 4.1 | 5203 | 5203.04 | 4.05317 | 0.0202918 | 159.291
2 x COLUMN | Z/2156 | 5 deg | +5.463 | 163.4 | 4.5 | 5462.8 | 5462.81 | 4.25553 | 0.021305 | 167.244
2 x COLUMN | Z/2155 | 5 deg | +5.163 | 154.4 | 4.1 | 5162.8 | 5162.81 | 4.02183 | 0.020135 | 158.059
2 x COLUMN | Z/2201 | 3 deg | +5.603 | 167.6 | 4.5 | 5603 | 5603.04 | 4.36477 | 0.0218518 | 171.537
2 x COLUMN | Z/2200 | 3 deg | +5.203 | 155.6 | 4.1 | 5203 | 5203.04 | 4.05317 | 0.0202918 | 159.291
2 x COLUMN | Z/2146 | 3 deg | +5.263 | 157.4 | 4.1 | 5262.8 | 5262.81 | 4.09973 | 0.020525 | 161.121
2 x COLUMN | Z/2145 | 3 deg | +5.163 | 154.4 | 4.1 | 5162.8 | 5162.81 | 4.02183 | 0.020135 | 158.059

# IfcColumn: SHS:100x100x5.0 (78)
In: Undefined
Description: SHS:100x100x5.0; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Phase: 1; Class: 12
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 26.7 m2; Height: 100 mm; Width: 100 mm
Pset_ColumnCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Finish | Top elevation | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
4 x COLUMN | Z/2181 | 12 deg | +5.163 | 73.4 | 2.1 | 5163 | 5163.04 | 1.95679 | 0.00980977 | 77.0067
4 x COLUMN | Z/1819 | 12 deg | +5.113 | 72.6 | 2 | 5113 | 5113.04 | 1.93784 | 0.00971477 | 76.2609
4 x COLUMN | Z/2127 | 12 deg | +5.163 | 73.4 | 2.1 | 5162.8 | 5162.81 | 1.9567 | 0.00980934 | 77.0033
4 x COLUMN | Z/1805 | 12 deg | +5.063 | 71.9 | 2 | 5062.8 | 5062.81 | 1.9188 | 0.00961934 | 75.5118
4 x COLUMN | Z/2069 | 12 deg | +5.163 | 73.4 | 2.1 | 5163.3 | 5163.25 | 1.95687 | 0.00981018 | 77.0099
4 x COLUMN | Z/1792 | 12 deg | +5.063 | 71.9 | 2 | 5063.2 | 5063.25 | 1.91897 | 0.00962017 | 75.5184
2 x COLUMN | Z/2186 | 25 deg | +5.163 | 73.4 | 2.1 | 5163 | 5163.04 | 1.95679 | 0.00980977 | 77.0067
2 x COLUMN | Z/2132 | 25 deg | +5.163 | 73.4 | 2.1 | 5162.8 | 5162.81 | 1.9567 | 0.00980934 | 77.0033
2 x COLUMN | Z/2073 | 25 deg | +5.163 | 73.4 | 2.1 | 5163.3 | 5163.25 | 1.95687 | 0.00981018 | 77.0099
2 x COLUMN | Z/1883 | 18 deg | +5.113 | 72.6 | 2 | 5113 | 5113.04 | 1.93784 | 0.00971477 | 76.2609
2 x COLUMN | Z/1865 | 18 deg | +5.163 | 73.4 | 2.1 | 5162.8 | 5162.81 | 1.9567 | 0.00980934 | 77.0033
2 x COLUMN | Z/1848 | 18 deg | +5.113 | 72.6 | 2 | 5113.2 | 5113.25 | 1.93792 | 0.00971517 | 76.2641
2 x COLUMN | Z/1877 | 15 deg | +5.113 | 72.6 | 2 | 5113 | 5113.04 | 1.93784 | 0.00971477 | 76.2609
2 x COLUMN | Z/1859 | 15 deg | +5.163 | 73.4 | 2.1 | 5162.8 | 5162.81 | 1.9567 | 0.00980934 | 77.0033
2 x COLUMN | Z/1843 | 15 deg | +5.113 | 72.6 | 2 | 5113.2 | 5113.25 | 1.93792 | 0.00971517 | 76.2641
2 x COLUMN | Z/2214 | 9 deg | +5.613 | 79.8 | 2.2 | 5613 | 5613.04 | 2.12734 | 0.0106648 | 83.7184
2 x COLUMN | Z/2213 | 9 deg | +5.163 | 73.4 | 2.1 | 5163 | 5163.04 | 1.95679 | 0.00980977 | 77.0067
2 x COLUMN | Z/2158 | 9 deg | +5.713 | 81.2 | 2.3 | 5712.8 | 5712.81 | 2.16515 | 0.0108543 | 85.2066
2 x COLUMN | Z/2157 | 9 deg | +5.163 | 73.4 | 2.1 | 5162.8 | 5162.81 | 1.9567 | 0.00980934 | 77.0033
2 x COLUMN | Z/2094 | 9 deg | +5.613 | 79.8 | 2.2 | 5613.3 | 5613.25 | 2.12742 | 0.0106652 | 83.7216
2 x COLUMN | Z/2093 | 9 deg | +5.163 | 73.4 | 2.1 | 5163.3 | 5163.25 | 1.95687 | 0.00981018 | 77.0099
2 x COLUMN | Z/2203 | 5 deg | +5.463 | 77.6 | 2.2 | 5463 | 5463.04 | 2.07049 | 0.0103798 | 81.4812
2 x COLUMN | Z/2202 | 5 deg | +5.163 | 73.4 | 2.1 | 5163 | 5163.04 | 1.95679 | 0.00980977 | 77.0067
2 x COLUMN | Z/2148 | 5 deg | +5.463 | 77.6 | 2.2 | 5462.8 | 5462.81 | 2.0704 | 0.0103793 | 81.4778
2 x COLUMN | Z/2147 | 5 deg | +5.163 | 73.4 | 2.1 | 5162.8 | 5162.81 | 1.9567 | 0.00980934 | 77.0033
2 x COLUMN | Z/2086 | 5 deg | +5.513 | 78.3 | 2.2 | 5513.3 | 5513.25 | 2.08952 | 0.0104752 | 82.2301
2 x COLUMN | Z/2085 | 5 deg | +5.163 | 73.4 | 2.1 | 5163.3 | 5163.25 | 1.95687 | 0.00981018 | 77.0099
2 x COLUMN | Z/2192 | 3 deg | +5.563 | 79 | 2.2 | 5563 | 5563.04 | 2.10839 | 0.0105698 | 82.9727
2 x COLUMN | Z/2191 | 3 deg | +5.163 | 73.4 | 2.1 | 5163 | 5163.04 | 1.95679 | 0.00980977 | 77.0067
2 x COLUMN | Z/2138 | 3 deg | +5.263 | 74.8 | 2.1 | 5262.8 | 5262.81 | 1.9946 | 0.00999934 | 78.4948
2 x COLUMN | Z/2137 | 3 deg | +5.163 | 73.4 | 2.1 | 5162.8 | 5162.81 | 1.9567 | 0.00980934 | 77.0033
2 x COLUMN | Z/2078 | 3 deg | +5.213 | 74.1 | 2.1 | 5213.3 | 5213.25 | 1.97582 | 0.00990518 | 77.7556
2 x COLUMN | Z/2077 | 3 deg | +5.163 | 73.4 | 2.1 | 5163.3 | 5163.25 | 1.95687 | 0.00981018 | 77.0099

# IfcColumn: SHS:125x125x5.0 (78)
In: Undefined
Description: SHS:125x125x5.0; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Phase: 1; Class: 12
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 26.4 m2; Height: 125 mm; Width: 125 mm
Pset_ColumnCommon - LoadBearing: no
Name | Finish | Top elevation | ASSEMBLY_POS = Reference | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
4 x COLUMN | 12 deg | +5.163 | Z/2182 | 93.6 | 2.6 | 5163 | 5163.04 | 2.47309 | 0.0123913 | 97.2716
4 x COLUMN | 12 deg | +5.113 | Z/1820 | 92.7 | 2.6 | 5113 | 5113.04 | 2.44914 | 0.0122713 | 96.3296
4 x COLUMN | 12 deg | +5.163 | Z/2128 | 93.6 | 2.6 | 5162.8 | 5162.81 | 2.47299 | 0.0123907 | 97.2673
4 x COLUMN | 12 deg | +5.063 | Z/1806 | 91.8 | 2.5 | 5062.8 | 5062.81 | 2.42509 | 0.0121507 | 95.3833
4 x COLUMN | 12 deg | +5.163 | Z/2070 | 93.6 | 2.6 | 5163.3 | 5163.25 | 2.4732 | 0.0123918 | 97.2756
4 x COLUMN | 12 deg | +5.063 | Z/1793 | 91.8 | 2.5 | 5063.2 | 5063.25 | 2.4253 | 0.0121518 | 95.3916
2 x COLUMN | 25 deg | +5.163 | Z/2187 | 93.6 | 2.6 | 5163 | 5163.04 | 2.47309 | 0.0123913 | 97.2716
2 x COLUMN | 25 deg | +5.163 | Z/2133 | 93.6 | 2.6 | 5162.8 | 5162.81 | 2.47299 | 0.0123907 | 97.2673
2 x COLUMN | 25 deg | +5.163 | Z/2074 | 93.6 | 2.6 | 5163.3 | 5163.25 | 2.4732 | 0.0123918 | 97.2756
2 x COLUMN | 18 deg | +5.113 | Z/1885 | 92.7 | 2.6 | 5113 | 5113.04 | 2.44914 | 0.0122713 | 96.3296
2 x COLUMN | 18 deg | +5.163 | Z/1867 | 93.6 | 2.6 | 5162.8 | 5162.81 | 2.47299 | 0.0123907 | 97.2673
2 x COLUMN | 18 deg | +5.113 | Z/1850 | 92.7 | 2.6 | 5113.2 | 5113.25 | 2.44925 | 0.0122718 | 96.3336
2 x COLUMN | 15 deg | +5.113 | Z/1879 | 92.7 | 2.6 | 5113 | 5113.04 | 2.44914 | 0.0122713 | 96.3296
2 x COLUMN | 15 deg | +5.163 | Z/1861 | 93.6 | 2.6 | 5162.8 | 5162.81 | 2.47299 | 0.0123907 | 97.2673
2 x COLUMN | 15 deg | +5.113 | Z/1845 | 92.7 | 2.6 | 5113.2 | 5113.25 | 2.44925 | 0.0122718 | 96.3336
2 x COLUMN | 9 deg | +5.613 | Z/2217 | 101.8 | 2.8 | 5613 | 5613.04 | 2.68864 | 0.0134713 | 105.75
2 x COLUMN | 9 deg | +5.163 | Z/2215 | 93.6 | 2.6 | 5163 | 5163.04 | 2.47309 | 0.0123913 | 97.2716
2 x COLUMN | 9 deg | +5.713 | Z/2160 | 103.6 | 3 | 5712.8 | 5712.81 | 2.73644 | 0.0137107 | 107.629
2 x COLUMN | 9 deg | +5.163 | Z/2159 | 93.6 | 2.6 | 5162.8 | 5162.81 | 2.47299 | 0.0123907 | 97.2673
2 x COLUMN | 9 deg | +5.613 | Z/2096 | 101.8 | 2.8 | 5613.3 | 5613.25 | 2.68875 | 0.0134718 | 105.754
2 x COLUMN | 9 deg | +5.163 | Z/2095 | 93.6 | 2.6 | 5163.3 | 5163.25 | 2.4732 | 0.0123918 | 97.2756
2 x COLUMN | 5 deg | +5.463 | Z/2206 | 99.1 | 2.7 | 5463 | 5463.04 | 2.61679 | 0.0131113 | 102.924
2 x COLUMN | 5 deg | +5.163 | Z/2204 | 93.6 | 2.6 | 5163 | 5163.04 | 2.47309 | 0.0123913 | 97.2716
2 x COLUMN | 5 deg | +5.463 | Z/2150 | 99.1 | 2.7 | 5462.8 | 5462.81 | 2.61669 | 0.0131107 | 102.919
2 x COLUMN | 5 deg | +5.163 | Z/2149 | 93.6 | 2.6 | 5162.8 | 5162.81 | 2.47299 | 0.0123907 | 97.2673
2 x COLUMN | 5 deg | +5.513 | Z/2088 | 100 | 2.8 | 5513.3 | 5513.25 | 2.64085 | 0.0132318 | 103.87
2 x COLUMN | 5 deg | +5.163 | Z/2087 | 93.6 | 2.6 | 5163.3 | 5163.25 | 2.4732 | 0.0123918 | 97.2756
2 x COLUMN | 3 deg | +5.563 | Z/2195 | 100.9 | 2.8 | 5563 | 5563.04 | 2.66469 | 0.0133513 | 104.808
2 x COLUMN | 3 deg | +5.163 | Z/2193 | 93.6 | 2.6 | 5163 | 5163.04 | 2.47309 | 0.0123913 | 97.2716
2 x COLUMN | 3 deg | +5.263 | Z/2140 | 95.4 | 2.6 | 5262.8 | 5262.81 | 2.52089 | 0.0126307 | 99.1513
2 x COLUMN | 3 deg | +5.163 | Z/2139 | 93.6 | 2.6 | 5162.8 | 5162.81 | 2.47299 | 0.0123907 | 97.2673
2 x COLUMN | 3 deg | +5.213 | Z/2080 | 94.5 | 2.6 | 5213.3 | 5213.25 | 2.49715 | 0.0125118 | 98.2176
2 x COLUMN | 3 deg | +5.163 | Z/2079 | 93.6 | 2.6 | 5163.3 | 5163.25 | 2.4732 | 0.0123918 | 97.2756

# IfcColumn: SHS:50x50x5.0 (26)
In: Undefined
Description: SHS:50x50x5.0; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Phase: 1; Class: 12
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 28 m2; Height: 50 mm; Width: 50 mm
Pset_ColumnCommon - LoadBearing: no
Name | Finish | Top elevation | ASSEMBLY_POS = Reference | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
4 x COLUMN | 12 deg | +5.113 | Z/1782 | 32.7 | 1 | 5113.1 | 5113.14 | 0.915252 | 0.00460183 | 36.1243
4 x COLUMN | 12 deg | +5.063 | Z/1513 | 32.4 | 1 | 5063.1 | 5063.14 | 0.906302 | 0.00455683 | 35.7711
2 x COLUMN | 25 deg | +5.113 | Z/1789 | 32.7 | 1 | 5113.1 | 5113.14 | 0.915252 | 0.00460183 | 36.1243
2 x COLUMN | 18 deg | +5.063 | Z/1825 | 32.4 | 1 | 5063.1 | 5063.14 | 0.906302 | 0.00455683 | 35.7711
2 x COLUMN | 15 deg | +5.063 | Z/1797 | 32.4 | 1 | 5063.1 | 5063.14 | 0.906302 | 0.00455683 | 35.7711
2 x COLUMN | 9 deg | +5.663 | Z/1841 | 36.2 | 1.1 | 5663.1 | 5663.14 | 1.0137 | 0.00509683 | 40.0101
2 x COLUMN | 9 deg | +5.113 | Z/1840 | 32.7 | 1 | 5113.1 | 5113.14 | 0.915252 | 0.00460183 | 36.1243
2 x COLUMN | 5 deg | +5.363 | Z/1817 | 34.3 | 1.1 | 5363.1 | 5363.14 | 0.960002 | 0.00482683 | 37.8906
2 x COLUMN | 5 deg | +5.113 | Z/1816 | 32.7 | 1 | 5113.1 | 5113.14 | 0.915252 | 0.00460183 | 36.1243
2 x COLUMN | 3 deg | +5.263 | Z/1801 | 33.6 | 1.1 | 5263.1 | 5263.14 | 0.942102 | 0.00473683 | 37.1841
2 x COLUMN | 3 deg | +5.113 | Z/1800 | 32.7 | 1 | 5113.1 | 5113.14 | 0.915252 | 0.00460183 | 36.1243

# IfcColumn: SHS:75x75x5.0 (52)
In: Undefined
Description: SHS:75x75x5.0; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Phase: 1; Class: 12
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 27.1 m2; Height: 75 mm; Width: 75 mm
Pset_ColumnCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Finish | Top elevation | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
4 x COLUMN | Z/1783 | 12 deg | +5.113 | 52.6 | 1.5 | 5113.1 | 5113.14 | 1.42657 | 0.0071584 | 56.1934
4 x COLUMN | Z/2024 | 12 deg | +5.113 | 52.6 | 1.5 | 5113.2 | 5113.16 | 1.42657 | 0.00715842 | 56.1936
4 x COLUMN | Z/1784 | 12 deg | +5.063 | 52.1 | 1.5 | 5063.2 | 5063.16 | 1.41262 | 0.00708842 | 55.6441
4 x COLUMN | Z/1779 | 12 deg | +5.063 | 52.1 | 1.5 | 5063.1 | 5063.14 | 1.41262 | 0.0070884 | 55.6439
2 x COLUMN | Z/2026 | 25 deg | +5.113 | 52.6 | 1.5 | 5113.2 | 5113.16 | 1.42657 | 0.00715842 | 56.1936
2 x COLUMN | Z/1790 | 25 deg | +5.113 | 52.6 | 1.5 | 5113.1 | 5113.14 | 1.42657 | 0.0071584 | 56.1934
2 x COLUMN | Z/1835 | 18 deg | +5.113 | 52.6 | 1.5 | 5113.2 | 5113.16 | 1.42657 | 0.00715842 | 56.1936
2 x COLUMN | Z/1827 | 18 deg | +5.063 | 52.1 | 1.5 | 5063.1 | 5063.14 | 1.41262 | 0.0070884 | 55.6439
2 x COLUMN | Z/1833 | 15 deg | +5.063 | 52.1 | 1.5 | 5063.2 | 5063.16 | 1.41262 | 0.00708842 | 55.6441
2 x COLUMN | Z/1810 | 15 deg | +5.063 | 52.1 | 1.5 | 5063.1 | 5063.14 | 1.41262 | 0.0070884 | 55.6439
2 x COLUMN | Z/2037 | 9 deg | +5.713 | 58.8 | 1.7 | 5713.2 | 5713.16 | 1.59397 | 0.00799842 | 62.7876
2 x COLUMN | Z/2036 | 9 deg | +5.113 | 52.6 | 1.5 | 5113.2 | 5113.16 | 1.42657 | 0.00715842 | 56.1936
2 x COLUMN | Z/1854 | 9 deg | +5.663 | 58.2 | 1.7 | 5663.1 | 5663.14 | 1.58002 | 0.0079284 | 62.2379
2 x COLUMN | Z/1853 | 9 deg | +5.113 | 52.6 | 1.5 | 5113.1 | 5113.14 | 1.42657 | 0.0071584 | 56.1934
2 x COLUMN | Z/2033 | 5 deg | +5.463 | 56.2 | 1.6 | 5463.2 | 5463.16 | 1.52422 | 0.00764842 | 60.0401
2 x COLUMN | Z/2032 | 5 deg | +5.113 | 52.6 | 1.5 | 5113.2 | 5113.16 | 1.42657 | 0.00715842 | 56.1936
2 x COLUMN | Z/1831 | 5 deg | +5.363 | 55.2 | 1.6 | 5363.1 | 5363.14 | 1.49632 | 0.0075084 | 58.9409
2 x COLUMN | Z/1826 | 5 deg | +5.113 | 52.6 | 1.5 | 5113.1 | 5113.14 | 1.42657 | 0.0071584 | 56.1934
2 x COLUMN | Z/2029 | 3 deg | +5.280 | 54.3 | 1.6 | 5279.8 | 5279.83 | 1.47307 | 0.00739176 | 58.0253
2 x COLUMN | Z/2028 | 3 deg | +5.113 | 52.6 | 1.5 | 5113.2 | 5113.16 | 1.42657 | 0.00715842 | 56.1936
2 x COLUMN | Z/1803 | 3 deg | +5.263 | 54.1 | 1.6 | 5263.1 | 5263.14 | 1.46842 | 0.0073684 | 57.8419
2 x COLUMN | Z/1802 | 3 deg | +5.113 | 52.6 | 1.5 | 5113.1 | 5113.14 | 1.42657 | 0.0071584 | 56.1934

# IfcElementAssembly (1642)
In: Undefined
PredefinedType: RIGID_FRAME
Name | ASSEMBLY_POSITION_CODE = Assembly/Cast unit position code | ASSEMBLY_POS = Assembly/Cast unit Mark | Assembly/Cast unit weight (kg) | Assembly/Cast unit bottom elevation | Assembly/Cast unit top elevation | Width (mm)
2 x COLUMN | C150SD-C200SD/SHS75*75-SHS100*100 | Z/1783 | 52.6 | +0.000 | +5.113 | 75
RAFTER | C150SD-C200SD/SHS75*75-SHS100*100 | Z/1775 | 4.9 | +4.393 | +4.694 | 64
PLATE | C150SD-C200SD/SHS75*75-SHS100*100 | PL/1972 | 1.9 | +4.442 | +4.700 | 67
2 x COLUMN | C150SD-C200SD/SHS50*50-SHS75*75 | Z/1782 | 32.7 | +0.000 | +5.113 | 50
RAFTER | C150SD-C200SD/SHS50*50-SHS75*75 | Z/1775 | 4.9 | +4.393 | +4.694 | 64
RAFTER | C150SD-C200SD/SHS50*50-SHS75*75 | Z/1514 | 3.6 | +4.873 | +5.135 | 64
2 x COLUMN | C150SD-C200SD/SHS50*50 | Z/1513 | 32.4 | +0.000 | +5.063 | 50
PLATE | C150SD-C200SD/SHS50*50-SHS75*75 | PL/1953 | 1.8 | +4.442 | +4.700 | 67
PLATE | C150SD-C200SD/SHS50*50 | PL/1952 | 1.9 | +4.764 | +5.061 | 67
2 x COLUMN | C200SD-C250SD/SHS75*75-SHS100*100 | Z/2024 | 52.6 | +0.000 | +5.113 | 75
RAFTER | C200SD-C250SD/SHS75*75-SHS100*100 | Z/2040 | 5.7 | +4.352 | +4.692 | 76
RAFTER | C200SD-C250SD/SHS75*75-SHS100*100 | Z/1786 | 4.9 | +4.831 | +5.154 | 76
2 x COLUMN | C200SD-C250SD/SHS75*75 | Z/1784 | 52.1 | +0.000 | +5.063 | 75
PLATE | C200SD-C250SD/SHS75*75-SHS100*100 | PL/1958 | 2.2 | +4.427 | +4.700 | 79
PLATE | C200SD-C250SD/SHS75*75 | PL/1957 | 2.4 | +4.757 | +5.069 | 79
RAFTER | C150SD-C200SD/SHS75*75-SHS100*100 | Z/1514 | 3.6 | +4.876 | +5.138 | 64
2 x COLUMN | C150SD-C200SD/SHS75*75 | Z/1779 | 52.1 | +0.000 | +5.063 | 75
PLATE | C150SD-C200SD/SHS75*75 | PL/1954 | 2.1 | +4.767 | +5.064 | 265.836
2 x COLUMN | C350SD>/SHS100*100-SHS125*125 | Z/2181 | 73.4 | +0.000 | +5.163 | 100
RAFTER | C350SD>/SHS100*100-SHS125*125 | Z/2176 | 9.4 | +4.234 | +4.688 | 125
RAFTER | C350SD>/SHS100*100-SHS125*125 | Z/1818 | 9 | +4.705 | +5.154 | 125
2 x COLUMN | C350SD>/SHS100*100 | Z/1819 | 72.6 | +0.000 | +5.113 | 100
PLATE | C350SD>/SHS100*100-SHS125*125 | PL/1970 | 7 | +4.197 | +4.700 | 128
PLATE | C350SD>/SHS100*100-SHS125*125 | PL/1969 | 7.4 | +4.546 | +5.123 | 128
2 x COLUMN | C300SD-C350SD/SHS100*100-SHS125*125 | Z/2127 | 73.4 | +0.000 | +5.163 | 100
RAFTER | C300SD-C350SD/SHS100*100-SHS125*125 | Z/2110 | 8.6 | +4.274 | +4.689 | 96
RAFTER | C300SD-C350SD/SHS100*100-SHS125*125 | Z/1804 | 8 | +4.749 | +5.155 | 96
2 x COLUMN | C300SD-C350SD/SHS100*100 | Z/1805 | 71.9 | +0.000 | +5.063 | 100
PLATE | C300SD-C350SD/SHS100*100-SHS125*125 | PL/1966 | 6.2 | +4.223 | +4.700 | 99
PLATE | C300SD-C350SD/SHS100*100-SHS125*125 | PL/1965 | 6.6 | +4.566 | +5.117 | 99
2 x COLUMN | C250SD-C300SD/SHS100*100-SHS125*125 | Z/2069 | 73.4 | +0.000 | +5.163 | 100
RAFTER | C250SD-C300SD/SHS100*100-SHS125*125 | Z/2055 | 6 | +4.311 | +4.691 | 76
RAFTER | C250SD-C300SD/SHS100*100-SHS125*125 | Z/1791 | 5.4 | +4.789 | +5.155 | 76
2 x COLUMN | C250SD-C300SD/SHS100*100 | Z/1792 | 71.9 | +0.000 | +5.063 | 100
PLATE | C250SD-C300SD/SHS100*100-SHS125*125 | PL/1962 | 3.9 | +4.322 | +4.700 | 79
PLATE | C250SD-C300SD/SHS100*100 | PL/1961 | 4.1 | +4.660 | +5.092 | 79
2 x COLUMN | C350SD>/SHS125*125-RHS100*50 | Z/2182 | 93.6 | +0.000 | +5.163 | 125
RAFTER | C350SD>/SHS125*125-RHS100*50 | Z/2176 | 9.4 | +4.234 | +4.688 | 125
RAFTER | C350SD>/SHS125*125-RHS100*50 | Z/1818 | 9 | +4.708 | +5.157 | 125
2 x COLUMN | C350SD>/SHS125*125 | Z/1820 | 92.7 | +0.000 | +5.113 | 125
PLATE | C350SD>/SHS125*125-RHS100*50 | PL/1712 | 7.2 | +4.202 | +4.700 | 128
PLATE | C350SD>/SHS125*125-RHS100*50 | PL/1711 | 7.7 | +4.553 | +5.125 | 128
2 x COLUMN | C300SD-C350SD/SHS125*125-RHS100*50 | Z/2128 | 93.6 | +0.000 | +5.163 | 125
RAFTER | C300SD-C350SD/SHS125*125-RHS100*50 | Z/2110 | 8.6 | +4.274 | +4.689 | 96
RAFTER | C300SD-C350SD/SHS125*125-RHS100*50 | Z/1804 | 8 | +4.751 | +5.157 | 96
2 x COLUMN | C300SD-C350SD/SHS125*125 | Z/1806 | 91.8 | +0.000 | +5.063 | 125
PLATE | C300SD-C350SD/SHS125*125-RHS100*50 | PL/1708 | 6.5 | +4.218 | +4.700 | 99
PLATE | C300SD-C350SD/SHS125*125-RHS100*50 | PL/1707 | 7 | +4.563 | +5.120 | 99
2 x COLUMN | C250SD-C300SD/SHS125*125-RHS100*50 | Z/2070 | 93.6 | +0.000 | +5.163 | 125
RAFTER | C250SD-C300SD/SHS125*125-RHS100*50 | Z/2055 | 6 | +4.311 | +4.691 | 76
RAFTER | C250SD-C300SD/SHS125*125-RHS100*50 | Z/1791 | 5.4 | +4.792 | +5.158 | 76
2 x COLUMN | C250SD-C300SD/SHS125*125 | Z/1793 | 91.8 | +0.000 | +5.063 | 125
PLATE | C250SD-C300SD/SHS125*125-RHS100*50 | PL/1704 | 4.1 | +4.332 | +4.700 | 79
PLATE | C250SD-C300SD/SHS125*125 | PL/1703 | 4.3 | +4.673 | +5.095 | 79
2 x COLUMN | C150SD-C200SD/RHS100*50-RHS150*50 | Z/1787 | 53.1 | +0.000 | +5.163 | 50
RAFTER | C150SD-C200SD/RHS100*50-RHS150*50 | Z/1775 | 4.9 | +4.393 | +4.694 | 64
RAFTER | C150SD-C200SD/RHS100*50-RHS150*50 | Z/1514 | 3.6 | +4.879 | +5.140 | 64
2 x COLUMN | C150SD-C200SD/RHS100*50 | Z/1780 | 52.1 | +0.000 | +5.063 | 50
PLATE | C150SD-C200SD/RHS100*50-RHS150*50 | PL/1826 | 2.1 | +4.442 | +4.700 | 67
PLATE | C150SD-C200SD/RHS100*50 | PL/1825 | 2.2 | +4.770 | +5.067 | 67
2 x COLUMN | C200SD-C250SD/RHS150*50-RHS150*100 | Z/2025 | 72.6 | +0.000 | +5.113 | 50
RAFTER | C200SD-C250SD/RHS150*50-RHS150*100 | Z/2040 | 5.7 | +4.352 | +4.692 | 76
RAFTER | C200SD-C250SD/RHS150*50-RHS150*100 | Z/1786 | 4.9 | +4.839 | +5.162 | 76
2 x COLUMN | C200SD-C250SD/RHS150*50 | Z/1785 | 71.9 | +0.000 | +5.063 | 50
PLATE | C200SD-C250SD/RHS150*50-RHS150*100 | PL/1832 | 2.7 | +4.432 | +4.700 | 79
PLATE | C200SD-C250SD/RHS150*50 | PL/1831 | 2.8 | +4.770 | +5.077 | 79
2 x COLUMN | C150SD-C200SD/RHS150*50-RHS150*100 | Z/1788 | 73.4 | +0.000 | +5.163 | 50
RAFTER | C150SD-C200SD/RHS150*50-RHS150*100 | Z/1775 | 4.9 | +4.393 | +4.694 | 64
RAFTER | C150SD-C200SD/RHS150*50-RHS150*100 | Z/1514 | 3.6 | +4.884 | +5.145 | 64
2 x COLUMN | C150SD-C200SD/RHS150*50 | Z/1781 | 71.9 | +0.000 | +5.063 | 50
PLATE | C150SD-C200SD/RHS150*50-RHS150*100 | PL/1828 | 2.4 | +4.442 | +4.700 | 67
PLATE | C150SD-C200SD/RHS150*50 | PL/1827 | 2.4 | +4.775 | +5.072 | 67
2 x COLUMN | C350SD>/RHS150*100-RHS200*100 | Z/2183 | 93.6 | +0.000 | +5.163 | 100
RAFTER | C350SD>/RHS150*100-RHS200*100 | Z/2176 | 9.4 | +4.234 | +4.688 | 125
RAFTER | C350SD>/RHS150*100-RHS200*100 | Z/1818 | 9 | +4.710 | +5.159 | 125
2 x COLUMN | C350SD>/RHS150*100 | Z/1821 | 92.7 | +0.000 | +5.113 | 100
PLATE | C350SD>/RHS150*100-RHS200*100 | PL/1860 | 7.4 | +4.202 | +4.700 | 128
PLATE | C350SD>/RHS150*100-RHS200*100 | PL/1859 | 8 | +4.556 | +5.128 | 128
2 x COLUMN | C300SD-C350SD/RHS150*100-RHS200*100 | Z/2129 | 93.6 | +0.000 | +5.163 | 100
RAFTER | C300SD-C350SD/RHS150*100-RHS200*100 | Z/2110 | 8.6 | +4.274 | +4.689 | 96
RAFTER | C300SD-C350SD/RHS150*100-RHS200*100 | Z/1804 | 8 | +4.754 | +5.160 | 96
2 x COLUMN | C300SD-C350SD/RHS150*100 | Z/1807 | 92.7 | +0.000 | +5.113 | 100
PLATE | C300SD-C350SD/RHS150*100-RHS200*100 | PL/1848 | 6.8 | +4.218 | +4.700 | 99
PLATE | C300SD-C350SD/RHS150*100-RHS200*100 | PL/1847 | 7.2 | +4.566 | +5.123 | 99
2 x COLUMN | C250SD-C300SD/RHS150*100-RHS200*100 | Z/2071 | 93.6 | +0.000 | +5.163 | 100
RAFTER | C250SD-C300SD/RHS150*100-RHS200*100 | Z/2055 | 6 | +4.311 | +4.691 | 76
RAFTER | C250SD-C300SD/RHS150*100-RHS200*100 | Z/1791 | 5.4 | +4.794 | +5.160 | 76
2 x COLUMN | C250SD-C300SD/RHS150*100 | Z/1794 | 91.8 | +0.000 | +5.063 | 100
PLATE | C250SD-C300SD/RHS150*100-RHS200*100 | PL/1838 | 4.3 | +4.332 | +4.700 | 79
PLATE | C250SD-C300SD/RHS150*100 | PL/1837 | 4.5 | +4.675 | +5.097 | 79
2 x COLUMN | C350SD>/RHS200*100-RHS250*150 | Z/2184 | 113.9 | +0.000 | +5.163 | 100
RAFTER | C350SD>/RHS200*100-RHS250*150 | Z/2176 | 9.4 | +4.234 | +4.688 | 125
RAFTER | C350SD>/RHS200*100-RHS250*150 | Z/1818 | 9 | +4.716 | +5.165 | 125
2 x COLUMN | C350SD>/RHS200*100 | Z/1822 | 112.8 | +0.000 | +5.113 | 100
PLATE | C350SD>/RHS200*100-RHS250*150 | PL/1862 | 8 | +4.202 | +4.700 | 128
PLATE | C350SD>/RHS200*100-RHS250*150 | PL/1861 | 8.6 | +4.561 | +5.133 | 128
2 x COLUMN | C300SD-C350SD/RHS200*100-RHS250*150 | Z/2130 | 113.9 | +0.000 | +5.163 | 100
RAFTER | C300SD-C350SD/RHS200*100-RHS250*150 | Z/2110 | 8.6 | +4.274 | +4.689 | 96
RAFTER | C300SD-C350SD/RHS200*100-RHS250*150 | Z/1804 | 8 | +4.759 | +5.165 | 96
2 x COLUMN | C300SD-C350SD/RHS200*100 | Z/1808 | 112.8 | +0.000 | +5.113 | 100
PLATE | C300SD-C350SD/RHS200*100-RHS250*150 | PL/1850 | 7.4 | +4.218 | +4.700 | 99
PLATE | C300SD-C350SD/RHS200*100-RHS250*150 | PL/1849 | 7.7 | +4.571 | +5.128 | 99
2 x COLUMN | C250SD-C300SD/RHS200*100-RHS250*150 | Z/2072 | 113.9 | +0.000 | +5.163 | 100
RAFTER | C250SD-C300SD/RHS200*100-RHS250*150 | Z/2055 | 6 | +4.311 | +4.691 | 76
RAFTER | C250SD-C300SD/RHS200*100-RHS250*150 | Z/1791 | 5.4 | +4.799 | +5.166 | 76
2 x COLUMN | C250SD-C300SD/RHS200*100 | Z/1795 | 111.7 | +0.000 | +5.063 | 100
