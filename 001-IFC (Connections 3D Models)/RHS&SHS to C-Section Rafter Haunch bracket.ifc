Properties of the parts of a building model (IFC2X3), part 5 of 5

# IfcPlate: PLT3*568.6 (8)
Name | ASSEMBLY_POS = Reference | Weight (kg) | Area per tons (m2) | Length (mm) | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
PLATE | PL/1071 | 7.8 | 85.8 | 711.6 | 568.6 | 0.676031 | 0.404629 | 0.00100239
PLATE | PL/1045 | 7.4 | 85.8 | 661.6 | 568.59 | 0.628222 | 0.376194 | 0.000931128
PLATE | PL/1043 | 6.8 | 86 | 611.6 | 568.59 | 0.580423 | 0.347764 | 0.00085988
PLATE | PL/1062 | 6.5 | 86 | 586.6 | 568.6 | 0.55653 | 0.333554 | 0.000824265
PLATE | PL/990 | 7.8 | 85.8 | 711.6 | 568.6 | 0.676031 | 0.404629 | 0.00100239
PLATE | PL/1018 | 7.4 | 85.8 | 661.6 | 568.59 | 0.628222 | 0.376194 | 0.000931128
PLATE | PL/1016 | 6.8 | 86 | 611.6 | 568.59 | 0.580423 | 0.347764 | 0.00085988
PLATE | PL/999 | 6.5 | 86 | 586.6 | 568.6 | 0.55653 | 0.333554 | 0.000824265

# IfcPlate: PLT3*569.6 (8)
In: Undefined
Description: PLT3*569.6; Material: STEEL/450
Tekla Common - Bottom elevation: +4.799; Top elevation: +5.282; Phase: 1; Class: 11
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.6 m2; Height: 569.6 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Weight (kg) | Area per tons (m2) | Length (mm) | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
PLATE | PL/1073 | 7.8 | 85.8 | 707.4 | 569.607 | 0.677401 | 0.402921 | 0.00100444
PLATE | PL/1051 | 7.4 | 85.8 | 657.4 | 569.607 | 0.6296 | 0.374441 | 0.000933188
PLATE | PL/1049 | 6.8 | 86 | 607.4 | 569.607 | 0.5818 | 0.34596 | 0.000861937
PLATE | PL/1064 | 6.5 | 86 | 582.4 | 569.598 | 0.557893 | 0.331709 | 0.000826303
PLATE | PL/992 | 7.8 | 85.8 | 707.4 | 569.607 | 0.677401 | 0.402921 | 0.00100444
PLATE | PL/1024 | 7.4 | 85.8 | 657.4 | 569.607 | 0.6296 | 0.374441 | 0.000933188
PLATE | PL/1022 | 6.8 | 86 | 607.4 | 569.607 | 0.5818 | 0.34596 | 0.000861937
PLATE | PL/1001 | 6.5 | 86 | 582.4 | 569.598 | 0.557893 | 0.331709 | 0.000826303

# IfcPlate: PLT3*579.6 (2)
In: Undefined
Description: PLT3*579.6; Material: STEEL/450
Tekla Common - Bottom elevation: +5.013; Top elevation: +5.516; Phase: 1; Class: 11
Tekla Quantity - Weight: 7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.6 m2; Height: 579.6 mm; Width: 3 mm; Length: 621.4 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 579.575 mm; NetArea: 0.598846 m2; GrossArea: 0.360143 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000887369 m3; GrossVolume: 0.000887369 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1131
PLATE | PL/1116

# IfcPlate: PLT3*583.6 (2)
In: Undefined
Description: PLT3*583.6; Material: STEEL/450
Tekla Common - Bottom elevation: +4.533; Top elevation: +5.033; Phase: 1; Class: 11
Tekla Quantity - Weight: 6.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.5 m2; Height: 583.6 mm; Width: 3 mm; Length: 584.3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 583.628 mm; NetArea: 0.538607 m2; GrossArea: 0.341004 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000797502 m3; GrossVolume: 0.000797502 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1040
PLATE | PL/1013

# IfcPlate: PLT3*583.9 (2)
In: Undefined
Description: PLT3*583.9; Material: STEEL/450
Tekla Common - Bottom elevation: +4.784; Top elevation: +5.282; Phase: 1; Class: 11
Tekla Quantity - Weight: 7.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.6 m2; Height: 583.9 mm; Width: 3 mm; Length: 614.9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 583.912 mm; NetArea: 0.615938 m2; GrossArea: 0.359036 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000912857 m3; GrossVolume: 0.000912857 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1156
PLATE | PL/1088

# IfcPlate: PLT3*584.4 (2)
In: Undefined
Description: PLT3*584.4; Material: STEEL/450
Tekla Common - Bottom elevation: +4.197; Top elevation: +4.700; Phase: 1; Class: 11
Tekla Quantity - Weight: 7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.6 m2; Height: 584.4 mm; Width: 3 mm; Length: 621.8 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 584.396 mm; NetArea: 0.599732 m2; GrossArea: 0.363375 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000888688 m3; GrossVolume: 0.000888688 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1970
PLATE | PL/1968

# IfcPlate: PLT3*586.9 (2)
In: Undefined
Description: PLT3*586.9; Material: STEEL/450
Tekla Common - Bottom elevation: +4.670; Top elevation: +5.168; Phase: 1; Class: 11
Tekla Quantity - Weight: 7.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.6 m2; Height: 586.9 mm; Width: 3 mm; Length: 613.8 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 586.898 mm; NetArea: 0.613494 m2; GrossArea: 0.360248 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000909213 m3; GrossVolume: 0.000909213 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1154
PLATE | PL/1086

# IfcPlate: PLT3*588.3 (8)
In: Undefined
Description: PLT3*588.3; Material: STEEL/450
Tekla Common - Phase: 1; Class: 11
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.6 m2; Height: 588.3 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 588.25 mm; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
PLATE | PL/1070 | +4.532 | +5.037 | 8 | 85.8 | 735.1 | 0.685673 | 0.432452 | 0.00101672
PLATE | PL/1044 | +4.531 | +5.036 | 7.4 | 85.8 | 685.1 | 0.637872 | 0.403039 | 0.000945465
PLATE | PL/1042 | +4.529 | +5.034 | 6.8 | 86 | 635.1 | 0.590072 | 0.373627 | 0.000874214
PLATE | PL/1061 | +4.529 | +5.034 | 6.6 | 86 | 610.1 | 0.566172 | 0.35892 | 0.000838589
PLATE | PL/989 | +4.532 | +5.037 | 8 | 85.8 | 735.1 | 0.685673 | 0.432452 | 0.00101672
PLATE | PL/1017 | +4.531 | +5.036 | 7.4 | 85.8 | 685.1 | 0.637872 | 0.403039 | 0.000945464
PLATE | PL/1015 | +4.529 | +5.034 | 6.8 | 86 | 635.1 | 0.590072 | 0.373627 | 0.000874214
PLATE | PL/998 | +4.529 | +5.034 | 6.6 | 86 | 610.1 | 0.566172 | 0.35892 | 0.000838589

# IfcPlate: PLT3*592.2 (2)
In: Undefined
Description: PLT3*592.2; Material: STEEL/450
Tekla Common - Bottom elevation: +4.509; Top elevation: +5.034; Phase: 1; Class: 11
Tekla Quantity - Weight: 7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.6 m2; Height: 592.2 mm; Width: 3 mm; Length: 637.7 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 592.219 mm; NetArea: 0.603765 m2; GrossArea: 0.377668 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000894686 m3; GrossVolume: 0.000894686 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1136
PLATE | PL/1094

# IfcPlate: PLT3*595.8 (2)
In: Undefined
Description: PLT3*595.8; Material: STEEL/450
Tekla Common - Bottom elevation: +4.540; Top elevation: +5.055; Phase: 1; Class: 11
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.5 m2; Height: 595.8 mm; Width: 3 mm; Length: 597.7 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 595.82 mm; NetArea: 0.546293 m2; GrossArea: 0.356147 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000808932 m3; GrossVolume: 0.000808932 m3
Name | ASSEMBLY_POS = Reference | Weight (kg)
PLATE | PL/1046 | 6.5
PLATE | PL/1019 | 6.3

# IfcPlate: PLT3*600.6 (8)
In: Undefined
Description: PLT3*600.6; Material: STEEL/450
Tekla Common - Bottom elevation: +4.202; Top elevation: +4.700; Phase: 1; Class: 11
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.6 m2; Height: 600.6 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Weight (kg) | Area per tons (m2) | Length (mm) | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
PLATE | PL/1158 | 8.7 | 85.8 | 787.1 | 600.582 | 0.746049 | 0.472693 | 0.00110681
PLATE | PL/1126 | 8 | 85.8 | 738.2 | 600.578 | 0.696751 | 0.443328 | 0.00103332
PLATE | PL/1124 | 7.4 | 85.8 | 689.1 | 600.582 | 0.647292 | 0.413853 | 0.00095958
PLATE | PL/1149 | 7.2 | 86 | 664.8 | 600.582 | 0.6228 | 0.399261 | 0.000923066
PLATE | PL/1081 | 8.7 | 85.8 | 787.1 | 600.582 | 0.746049 | 0.472693 | 0.00110681
PLATE | PL/1111 | 8 | 85.8 | 738.2 | 600.578 | 0.696751 | 0.443328 | 0.00103332
PLATE | PL/1109 | 7.4 | 85.8 | 689.1 | 600.582 | 0.647292 | 0.413853 | 0.00095958
PLATE | PL/1090 | 7.2 | 86 | 664.8 | 600.582 | 0.6228 | 0.399261 | 0.000923066

# IfcPlate: PLT3*602.4 (8)
In: Undefined
Description: PLT3*602.4; Material: STEEL/450
Tekla Common - Phase: 1; Class: 11
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.6 m2; Height: 602.4 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 602.364 mm; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
PLATE | PL/1072 | +4.542 | +5.062 | 8 | 85.8 | 746.7 | 0.693439 | 0.449756 | 0.00102826
PLATE | PL/1050 | +4.540 | +5.059 | 7.4 | 85.8 | 696.7 | 0.645638 | 0.419637 | 0.000957013
PLATE | PL/1048 | +4.537 | +5.057 | 7 | 86 | 646.7 | 0.597838 | 0.389519 | 0.000885763
PLATE | PL/1063 | +4.536 | +5.056 | 6.6 | 86 | 621.7 | 0.573938 | 0.37446 | 0.000850138
PLATE | PL/991 | +4.542 | +5.062 | 8 | 85.8 | 746.7 | 0.693439 | 0.449756 | 0.00102826
PLATE | PL/1023 | +4.540 | +5.059 | 7.4 | 85.8 | 696.7 | 0.645638 | 0.419637 | 0.000957013
PLATE | PL/1021 | +4.537 | +5.057 | 7 | 86 | 646.7 | 0.597838 | 0.389519 | 0.000885763
PLATE | PL/1000 | +4.536 | +5.056 | 6.6 | 86 | 621.7 | 0.573938 | 0.37446 | 0.000850138

# IfcPlate: PLT3*603.9 (8)
In: Undefined
Description: PLT3*603.9; Material: STEEL/450
Tekla Common - Bottom elevation: +4.202; Top elevation: +4.700; Phase: 1; Class: 11
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.6 m2; Height: 603.9 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Weight (kg) | Length (mm) | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
PLATE | PL/1712 | 7.2 | 653.3 | 603.902 | 0.621092 | 0.394515 | 0.000920529
PLATE | PL/1860 | 7.4 | 677.8 | 603.905 | 0.645726 | 0.409352 | 0.000957254
PLATE | PL/1862 | 8 | 727.1 | 603.897 | 0.695008 | 0.4391 | 0.00103073
PLATE | PL/1864 | 8.7 | 776.3 | 603.9 | 0.744305 | 0.468827 | 0.00110422
PLATE | PL/1854 | 8.7 | 776.3 | 603.9 | 0.744305 | 0.468827 | 0.00110422
PLATE | PL/1858 | 8 | 727.1 | 603.897 | 0.695008 | 0.4391 | 0.00103073
PLATE | PL/1856 | 7.4 | 677.8 | 603.905 | 0.645726 | 0.409352 | 0.000957254
PLATE | PL/1710 | 7.2 | 653.3 | 603.902 | 0.621092 | 0.394515 | 0.000920529

# IfcPlate: PLT3*604.5 (2)
In: Undefined
Description: PLT3*604.5; Material: STEEL/450
Tekla Common - Bottom elevation: +5.018; Top elevation: +5.516; Phase: 1; Class: 11
Tekla Quantity - Weight: 7.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.6 m2; Height: 604.5 mm; Width: 3 mm; Length: 616.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 604.545 mm; NetArea: 0.620099 m2; GrossArea: 0.372776 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000919053 m3; GrossVolume: 0.000919053 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1152
PLATE | PL/1093

# IfcPlate: PLT3*605 (2)
In: Undefined
Description: PLT3*605; Material: STEEL/450
Tekla Common - Bottom elevation: +4.197; Top elevation: +4.700; Phase: 1; Class: 11
Tekla Quantity - Weight: 7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.6 m2; Height: 605 mm; Width: 3 mm; Length: 641.8 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 605.007 mm; NetArea: 0.601413 m2; GrossArea: 0.388286 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000891185 m3; GrossVolume: 0.000891185 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1122
PLATE | PL/1107

# IfcPlate: PLT3*606.3 (2)
In: Undefined
Description: PLT3*606.3; Material: STEEL/450
Tekla Common - Bottom elevation: +4.517; Top elevation: +5.057; Phase: 1; Class: 11
Tekla Quantity - Weight: 7.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.6 m2; Height: 606.3 mm; Width: 3 mm; Length: 651.7 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 606.283 mm; NetArea: 0.613783 m2; GrossArea: 0.395096 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000909605 m3; GrossVolume: 0.000909605 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1142
PLATE | PL/1100

# IfcPlate: PLT3*608.9 (2)
In: Undefined
Description: PLT3*608.9; Material: STEEL/450
Tekla Common - Bottom elevation: +4.784; Top elevation: +5.282; Phase: 1; Class: 11
Tekla Quantity - Weight: 7.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.6 m2; Height: 608.9 mm; Width: 3 mm; Length: 614.9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 608.912 mm; NetArea: 0.640588 m2; GrossArea: 0.374408 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000949607 m3; GrossVolume: 0.000949607 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1145
PLATE | PL/1103

# IfcPlate: PLT3*611.9 (2)
In: Undefined
Description: PLT3*611.9; Material: STEEL/450
Tekla Common - Bottom elevation: +4.670; Top elevation: +5.168; Phase: 1; Class: 11
Tekla Quantity - Weight: 7.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.6 m2; Height: 611.9 mm; Width: 3 mm; Length: 613.8 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 611.898 mm; NetArea: 0.638144 m2; GrossArea: 0.375594 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000945963 m3; GrossVolume: 0.000945963 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1139
PLATE | PL/1097

# IfcPlate: PLT3*613.8 (4)
In: Undefined
Description: PLT3*613.8; Material: STEEL/450
Tekla Common - Bottom elevation: +4.670; Top elevation: +5.168; Phase: 1; Class: 11
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.6 m2; Height: 613.8 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 613.808 mm; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Weight (kg) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
PLATE | PL/1163 | 8.6 | 711.9 | 0.736735 | 0.436969 | 0.00109295
PLATE | PL/1141 | 8 | 661.9 | 0.687435 | 0.406278 | 0.00101945
PLATE | PL/1077 | 8.6 | 711.9 | 0.736735 | 0.436969 | 0.00109295
PLATE | PL/1099 | 8 | 661.9 | 0.687435 | 0.406278 | 0.00101945

# IfcPlate: PLT3*614.9 (4)
In: Undefined
Description: PLT3*614.9; Material: STEEL/450
Tekla Common - Bottom elevation: +4.784; Top elevation: +5.282; Phase: 1; Class: 11
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.6 m2; Height: 614.9 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 614.881 mm; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Weight (kg) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
PLATE | PL/1165 | 8.6 | 708.9 | 0.739189 | 0.435896 | 0.00109661
PLATE | PL/1147 | 8 | 658.9 | 0.689889 | 0.405152 | 0.00102311
PLATE | PL/1079 | 8.6 | 708.9 | 0.739189 | 0.435896 | 0.00109661
PLATE | PL/1105 | 8 | 658.9 | 0.689889 | 0.405152 | 0.00102311

# IfcPlate: PLT3*616 (2)
In: Undefined
Description: PLT3*616; Material: STEEL/450
Tekla Common - Bottom elevation: +4.515; Top elevation: +5.035; Phase: 1; Class: 11
Tekla Quantity - Weight: 7.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.6 m2; Height: 616 mm; Width: 3 mm; Length: 633.2 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 616.025 mm; NetArea: 0.624696 m2; GrossArea: 0.390039 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00092589 m3; GrossVolume: 0.00092589 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1153
PLATE | PL/1085

# IfcPlate: PLT3*616.6 (6)
In: Undefined
Description: PLT3*616.6; Material: STEEL/450
Tekla Common - Bottom elevation: +5.018; Top elevation: +5.516; Phase: 1; Class: 11
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.6 m2; Height: 616.6 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Weight (kg) | Length (mm) | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
PLATE | PL/1161 | 8.7 | 729.6 | 616.625 | 0.743382 | 0.449874 | 0.00110285
PLATE | PL/1135 | 8 | 679.6 | 616.625 | 0.694082 | 0.419043 | 0.00102935
PLATE | PL/1133 | 7.4 | 629.6 | 616.622 | 0.644779 | 0.38821 | 0.000955847
PLATE | PL/1084 | 8.7 | 729.6 | 616.625 | 0.743382 | 0.449874 | 0.00110285
PLATE | PL/1120 | 8 | 679.6 | 616.625 | 0.694082 | 0.419043 | 0.00102935
PLATE | PL/1118 | 7.4 | 629.6 | 616.622 | 0.644779 | 0.38821 | 0.000955847

# IfcPlate: PLT3*617.2 (2)
In: Undefined
Description: PLT3*617.2; Material: STEEL/450
Tekla Common - Bottom elevation: +4.555; Top elevation: +5.099; Phase: 1; Class: 11
Tekla Quantity - Weight: 6.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.6 m2; Height: 617.2 mm; Width: 3 mm; Length: 625.7 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 617.19 mm; NetArea: 0.560855 m2; GrossArea: 0.386186 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000830577 m3; GrossVolume: 0.000830577 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1052
PLATE | PL/1025

# IfcPlate: PLT3*622.4 (2)
In: Undefined
Description: PLT3*622.4; Material: STEEL/450
Tekla Common - Bottom elevation: +4.566; Top elevation: +5.117; Phase: 1; Class: 11
Tekla Quantity - Weight: 6.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.6 m2; Height: 622.4 mm; Width: 3 mm; Length: 632.5 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 622.4 mm; NetArea: 0.564317 m2; GrossArea: 0.393686 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000835721 m3; GrossVolume: 0.000835721 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1965
PLATE | PL/1963

# IfcPlate: PLT3*630.1 (2)
In: Undefined
Description: PLT3*630.1; Material: STEEL/450
Tekla Common - Bottom elevation: +4.523; Top elevation: +5.058; Phase: 1; Class: 11
Tekla Quantity - Weight: 7.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.6 m2; Height: 630.1 mm; Width: 3 mm; Length: 647.1 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 630.147 mm; NetArea: 0.634622 m2; GrossArea: 0.407777 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000940672 m3; GrossVolume: 0.000940672 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1155
PLATE | PL/1087

# IfcPlate: PLT3*630.3 (8)
In: Undefined
Description: PLT3*630.3; Material: STEEL/450
Tekla Common - Phase: 1; Class: 11
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.6 m2; Height: 630.3 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 630.333 mm; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
PLATE | PL/1074 | +4.561 | +5.111 | 8.3 | 85.8 | 767.9 | 0.70812 | 0.484056 | 0.00105009
PLATE | PL/1056 | +4.557 | +5.107 | 7.7 | 85.8 | 717.9 | 0.660312 | 0.452533 | 0.000978825
PLATE | PL/1054 | +4.554 | +5.103 | 7.2 | 86 | 667.9 | 0.612522 | 0.421022 | 0.00090759
PLATE | PL/1065 | +4.552 | +5.101 | 6.8 | 86 | 642.9 | 0.588622 | 0.405264 | 0.000871965
PLATE | PL/993 | +4.561 | +5.111 | 8.3 | 85.8 | 767.9 | 0.70812 | 0.484056 | 0.00105009
PLATE | PL/1029 | +4.557 | +5.107 | 7.7 | 85.8 | 717.9 | 0.660312 | 0.452533 | 0.000978825
PLATE | PL/1027 | +4.554 | +5.103 | 7.2 | 86 | 667.9 | 0.612522 | 0.421022 | 0.00090759
PLATE | PL/1002 | +4.552 | +5.101 | 6.8 | 86 | 642.9 | 0.588622 | 0.405264 | 0.000871965

# IfcPlate: PLT3*631.8 (2)
In: Undefined
Description: PLT3*631.8; Material: STEEL/450
Tekla Common - Bottom elevation: +4.566; Top elevation: +5.132; Phase: 1; Class: 11
Tekla Quantity - Weight: 6.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.6 m2; Height: 631.8 mm; Width: 3 mm; Length: 646.4 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 631.76 mm; NetArea: 0.571028 m2; GrossArea: 0.408353 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000845691 m3; GrossVolume: 0.000845691 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1031
PLATE | PL/1004

# IfcPlate: PLT3*632.4 (2)
In: Undefined
Description: PLT3*632.4; Material: STEEL/450
Tekla Common - Bottom elevation: +4.533; Top elevation: +5.103; Phase: 1; Class: 11
Tekla Quantity - Weight: 7.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.6 m2; Height: 632.4 mm; Width: 3 mm; Length: 679.3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 632.446 mm; NetArea: 0.632797 m2; GrossArea: 0.429625 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000937915 m3; GrossVolume: 0.000937915 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1130
PLATE | PL/1115

# IfcPlate: PLT3*633.2 (6)
In: Undefined
Description: PLT3*633.2; Material: STEEL/450
Tekla Common - Phase: 1; Class: 11
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.6 m2; Height: 633.2 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 633.154 mm; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
PLATE | PL/1162 | +4.518 | +5.038 | 8.7 | 741 | 0.747936 | 0.469177 | 0.00110963
PLATE | PL/1140 | +4.517 | +5.037 | 8 | 691 | 0.698636 | 0.437519 | 0.00103613
PLATE | PL/1138 | +4.516 | +5.036 | 7.7 | 641 | 0.649346 | 0.405868 | 0.00096264
PLATE | PL/1076 | +4.518 | +5.038 | 8.7 | 741 | 0.747936 | 0.469177 | 0.00110963
PLATE | PL/1098 | +4.517 | +5.037 | 8 | 691 | 0.698636 | 0.437519 | 0.00103613
PLATE | PL/1096 | +4.516 | +5.036 | 7.7 | 641 | 0.649346 | 0.405868 | 0.00096264

# IfcPlate: PLT3*637 (2)
In: Undefined
Description: PLT3*637; Material: STEEL/450
Tekla Common - Bottom elevation: +4.563; Top elevation: +5.120; Phase: 1; Class: 11
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.6 m2; Height: 637 mm; Width: 3 mm; Length: 647.1 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 636.971 mm; NetArea: 0.591069 m2; GrossArea: 0.412178 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000875598 m3; GrossVolume: 0.000875598 m3
Name | ASSEMBLY_POS = Reference | Weight (kg)
PLATE | PL/1707 | 7
PLATE | PL/1705 | 6.8

# IfcPlate: PLT3*637.2 (6)
In: Undefined
Description: PLT3*637.2; Material: STEEL/450
Tekla Common - Phase: 1; Class: 11
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.6 m2; Height: 637.2 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Length (mm) | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
PLATE | PL/1847 | +4.566 | +5.123 | 7.2 | 673 | 637.182 | 0.616006 | 0.428852 | 0.000912767
PLATE | PL/1849 | +4.571 | +5.128 | 7.7 | 723 | 637.182 | 0.663806 | 0.460711 | 0.000984018
PLATE | PL/1851 | +4.576 | +5.133 | 8.3 | 773.1 | 637.162 | 0.711609 | 0.492579 | 0.00105527
PLATE | PL/1841 | +4.576 | +5.133 | 8.3 | 773.1 | 637.162 | 0.711609 | 0.492579 | 0.00105527
PLATE | PL/1845 | +4.571 | +5.128 | 7.7 | 723 | 637.182 | 0.663806 | 0.460711 | 0.000984018
PLATE | PL/1843 | +4.566 | +5.123 | 7.2 | 673 | 637.182 | 0.616006 | 0.428852 | 0.000912767

# IfcPlate: PLT3*638.7 (2)
In: Undefined
Description: PLT3*638.7; Material: STEEL/450
Tekla Common - Bottom elevation: +4.546; Top elevation: +5.123; Phase: 1; Class: 11
Tekla Quantity - Weight: 7.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.6 m2; Height: 638.7 mm; Width: 3 mm; Length: 686.1 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 638.747 mm; NetArea: 0.637385 m2; GrossArea: 0.438226 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000944743 m3; GrossVolume: 0.000944743 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1969
PLATE | PL/1967

# IfcPlate: PLT3*644.8 (2)
In: Undefined
Description: PLT3*644.8; Material: STEEL/450
Tekla Common - Bottom elevation: +4.577; Top elevation: +5.165; Phase: 1; Class: 11
Tekla Quantity - Weight: 6.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.6 m2; Height: 644.8 mm; Width: 3 mm; Length: 666.8 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 644.755 mm; NetArea: 0.580526 m2; GrossArea: 0.429942 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000859795 m3; GrossVolume: 0.000859795 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1037
PLATE | PL/1010

# IfcPlate: PLT3*647.1 (6)
In: Undefined
Description: PLT3*647.1; Material: STEEL/450
Tekla Common - Phase: 1; Class: 11
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Height: 647.1 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 647.115 mm; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Net surface area (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
PLATE | PL/1164 | +4.529 | +5.064 | 8.7 | 0.8 | 755.1 | 0.757842 | 0.488647 | 0.00112438
PLATE | PL/1146 | +4.527 | +5.062 | 8.3 | 0.6 | 705.1 | 0.708572 | 0.456311 | 0.00105092
PLATE | PL/1144 | +4.524 | +5.059 | 7.7 | 0.6 | 655.1 | 0.659272 | 0.423955 | 0.000977422
PLATE | PL/1078 | +4.529 | +5.064 | 8.7 | 0.8 | 755.1 | 0.757842 | 0.488647 | 0.00112438
PLATE | PL/1104 | +4.527 | +5.062 | 8.3 | 0.6 | 705.1 | 0.708572 | 0.456311 | 0.00105092
PLATE | PL/1102 | +4.524 | +5.059 | 7.7 | 0.6 | 655.1 | 0.659272 | 0.423955 | 0.000977422

# IfcPlate: PLT3*650.5 (2)
In: Undefined
Description: PLT3*650.5; Material: STEEL/450
Tekla Common - Bottom elevation: +4.546; Top elevation: +5.137; Phase: 1; Class: 11
Tekla Quantity - Weight: 7.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.6 m2; Height: 650.5 mm; Width: 3 mm; Length: 699.7 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 650.473 mm; NetArea: 0.646284 m2; GrossArea: 0.455141 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000957987 m3; GrossVolume: 0.000957987 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1121
PLATE | PL/1106

# IfcPlate: PLT3*651 (8)
In: Undefined
Description: PLT3*651; Material: STEEL/450
Tekla Common - Phase: 1; Class: 11
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.6 m2; Height: 651 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Length (mm) | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
PLATE | PL/1067 | +4.577 | +5.148 | 8.3 | 85.8 | 782.4 | 651.007 | 0.718376 | 0.509354 | 0.00106532
PLATE | PL/1035 | +4.571 | +5.143 | 7.8 | 85.8 | 732.4 | 651.027 | 0.67057 | 0.476792 | 0.000994065
PLATE | PL/1033 | +4.566 | +5.137 | 7.2 | 86 | 682.4 | 651.027 | 0.622769 | 0.444241 | 0.000922815
PLATE | PL/1058 | +4.563 | +5.135 | 7 | 86 | 657.4 | 651.027 | 0.598869 | 0.427965 | 0.00088719
PLATE | PL/986 | +4.577 | +5.148 | 8.3 | 85.8 | 782.4 | 651.007 | 0.718376 | 0.509354 | 0.00106532
PLATE | PL/1008 | +4.571 | +5.143 | 7.8 | 85.8 | 732.4 | 651.027 | 0.67057 | 0.476792 | 0.000994065
PLATE | PL/1006 | +4.566 | +5.137 | 7.2 | 86 | 682.4 | 651.027 | 0.622769 | 0.444241 | 0.000922815
PLATE | PL/995 | +4.563 | +5.135 | 7 | 86 | 657.4 | 651.027 | 0.598869 | 0.427965 | 0.00088719

# IfcPlate: PLT3*656.4 (4)
In: Undefined
Description: PLT3*656.4; Material: STEEL/450
Tekla Common - Phase: 1; Class: 11
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.6 m2; Height: 656.4 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Length (mm) | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
PLATE | PL/1216 | +4.588 | +5.198 | 6.8 | 86 | 687 | 656.356 | 0.589366 | 0.450888 | 0.000872912
PLATE | PL/1151 | +4.540 | +5.105 | 7.7 | 85.8 | 674.8 | 656.412 | 0.65348 | 0.442923 | 0.000968749
PLATE | PL/1092 | +4.540 | +5.105 | 7.7 | 85.8 | 674.8 | 656.412 | 0.65348 | 0.442923 | 0.000968749
PLATE | PL/1210 | +4.588 | +5.198 | 6.8 | 86 | 687 | 656.356 | 0.589366 | 0.450888 | 0.000872912

# IfcPlate: PLT3*662.8 (2)
In: Undefined
Description: PLT3*662.8; Material: STEEL/450
Tekla Common - Bottom elevation: +4.553; Top elevation: +5.125; Phase: 1; Class: 11
Tekla Quantity - Weight: 7.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.6 m2; Height: 662.8 mm; Width: 3 mm; Length: 681.5 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 662.781 mm; NetArea: 0.658029 m2; GrossArea: 0.451695 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000975521 m3; GrossVolume: 0.000975521 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1711
PLATE | PL/1709

# IfcPlate: PLT3*667.1 (2)
In: Undefined
Description: PLT3*667.1; Material: STEEL/450
Tekla Common - Bottom elevation: +4.558; Top elevation: +5.172; Phase: 1; Class: 11
Tekla Quantity - Weight: 7.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.6 m2; Height: 667.1 mm; Width: 3 mm; Length: 719.8 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 667.05 mm; NetArea: 0.659001 m2; GrossArea: 0.480153 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000976909 m3; GrossVolume: 0.000976909 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1127
PLATE | PL/1112

# IfcPlate: PLT3*670.3 (2)
In: Undefined
Description: PLT3*670.3; Material: STEEL/450
Tekla Common - Bottom elevation: +4.575; Top elevation: +5.168; Phase: 1; Class: 11
Tekla Quantity - Weight: 7.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.6 m2; Height: 670.3 mm; Width: 3 mm; Length: 671.5 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 670.338 mm; NetArea: 0.608468 m2; GrossArea: 0.450127 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000901444 m3; GrossVolume: 0.000901444 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1060
PLATE | PL/997

# IfcPlate: PLT3*671.5 (6)
In: Undefined
Description: PLT3*671.5; Material: STEEL/450
Tekla Common - Phase: 1; Class: 11
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.6 m2; Height: 671.5 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 671.463 mm; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
PLATE | PL/1069 | +4.592 | +5.185 | 8.6 | 85.8 | 795.4 | 0.727973 | 0.53408 | 0.00107958
PLATE | PL/1039 | +4.585 | +5.178 | 7.8 | 85.8 | 745.4 | 0.680173 | 0.500507 | 0.00100833
PLATE | PL/1038 | +4.578 | +5.172 | 7.4 | 86 | 695.4 | 0.632374 | 0.466934 | 0.000937077
PLATE | PL/988 | +4.592 | +5.185 | 8.6 | 85.8 | 795.4 | 0.727973 | 0.53408 | 0.00107958
PLATE | PL/1012 | +4.585 | +5.178 | 7.8 | 85.8 | 745.4 | 0.680173 | 0.500507 | 0.00100833
PLATE | PL/1011 | +4.578 | +5.172 | 7.4 | 86 | 695.4 | 0.632374 | 0.466934 | 0.000937077

# IfcPlate: PLT3*674.6 (2)
In: Undefined
Description: PLT3*674.6; Material: STEEL/450
Tekla Common - Bottom elevation: +4.553; Top elevation: +5.140; Phase: 1; Class: 11
Tekla Quantity - Weight: 7.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.6 m2; Height: 674.6 mm; Width: 3 mm; Length: 695.2 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 674.552 mm; NetArea: 0.666857 m2; GrossArea: 0.468919 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000988658 m3; GrossVolume: 0.000988658 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1148
PLATE | PL/1089

# IfcPlate: PLT3*674.8 (6)
In: Undefined
Description: PLT3*674.8; Material: STEEL/450
Tekla Common - Phase: 1; Class: 11
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Height: 674.8 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 674.764 mm; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Net surface area (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
PLATE | PL/1160 | +4.550 | +5.115 | 9 | 0.8 | 781.4 | 0.77673 | 0.527269 | 0.0011525
PLATE | PL/1134 | +4.546 | +5.111 | 8.6 | 0.6 | 731.5 | 0.727469 | 0.493558 | 0.00107906
PLATE | PL/1132 | +4.542 | +5.107 | 7.8 | 0.6 | 681.5 | 0.67813 | 0.459792 | 0.0010055
PLATE | PL/1083 | +4.550 | +5.115 | 9 | 0.8 | 781.4 | 0.77673 | 0.527269 | 0.0011525
PLATE | PL/1119 | +4.546 | +5.111 | 8.6 | 0.6 | 731.5 | 0.727469 | 0.493558 | 0.00107906
PLATE | PL/1117 | +4.542 | +5.107 | 7.8 | 0.6 | 681.5 | 0.67813 | 0.459792 | 0.0010055

# IfcPlate: PLT3*678 (2)
In: Undefined
Description: PLT3*678; Material: STEEL/450
Tekla Common - Bottom elevation: +4.617; Top elevation: +5.275; Phase: 1; Class: 11
Tekla Quantity - Weight: 7.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.6 m2; Height: 678 mm; Width: 3 mm; Length: 732.2 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 677.96 mm; NetArea: 0.607211 m2; GrossArea: 0.496384 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000899359 m3; GrossVolume: 0.000899359 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1219
PLATE | PL/1213

# IfcPlate: PLT3*681.1 (2)
In: Undefined
Description: PLT3*681.1; Material: STEEL/450
Tekla Common - Bottom elevation: +4.567; Top elevation: +5.138; Phase: 1; Class: 11
Tekla Quantity - Weight: 9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.8 m2; Height: 681.1 mm; Width: 3 mm; Length: 787.7 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 681.108 mm; NetArea: 0.781011 m2; GrossArea: 0.536507 m2; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | NetVolume (m3) = GrossVolume (m3)
PLATE | PL/1863 | 0.00115886
PLATE | PL/1853 | 0.00115888

# IfcPlate: PLT3*681.5 (4)
In: Undefined
Description: PLT3*681.5; Material: STEEL/450
Tekla Common - Phase: 1; Class: 11
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.6 m2; Height: 681.5 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Length (mm) | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
PLATE | PL/1859 | +4.556 | +5.128 | 8 | 687.8 | 681.503 | 0.68267 | 0.468734 | 0.00101226
PLATE | PL/1861 | +4.561 | +5.133 | 8.6 | 737.8 | 681.539 | 0.731994 | 0.502841 | 0.00108579
PLATE | PL/1857 | +4.561 | +5.133 | 8.6 | 737.8 | 681.539 | 0.731994 | 0.502841 | 0.00108579
PLATE | PL/1855 | +4.556 | +5.128 | 8 | 687.8 | 681.503 | 0.68267 | 0.468734 | 0.00101226

# IfcPlate: PLT3*682 (2)
In: Undefined
Description: PLT3*682; Material: STEEL/450
Tekla Common - Bottom elevation: +4.587; Top elevation: +5.202; Phase: 1; Class: 11
Tekla Quantity - Weight: 7.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.6 m2; Height: 682 mm; Width: 3 mm; Length: 691.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 681.956 mm; NetArea: 0.617369 m2; GrossArea: 0.471622 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000914652 m3; GrossVolume: 0.000914652 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1222
PLATE | PL/1208

# IfcPlate: PLT3*682.1 (2)
In: Undefined
Description: PLT3*682.1; Material: STEEL/450
Tekla Common - Bottom elevation: +4.571; Top elevation: +5.206; Phase: 1; Class: 11
Tekla Quantity - Weight: 7.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.6 m2; Height: 682.1 mm; Width: 3 mm; Length: 739.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 682.113 mm; NetArea: 0.670989 m2; GrossArea: 0.504464 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000994738 m3; GrossVolume: 0.000994738 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1236
PLATE | PL/1230

# IfcPlate: PLT3*691.2 (2)
In: Undefined
Description: PLT3*691.2; Material: STEEL/450
Tekla Common - Bottom elevation: +4.567; Top elevation: +5.175; Phase: 1; Class: 11
Tekla Quantity - Weight: 7.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.6 m2; Height: 691.2 mm; Width: 3 mm; Length: 715.3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 691.184 mm; NetArea: 0.679475 m2; GrossArea: 0.494386 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00100743 m3; GrossVolume: 0.00100743 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1150
PLATE | PL/1091

# IfcPlate: PLT3*691.6 (6)
In: Undefined
Description: PLT3*691.6; Material: STEEL/450
Tekla Common - Phase: 1; Class: 11
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.6 m2; Height: 691.6 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 691.572 mm; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
PLATE | PL/1224 | +4.608 | +5.222 | 8.6 | 85.8 | 807 | 0.736869 | 0.558068 | 0.00109278
PLATE | PL/1218 | +4.599 | +5.214 | 8 | 85.8 | 757 | 0.689069 | 0.52349 | 0.00102153
PLATE | PL/1217 | +4.591 | +5.206 | 7.4 | 86 | 707 | 0.641269 | 0.488911 | 0.000950277
PLATE | PL/1206 | +4.608 | +5.222 | 8.6 | 85.8 | 807 | 0.736869 | 0.558068 | 0.00109278
PLATE | PL/1212 | +4.599 | +5.214 | 8 | 85.8 | 757 | 0.689069 | 0.52349 | 0.00102153
PLATE | PL/1211 | +4.591 | +5.206 | 7.4 | 86 | 707 | 0.641269 | 0.488911 | 0.000950277

# IfcPlate: PLT3*694.7 (2)
In: Undefined
Description: PLT3*694.7; Material: STEEL/450
Tekla Common - Bottom elevation: +4.567; Top elevation: +5.153; Phase: 1; Class: 11
Tekla Quantity - Weight: 9.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.8 m2; Height: 694.7 mm; Width: 3 mm; Length: 799.5 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 694.748 mm; NetArea: 0.789827 m2; GrossArea: 0.555431 m2; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | NetVolume (m3) = GrossVolume (m3)
PLATE | PL/1157 | 0.00117198
PLATE | PL/1080 | 0.001172

# IfcPlate: PLT3*695.1 (2)
In: Undefined
Description: PLT3*695.1; Material: STEEL/450
Tekla Common - Bottom elevation: +4.556; Top elevation: +5.143; Phase: 1; Class: 11
Tekla Quantity - Weight: 8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.6 m2; Height: 695.1 mm; Width: 3 mm; Length: 699.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 695.145 mm; NetArea: 0.691506 m2; GrossArea: 0.486304 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00102541 m3; GrossVolume: 0.00102541 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1123
PLATE | PL/1108

# IfcPlate: PLT3*695.2 (2)
In: Undefined
Description: PLT3*695.2; Material: STEEL/450
Tekla Common - Bottom elevation: +4.561; Top elevation: +5.148; Phase: 1; Class: 11
Tekla Quantity - Weight: 8.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.6 m2; Height: 695.2 mm; Width: 3 mm; Length: 749.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 695.181 mm; NetArea: 0.740831 m2; GrossArea: 0.521094 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00109894 m3; GrossVolume: 0.00109894 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1125
PLATE | PL/1110

# IfcPlate: PLT3*703.5 (2)
In: Undefined
Description: PLT3*703.5; Material: STEEL/450
Tekla Common - Bottom elevation: +4.618; Top elevation: +5.281; Phase: 1; Class: 11
Tekla Quantity - Weight: 7.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.6 m2; Height: 703.5 mm; Width: 3 mm; Length: 736.8 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 703.46 mm; NetArea: 0.635342 m2; GrossArea: 0.518307 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000941289 m3; GrossVolume: 0.000941289 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1223
PLATE | PL/1209

# IfcPlate: PLT3*706.3 (2)
In: Undefined
Description: PLT3*706.3; Material: STEEL/450
Tekla Common - Bottom elevation: +4.580; Top elevation: +5.210; Phase: 1; Class: 11
Tekla Quantity - Weight: 8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.6 m2; Height: 706.3 mm; Width: 3 mm; Length: 735 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 706.288 mm; NetArea: 0.691368 m2; GrossArea: 0.519143 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00102512 m3; GrossVolume: 0.00102512 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1243
PLATE | PL/1228

# IfcPlate: PLT3*711.5 (2)
In: Undefined
Description: PLT3*711.5; Material: STEEL/450
Tekla Common - Bottom elevation: +4.603; Top elevation: +5.287; Phase: 1; Class: 11
Tekla Quantity - Weight: 8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.6 m2; Height: 711.5 mm; Width: 3 mm; Length: 783.9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 711.47 mm; NetArea: 0.695969 m2; GrossArea: 0.557724 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00103186 m3; GrossVolume: 0.00103186 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1239
PLATE | PL/1233

# IfcPlate: PLT3*715.3 (6)
In: Undefined
Description: PLT3*715.3; Material: STEEL/450
Tekla Common - Phase: 1; Class: 11
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Height: 715.3 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Net surface area (m2) | Length (mm) | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
PLATE | PL/1159 | +4.583 | +5.192 | 9.4 | 0.8 | 816.1 | 715.294 | 0.802718 | 0.583776 | 0.00119117
PLATE | PL/1129 | +4.577 | +5.185 | 8.7 | 0.8 | 766.2 | 715.274 | 0.75342 | 0.548025 | 0.00111767
PLATE | PL/1128 | +4.570 | +5.178 | 8.3 | 0.6 | 716.2 | 715.274 | 0.704125 | 0.512268 | 0.00104418
PLATE | PL/1082 | +4.583 | +5.192 | 9.4 | 0.8 | 816.1 | 715.294 | 0.802718 | 0.583776 | 0.00119117
PLATE | PL/1114 | +4.577 | +5.185 | 8.7 | 0.8 | 766.2 | 715.274 | 0.75342 | 0.548025 | 0.00111767
PLATE | PL/1113 | +4.570 | +5.178 | 8.3 | 0.6 | 716.2 | 715.274 | 0.704125 | 0.512268 | 0.00104418

# IfcPlate: PLT3*728.5 (2)
In: Undefined
Description: PLT3*728.5; Material: STEEL/450
Tekla Common - Bottom elevation: +4.623; Top elevation: +5.287; Phase: 1; Class: 11
Tekla Quantity - Weight: 7.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.6 m2; Height: 728.5 mm; Width: 3 mm; Length: 736.8 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 728.46 mm; NetArea: 0.659242 m2; GrossArea: 0.536727 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000976914 m3; GrossVolume: 0.000976914 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1220
PLATE | PL/1214

# IfcPlate: PLT3*731.3 (2)
In: Undefined
Description: PLT3*731.3; Material: STEEL/450
Tekla Common - Bottom elevation: +4.584; Top elevation: +5.214; Phase: 1; Class: 11
Tekla Quantity - Weight: 8.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.6 m2; Height: 731.3 mm; Width: 3 mm; Length: 735 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 731.288 mm; NetArea: 0.716018 m2; GrossArea: 0.537519 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00106187 m3; GrossVolume: 0.00106187 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1237
PLATE | PL/1231

# IfcPlate: PLT3*735 (2)
In: Undefined
Description: PLT3*735; Material: STEEL/450
Tekla Common - Bottom elevation: +4.600; Top elevation: +5.231; Phase: 1; Class: 11
Tekla Quantity - Weight: 9.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.8 m2; Height: 735 mm; Width: 3 mm; Length: 831.3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 735.03 mm; NetArea: 0.814619 m2; GrossArea: 0.611022 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00120887 m3; GrossVolume: 0.00120887 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1244
PLATE | PL/1226

# IfcPlate: PLT3*735.1 (2)
In: Undefined
Description: PLT3*735.1; Material: STEEL/450
Tekla Common - Bottom elevation: +4.592; Top elevation: +5.222; Phase: 1; Class: 11
Tekla Quantity - Weight: 9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.8 m2; Height: 735.1 mm; Width: 3 mm; Length: 781.3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 735.05 mm; NetArea: 0.765357 m2; GrossArea: 0.574308 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00113543 m3; GrossVolume: 0.00113543 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1238
PLATE | PL/1232

# IfcPlate: PLT3*735.8 (2)
In: Undefined
Description: PLT3*735.8; Material: STEEL/450
Tekla Common - Bottom elevation: +4.614; Top elevation: +5.293; Phase: 1; Class: 11
Tekla Quantity - Weight: 8.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.6 m2; Height: 735.8 mm; Width: 3 mm; Length: 779.3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 735.779 mm; NetArea: 0.716141 m2; GrossArea: 0.573429 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00106193 m3; GrossVolume: 0.00106193 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1242
PLATE | PL/1229

# IfcPlate: PLT3*736.8 (4)
In: Undefined
Description: PLT3*736.8; Material: STEEL/450
Tekla Common - Phase: 1; Class: 11
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Height: 736.8 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 736.797 mm; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Net surface area (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
PLATE | PL/1225 | +4.647 | +5.310 | 8.7 | 0.8 | 828.5 | 0.754841 | 0.610407 | 0.00111941
PLATE | PL/1221 | +4.635 | +5.299 | 8.3 | 0.6 | 778.5 | 0.707041 | 0.573567 | 0.00104816
PLATE | PL/1207 | +4.647 | +5.310 | 8.7 | 0.8 | 828.5 | 0.754841 | 0.610407 | 0.00111941
PLATE | PL/1215 | +4.635 | +5.299 | 8.3 | 0.6 | 778.5 | 0.707041 | 0.573567 | 0.00104816

# IfcPlate: PLT3*760.8 (2)
In: Undefined
Description: PLT3*760.8; Material: STEEL/450
Tekla Common - Bottom elevation: +4.620; Top elevation: +5.299; Phase: 1; Class: 11
Tekla Quantity - Weight: 8.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.6 m2; Height: 760.8 mm; Width: 3 mm; Length: 779.3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 760.794 mm; NetArea: 0.740806 m2; GrossArea: 0.59291 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00109871 m3; GrossVolume: 0.00109871 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1240
PLATE | PL/1234

# IfcPlate: PLT3*779.3 (4)
In: Undefined
Description: PLT3*779.3; Material: STEEL/450
Tekla Common - Phase: 1; Class: 11
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.8 m2; Height: 779.3 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 779.349 mm; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
PLATE | PL/1245 | +4.643 | +5.322 | 9.8 | 860.8 | 0.839392 | 0.670848 | 0.00124569
PLATE | PL/1241 | +4.632 | +5.310 | 9.2 | 810.8 | 0.790092 | 0.63188 | 0.00117219
PLATE | PL/1227 | +4.643 | +5.322 | 9.8 | 860.8 | 0.839392 | 0.670848 | 0.00124569
PLATE | PL/1235 | +4.632 | +5.310 | 9.2 | 810.8 | 0.790092 | 0.63188 | 0.00117219
