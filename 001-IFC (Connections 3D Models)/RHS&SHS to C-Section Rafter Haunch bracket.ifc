Properties of the parts of a building model (IFC2X3), part 4 of 5

# IfcPlate: PLT3*319.9 (2)
BaseQuantities - Width: 319.884 mm; NetArea: 0.191763 m2; GrossArea: 0.109574 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000281501 m3; GrossVolume: 0.000281501 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/913
PLATE | PL/879

# IfcPlate: PLT3*321.8 (2)
In: Undefined
Description: PLT3*321.8; Material: STEEL/450
Tekla Common - Bottom elevation: +4.751; Top elevation: +5.029; Phase: 1; Class: 11
Tekla Quantity - Weight: 1.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.9 m2; Net surface area: 0.2 m2; Height: 321.8 mm; Width: 3 mm; Length: 330.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 321.762 mm; NetArea: 0.162297 m2; GrossArea: 0.106363 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000237751 m3; GrossVolume: 0.000237751 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/851
PLATE | PL/830

# IfcPlate: PLT3*321.9 (2)
In: Undefined
Description: PLT3*321.9; Material: STEEL/450
Tekla Common - Bottom elevation: +5.008; Top elevation: +5.281; Phase: 1; Class: 11
Tekla Quantity - Weight: 2.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.9 m2; Net surface area: 0.2 m2; Height: 321.9 mm; Width: 3 mm; Length: 343.1 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 321.854 mm; NetArea: 0.192676 m2; GrossArea: 0.110415 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000282854 m3; GrossVolume: 0.000282854 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/906
PLATE | PL/884

# IfcPlate: PLT3*323.2 (6)
In: Undefined
Description: PLT3*323.2; Material: STEEL/450
Tekla Common - Phase: 1; Class: 11
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.2 m2; Height: 323.2 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Length (mm) | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
PLATE | PL/867 | +4.750 | +5.020 | 2.4 | 86.7 | 415.5 | 323.159 | 0.210489 | 0.134282 | 0.000309191
PLATE | PL/865 | +4.749 | +5.018 | 2.1 | 86.9 | 365.5 | 323.159 | 0.185191 | 0.118128 | 0.000271694
PLATE | PL/876 | +4.748 | +5.018 | 1.9 | 86.9 | 340.5 | 323.154 | 0.172538 | 0.110044 | 0.00025294
PLATE | PL/815 | +4.750 | +5.020 | 2.4 | 86.7 | 415.5 | 323.159 | 0.210489 | 0.134282 | 0.000309191
PLATE | PL/777 | +4.749 | +5.018 | 2.1 | 86.9 | 365.5 | 323.159 | 0.185191 | 0.118128 | 0.000271694
PLATE | PL/766 | +4.748 | +5.018 | 1.9 | 86.9 | 340.5 | 323.154 | 0.172538 | 0.110044 | 0.00025294

# IfcPlate: PLT3*323.8 (2)
In: Undefined
Description: PLT3*323.8; Material: STEEL/450
Tekla Common - Bottom elevation: +4.767; Top elevation: +5.072; Phase: 1; Class: 11
Tekla Quantity - Weight: 2.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.9 m2; Net surface area: 0.2 m2; Height: 323.8 mm; Width: 3 mm; Length: 408.4 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 323.841 mm; NetArea: 0.182764 m2; GrossArea: 0.132245 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000268044 m3; GrossVolume: 0.000268044 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/869
PLATE | PL/768

# IfcPlate: PLT3*324.9 (2)
In: Undefined
Description: PLT3*324.9; Material: STEEL/450
Tekla Common - Bottom elevation: +4.767; Top elevation: +5.064; Phase: 1; Class: 11
Tekla Quantity - Weight: 2.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.9 m2; Net surface area: 0.2 m2; Height: 324.9 mm; Width: 3 mm; Length: 403.5 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 324.905 mm; NetArea: 0.180629 m2; GrossArea: 0.131108 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000264893 m3; GrossVolume: 0.000264893 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1954
PLATE | PL/1949

# IfcPlate: PLT3*330.6 (8)
In: Undefined
Description: PLT3*330.6; Material: STEEL/450
Tekla Common - Phase: 1; Class: 11
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.2 m2; Height: 330.6 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000009 m2
Name | Bottom elevation | Top elevation | ASSEMBLY_POS = Reference | Weight (kg) | Area per tons (m2) | Length (mm) | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
PLATE | +4.432 | +4.700 | PL/901 | 2.7 | 86.7 | 436.4 | 330.638 | 0.233 | 0.1443 | 0.000342621
PLATE | +4.756 | +5.033 | PL/855 | 2.4 | 86.7 | 421.8 | 330.564 | 0.212896 | 0.139419 | 0.00031275
PLATE | +4.754 | +5.031 | PL/853 | 2.2 | 86.9 | 371.8 | 330.564 | 0.187602 | 0.122894 | 0.000275258
PLATE | +4.752 | +5.030 | PL/872 | 1.9 | 86.9 | 346.8 | 330.564 | 0.174952 | 0.11463 | 0.000256508
PLATE | +4.432 | +4.700 | PL/890 | 2.7 | 86.7 | 436.4 | 330.638 | 0.233 | 0.1443 | 0.000342621
PLATE | +4.756 | +5.033 | PL/834 | 2.4 | 86.7 | 421.8 | 330.564 | 0.212896 | 0.139419 | 0.00031275
PLATE | +4.754 | +5.031 | PL/832 | 2.2 | 86.9 | 371.8 | 330.564 | 0.187602 | 0.122894 | 0.000275258
PLATE | +4.752 | +5.030 | PL/771 | 1.9 | 86.9 | 346.8 | 330.564 | 0.174952 | 0.11463 | 0.000256508

# IfcPlate: PLT3*332.5 (2)
In: Undefined
Description: PLT3*332.5; Material: STEEL/450
Tekla Common - Bottom elevation: +4.432; Top elevation: +4.700; Phase: 1; Class: 11
Tekla Quantity - Weight: 2.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.7 m2; Net surface area: 0.2 m2; Height: 332.5 mm; Width: 3 mm; Length: 430.3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 332.476 mm; NetArea: 0.232204 m2; GrossArea: 0.143059 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000341449 m3; GrossVolume: 0.000341449 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1832
PLATE | PL/1830

# IfcPlate: PLT3*333.2 (2)
In: Undefined
Description: PLT3*333.2; Material: STEEL/450
Tekla Common - Bottom elevation: +5.248; Top elevation: +5.516; Phase: 1; Class: 11
Tekla Quantity - Weight: 2.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.7 m2; Net surface area: 0.2 m2; Height: 333.2 mm; Width: 3 mm; Length: 427.5 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 333.219 mm; NetArea: 0.231805 m2; GrossArea: 0.142462 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00034086 m3; GrossVolume: 0.00034086 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/899
PLATE | PL/895

# IfcPlate: PLT3*333.3 (2)
In: Undefined
Description: PLT3*333.3; Material: STEEL/450
Tekla Common - Bottom elevation: +4.759; Top elevation: +5.052; Phase: 1; Class: 11
Tekla Quantity - Weight: 1.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.9 m2; Net surface area: 0.2 m2; Height: 333.2 mm; Width: 3 mm; Length: 345.3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 333.287 mm; NetArea: 0.166895 m2; GrossArea: 0.115071 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000244543 m3; GrossVolume: 0.000244543 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/857
PLATE | PL/836

# IfcPlate: PLT3*334 (2)
In: Undefined
Description: PLT3*334; Material: STEEL/450
Tekla Common - Bottom elevation: +5.243; Top elevation: +5.516; Phase: 1; Class: 11
Tekla Quantity - Weight: 2.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.9 m2; Net surface area: 0.2 m2; Height: 334 mm; Width: 3 mm; Length: 343.8 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 334.049 mm; NetArea: 0.194335 m2; GrossArea: 0.114846 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000285305 m3; GrossVolume: 0.000285305 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/908
PLATE | PL/886

# IfcPlate: PLT3*335.1 (2)
In: Undefined
Description: PLT3*335.1; Material: STEEL/450
Tekla Common - Bottom elevation: +4.427; Top elevation: +4.700; Phase: 1; Class: 11
Tekla Quantity - Weight: 2.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.9 m2; Net surface area: 0.2 m2; Height: 335.1 mm; Width: 3 mm; Length: 364.8 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 335.136 mm; NetArea: 0.195467 m2; GrossArea: 0.122264 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000286974 m3; GrossVolume: 0.000286974 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/910
PLATE | PL/881

# IfcPlate: PLT3*336.1 (2)
In: Undefined
Description: PLT3*336.1; Material: STEEL/450
Tekla Common - Bottom elevation: +4.764; Top elevation: +5.061; Phase: 1; Class: 11
Tekla Quantity - Weight: 1.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.9 m2; Net surface area: 0.2 m2; Height: 336.1 mm; Width: 3 mm; Length: 348.8 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 336.105 mm; NetArea: 0.167982 m2; GrossArea: 0.117234 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000246147 m3; GrossVolume: 0.000246147 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1952
PLATE | PL/1950

# IfcPlate: PLT3*337 (2)
In: Undefined
Description: PLT3*337; Material: STEEL/450
Tekla Common - Bottom elevation: +4.427; Top elevation: +4.700; Phase: 1; Class: 11
Tekla Quantity - Weight: 2.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.9 m2; Net surface area: 0.2 m2; Height: 337 mm; Width: 3 mm; Length: 358.2 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 337.004 mm; NetArea: 0.194717 m2; GrossArea: 0.120703 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000285869 m3; GrossVolume: 0.000285869 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1958
PLATE | PL/1956

# IfcPlate: PLT3*337.9 (4)
In: Undefined
Description: PLT3*337.9; Material: STEEL/450
Tekla Common - Phase: 1; Class: 11
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.2 m2; Height: 337.9 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Length (mm) | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
PLATE | PL/904 | +4.900 | +5.168 | 2.6 | 86.7 | 393.2 | 337.858 | 0.229121 | 0.132847 | 0.000336892
PLATE | PL/912 | +4.734 | +5.019 | 2.3 | 86.9 | 352.9 | 337.914 | 0.195367 | 0.119247 | 0.000286845
PLATE | PL/888 | +4.900 | +5.168 | 2.6 | 86.7 | 393.2 | 337.858 | 0.229121 | 0.132847 | 0.000336892
PLATE | PL/878 | +4.734 | +5.019 | 2.3 | 86.9 | 352.9 | 337.914 | 0.195367 | 0.119247 | 0.000286846

# IfcPlate: PLT3*338.3 (2)
In: Undefined
Description: PLT3*338.3; Material: STEEL/450
Tekla Common - Bottom elevation: +5.013; Top elevation: +5.281; Phase: 1; Class: 11
Tekla Quantity - Weight: 2.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.7 m2; Net surface area: 0.2 m2; Height: 338.3 mm; Width: 3 mm; Length: 396.9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 338.307 mm; NetArea: 0.230068 m2; GrossArea: 0.134258 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000338293 m3; GrossVolume: 0.000338293 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/897
PLATE | PL/893

# IfcPlate: PLT3*341.1 (2)
In: Undefined
Description: PLT3*341.1; Material: STEEL/450
Tekla Common - Bottom elevation: +4.764; Top elevation: +5.069; Phase: 1; Class: 11
Tekla Quantity - Weight: 1.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.9 m2; Net surface area: 0.2 m2; Height: 341.1 mm; Width: 3 mm; Length: 356.1 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 341.111 mm; NetArea: 0.170116 m2; GrossArea: 0.121468 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000249297 m3; GrossVolume: 0.000249297 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/842
PLATE | PL/817

# IfcPlate: PLT3*345.3 (6)
In: Undefined
Description: PLT3*345.3; Material: STEEL/450
Tekla Common - Phase: 1; Class: 11
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.2 m2; Height: 345.3 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 345.26 mm; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
PLATE | PL/861 | +4.767 | +5.060 | 2.4 | 86.7 | 433.3 | 0.217491 | 0.149593 | 0.000319538
PLATE | PL/859 | +4.763 | +5.056 | 2.2 | 86.9 | 383.3 | 0.192191 | 0.13233 | 0.000282037
PLATE | PL/874 | +4.761 | +5.054 | 2.1 | 86.9 | 358.2 | 0.17954 | 0.123699 | 0.000263286
PLATE | PL/840 | +4.767 | +5.060 | 2.4 | 86.7 | 433.3 | 0.217491 | 0.149593 | 0.000319538
PLATE | PL/838 | +4.763 | +5.056 | 2.2 | 86.9 | 383.3 | 0.192191 | 0.13233 | 0.000282037
PLATE | PL/773 | +4.761 | +5.054 | 2.1 | 86.9 | 358.2 | 0.17954 | 0.123699 | 0.000263286

# IfcPlate: PLT3*346.5 (2)
In: Undefined
Description: PLT3*346.5; Material: STEEL/450
Tekla Common - Bottom elevation: +4.739; Top elevation: +5.032; Phase: 1; Class: 11
Tekla Quantity - Weight: 2.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.7 m2; Net surface area: 0.2 m2; Height: 346.5 mm; Width: 3 mm; Length: 360.3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 346.46 mm; NetArea: 0.19866 m2; GrossArea: 0.12484 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000291725 m3; GrossVolume: 0.000291725 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/905
PLATE | PL/883

# IfcPlate: PLT3*348.1 (2)
In: Undefined
Description: PLT3*348.1; Material: STEEL/450
Tekla Common - Bottom elevation: +4.770; Top elevation: +5.086; Phase: 1; Class: 11
Tekla Quantity - Weight: 1.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.9 m2; Net surface area: 0.2 m2; Height: 348.1 mm; Width: 3 mm; Length: 366.8 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 348.132 mm; NetArea: 0.173148 m2; GrossArea: 0.127695 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000253769 m3; GrossVolume: 0.000253769 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/848
PLATE | PL/823

# IfcPlate: PLT3*348.3 (2)
In: Undefined
Description: PLT3*348.3; Material: STEEL/450
Tekla Common - Bottom elevation: +4.741; Top elevation: +5.021; Phase: 1; Class: 11
Tekla Quantity - Weight: 2.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.7 m2; Net surface area: 0.2 m2; Height: 348.3 mm; Width: 3 mm; Length: 411.4 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 348.307 mm; NetArea: 0.232595 m2; GrossArea: 0.143304 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000342043 m3; GrossVolume: 0.000342043 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/903
PLATE | PL/887

# IfcPlate: PLT3*348.8 (4)
In: Undefined
Description: PLT3*348.8; Material: STEEL/450
Tekla Common - Phase: 1; Class: 11
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.2 m2; Height: 348.8 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Length (mm) | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
PLATE | PL/1825 | +4.770 | +5.067 | 2.2 | 86.9 | 386.1 | 348.823 | 0.193283 | 0.134672 | 0.000283649
PLATE | PL/1827 | +4.775 | +5.072 | 2.4 | 86.7 | 436.1 | 348.821 | 0.218585 | 0.15212 | 0.000321152
PLATE | PL/1823 | +4.775 | +5.072 | 2.4 | 86.7 | 436.1 | 348.821 | 0.218585 | 0.15212 | 0.000321152
PLATE | PL/1821 | +4.770 | +5.067 | 2.2 | 86.9 | 386.1 | 348.823 | 0.193283 | 0.134672 | 0.000283649

# IfcPlate: PLT3*354.5 (2)
In: Undefined
Description: PLT3*354.5; Material: STEEL/450
Tekla Common - Bottom elevation: +4.776; Top elevation: +5.104; Phase: 1; Class: 11
Tekla Quantity - Weight: 1.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.9 m2; Net surface area: 0.2 m2; Height: 354.5 mm; Width: 3 mm; Length: 377.3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 354.532 mm; NetArea: 0.176015 m2; GrossArea: 0.133769 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000257993 m3; GrossVolume: 0.000257993 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1174
PLATE | PL/1168

# IfcPlate: PLT3*355.8 (2)
In: Undefined
Description: PLT3*355.8; Material: STEEL/450
Tekla Common - Bottom elevation: +4.747; Top elevation: +5.035; Phase: 1; Class: 11
Tekla Quantity - Weight: 2.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.7 m2; Net surface area: 0.2 m2; Height: 355.8 mm; Width: 3 mm; Length: 420.1 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 355.773 mm; NetArea: 0.235846 m2; GrossArea: 0.149448 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000346862 m3; GrossVolume: 0.000346862 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/896
PLATE | PL/892

# IfcPlate: PLT3*356.1 (4)
In: Undefined
Description: PLT3*356.1; Material: STEEL/450
Tekla Common - Phase: 1; Class: 11
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.2 m2; Height: 356.1 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Length (mm) | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
PLATE | PL/846 | +4.775 | +5.080 | 2.4 | 86.7 | 441.1 | 356.112 | 0.220719 | 0.157083 | 0.000324302
PLATE | PL/844 | +4.770 | +5.074 | 2.3 | 86.9 | 391.1 | 356.115 | 0.195417 | 0.13927 | 0.000286799
PLATE | PL/821 | +4.775 | +5.080 | 2.4 | 86.7 | 441.1 | 356.112 | 0.220719 | 0.157083 | 0.000324302
PLATE | PL/819 | +4.770 | +5.074 | 2.3 | 86.9 | 391.1 | 356.115 | 0.195417 | 0.13927 | 0.000286799

# IfcPlate: PLT3*361.2 (2)
In: Undefined
Description: PLT3*361.2; Material: STEEL/450
Tekla Common - Bottom elevation: +4.783; Top elevation: +5.100; Phase: 1; Class: 11
Tekla Quantity - Weight: 2.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.7 m2; Net surface area: 0.2 m2; Height: 361.2 mm; Width: 3 mm; Length: 479.3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 361.208 mm; NetArea: 0.223743 m2; GrossArea: 0.173144 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000328762 m3; GrossVolume: 0.000328762 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/850
PLATE | PL/825

# IfcPlate: PLT3*362.6 (2)
In: Undefined
Description: PLT3*362.6; Material: STEEL/450
Tekla Common - Bottom elevation: +4.749; Top elevation: +5.058; Phase: 1; Class: 11
Tekla Quantity - Weight: 2.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.7 m2; Net surface area: 0.2 m2; Height: 362.6 mm; Width: 3 mm; Length: 375 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 362.601 mm; NetArea: 0.205018 m2; GrossArea: 0.135989 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000301146 m3; GrossVolume: 0.000301146 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/907
PLATE | PL/885

# IfcPlate: PLT3*366.3 (2)
In: Undefined
Description: PLT3*366.3; Material: STEEL/450
Tekla Common - Bottom elevation: +4.790; Top elevation: +5.144; Phase: 1; Class: 11
Tekla Quantity - Weight: 2.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.9 m2; Net surface area: 0.2 m2; Height: 366.3 mm; Width: 3 mm; Length: 401.1 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 366.265 mm; NetArea: 0.181909 m2; GrossArea: 0.1469 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000266661 m3; GrossVolume: 0.000266661 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1177
PLATE | PL/1171

# IfcPlate: PLT3*366.5 (2)
In: Undefined
Description: PLT3*366.5; Material: STEEL/450
Tekla Common - Bottom elevation: +4.757; Top elevation: +5.069; Phase: 1; Class: 11
Tekla Quantity - Weight: 2.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.7 m2; Net surface area: 0.2 m2; Height: 366.5 mm; Width: 3 mm; Length: 378.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 366.486 mm; NetArea: 0.206547 m2; GrossArea: 0.138767 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00030341 m3; GrossVolume: 0.00030341 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1957
PLATE | PL/1955

# IfcPlate: PLT3*366.8 (4)
In: Undefined
Description: PLT3*366.8; Material: STEEL/450
Tekla Common - Phase: 1; Class: 11
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.9 m2; Net surface area: 0.2 m2; Height: 366.8 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Length (mm) | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
PLATE | PL/849 | +4.777 | +5.093 | 2.3 | 398.1 | 366.8 | 0.198447 | 0.146031 | 0.000291268
PLATE | PL/871 | +4.773 | +5.090 | 2.1 | 373.1 | 366.801 | 0.1858 | 0.136865 | 0.000272522
PLATE | PL/824 | +4.777 | +5.093 | 2.3 | 398.1 | 366.8 | 0.198447 | 0.146031 | 0.000291268
PLATE | PL/770 | +4.773 | +5.090 | 2.1 | 373.1 | 366.801 | 0.1858 | 0.136865 | 0.000272522

# IfcPlate: PLT3*370.5 (2)
In: Undefined
Description: PLT3*370.5; Material: STEEL/450
Tekla Common - Bottom elevation: +4.760; Top elevation: +5.064; Phase: 1; Class: 11
Tekla Quantity - Weight: 2.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.7 m2; Net surface area: 0.2 m2; Height: 370.5 mm; Width: 3 mm; Length: 436.3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 370.507 mm; NetArea: 0.242092 m2; GrossArea: 0.161655 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000356116 m3; GrossVolume: 0.000356116 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/898
PLATE | PL/894

# IfcPlate: PLT3*373.7 (2)
In: Undefined
Description: PLT3*373.7; Material: STEEL/450
Tekla Common - Bottom elevation: +4.757; Top elevation: +5.077; Phase: 1; Class: 11
Tekla Quantity - Weight: 2.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.7 m2; Net surface area: 0.2 m2; Height: 373.7 mm; Width: 3 mm; Length: 385.9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 373.706 mm; NetArea: 0.209549 m2; GrossArea: 0.144218 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000307856 m3; GrossVolume: 0.000307856 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/909
PLATE | PL/880

# IfcPlate: PLT3*374.1 (2)
In: Undefined
Description: PLT3*374.1; Material: STEEL/450
Tekla Common - Bottom elevation: +4.770; Top elevation: +5.077; Phase: 1; Class: 11
Tekla Quantity - Weight: 2.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.7 m2; Net surface area: 0.2 m2; Height: 374.1 mm; Width: 3 mm; Length: 440.3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 374.087 mm; NetArea: 0.243598 m2; GrossArea: 0.164712 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000358346 m3; GrossVolume: 0.000358346 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1831
PLATE | PL/1829

# IfcPlate: PLT3*377.3 (2)
In: Undefined
Description: PLT3*377.3; Material: STEEL/450
Tekla Common - Bottom elevation: +4.780; Top elevation: +5.108; Phase: 1; Class: 11
Tekla Quantity - Weight: 2.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.9 m2; Net surface area: 0.2 m2; Height: 377.3 mm; Width: 3 mm; Length: 379.5 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 377.312 mm; NetArea: 0.188665 m2; GrossArea: 0.143202 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000276743 m3; GrossVolume: 0.000276743 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1180
PLATE | PL/1166

# IfcPlate: PLT3*377.4 (4)
In: Undefined
Description: PLT3*377.4; Material: STEEL/450
Tekla Common - Phase: 1; Class: 11
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.2 m2; Height: 377.4 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 377.352 mm; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
PLATE | PL/1176 | +4.792 | +5.120 | 2.6 | 86.7 | 454.5 | 0.226616 | 0.171496 | 0.000332995
PLATE | PL/1175 | +4.784 | +5.112 | 2.3 | 86.9 | 404.5 | 0.201316 | 0.152629 | 0.000295494
PLATE | PL/1170 | +4.792 | +5.120 | 2.6 | 86.7 | 454.5 | 0.226616 | 0.171496 | 0.000332995
PLATE | PL/1169 | +4.784 | +5.112 | 2.3 | 86.9 | 404.5 | 0.201316 | 0.152629 | 0.000295494

# IfcPlate: PLT3*381.4 (2)
In: Undefined
Description: PLT3*381.4; Material: STEEL/450
Tekla Common - Bottom elevation: +4.770; Top elevation: +5.085; Phase: 1; Class: 11
Tekla Quantity - Weight: 2.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.7 m2; Net surface area: 0.2 m2; Height: 381.4 mm; Width: 3 mm; Length: 447.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 381.368 mm; NetArea: 0.246555 m2; GrossArea: 0.170692 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000362725 m3; GrossVolume: 0.000362725 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/900
PLATE | PL/889

# IfcPlate: PLT3*384.2 (2)
In: Undefined
Description: PLT3*384.2; Material: STEEL/450
Tekla Common - Bottom elevation: +4.765; Top elevation: +5.097; Phase: 1; Class: 11
Tekla Quantity - Weight: 2.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.7 m2; Net surface area: 0.2 m2; Height: 384.2 mm; Width: 3 mm; Length: 396.5 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 384.173 mm; NetArea: 0.213883 m2; GrossArea: 0.152342 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00031427 m3; GrossVolume: 0.00031427 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/911
PLATE | PL/882

# IfcPlate: PLT3*391.3 (2)
In: Undefined
Description: PLT3*391.3; Material: STEEL/450
Tekla Common - Bottom elevation: +4.796; Top elevation: +5.150; Phase: 1; Class: 11
Tekla Quantity - Weight: 2.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.9 m2; Net surface area: 0.2 m2; Height: 391.3 mm; Width: 3 mm; Length: 401.1 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 391.265 mm; NetArea: 0.194558 m2; GrossArea: 0.156927 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000285411 m3; GrossVolume: 0.000285411 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1181
PLATE | PL/1167

# IfcPlate: PLT3*392 (2)
In: Undefined
Description: PLT3*392; Material: STEEL/450
Tekla Common - Bottom elevation: +4.780; Top elevation: +5.107; Phase: 1; Class: 11
Tekla Quantity - Weight: 3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.7 m2; Net surface area: 0.3 m2; Height: 392 mm; Width: 3 mm; Length: 458.1 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 392.029 mm; NetArea: 0.250822 m2; GrossArea: 0.179583 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00036904 m3; GrossVolume: 0.00036904 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/902
PLATE | PL/891

# IfcPlate: PLT3*393.7 (2)
In: Undefined
Description: PLT3*393.7; Material: STEEL/450
Tekla Common - Bottom elevation: +4.773; Top elevation: +5.116; Phase: 1; Class: 11
Tekla Quantity - Weight: 2.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.7 m2; Net surface area: 0.2 m2; Height: 393.7 mm; Width: 3 mm; Length: 407 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 393.697 mm; NetArea: 0.218008 m2; GrossArea: 0.160251 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000320373 m3; GrossVolume: 0.000320373 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1188
PLATE | PL/1182

# IfcPlate: PLT3*401.1 (4)
In: Undefined
Description: PLT3*401.1; Material: STEEL/450
Tekla Common - Phase: 1; Class: 11
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.2 m2; Height: 401.1 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 401.077 mm; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
PLATE | PL/1179 | +4.814 | +5.168 | 2.7 | 86.7 | 466.3 | 0.232508 | 0.187008 | 0.000341661
PLATE | PL/1178 | +4.802 | +5.156 | 2.4 | 86.9 | 416.3 | 0.207208 | 0.166954 | 0.000304161
PLATE | PL/1173 | +4.814 | +5.168 | 2.7 | 86.7 | 466.3 | 0.232508 | 0.187008 | 0.000341661
PLATE | PL/1172 | +4.802 | +5.156 | 2.4 | 86.9 | 416.3 | 0.207208 | 0.166954 | 0.000304161

# IfcPlate: PLT3*402.5 (2)
In: Undefined
Description: PLT3*402.5; Material: STEEL/450
Tekla Common - Bottom elevation: +4.790; Top elevation: +5.128; Phase: 1; Class: 11
Tekla Quantity - Weight: 3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.7 m2; Net surface area: 0.3 m2; Height: 402.5 mm; Width: 3 mm; Length: 467.7 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 402.544 mm; NetArea: 0.254886 m2; GrossArea: 0.188254 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000375051 m3; GrossVolume: 0.000375051 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1186
PLATE | PL/1184

# IfcPlate: PLT3*412.8 (2)
In: Undefined
Description: PLT3*412.8; Material: STEEL/450
Tekla Common - Bottom elevation: +4.793; Top elevation: +5.162; Phase: 1; Class: 11
Tekla Quantity - Weight: 2.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.7 m2; Net surface area: 0.2 m2; Height: 412.8 mm; Width: 3 mm; Length: 430.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 412.759 mm; NetArea: 0.226787 m2; GrossArea: 0.177724 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000333346 m3; GrossVolume: 0.000333346 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1189
PLATE | PL/1183

# IfcPlate: PLT3*426.1 (2)
In: Undefined
Description: PLT3*426.1; Material: STEEL/450
Tekla Common - Bottom elevation: +4.815; Top elevation: +5.180; Phase: 1; Class: 11
Tekla Quantity - Weight: 3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.7 m2; Net surface area: 0.3 m2; Height: 426.1 mm; Width: 3 mm; Length: 486.9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 426.083 mm; NetArea: 0.263536 m2; GrossArea: 0.207453 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000387834 m3; GrossVolume: 0.000387834 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1187
PLATE | PL/1185

# IfcPlate: PLT3*426.4 (6)
In: Undefined
Description: PLT3*426.4; Material: STEEL/450
Tekla Common - Bottom elevation: +4.332; Top elevation: +4.700; Phase: 1; Class: 11
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.3 m2; Height: 426.4 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Weight (kg) | Area per tons (m2) | Length (mm) | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
PLATE | PL/955 | 4.7 | 86.2 | 588.8 | 426.446 | 0.405298 | 0.251088 | 0.000598949
PLATE | PL/953 | 4.3 | 86.3 | 539.9 | 426.444 | 0.368998 | 0.230235 | 0.000544949
PLATE | PL/978 | 4.1 | 86.3 | 515.4 | 426.444 | 0.350848 | 0.219807 | 0.000517949
PLATE | PL/941 | 4.7 | 86.2 | 588.8 | 426.446 | 0.405298 | 0.251088 | 0.000598949
PLATE | PL/939 | 4.3 | 86.3 | 539.9 | 426.444 | 0.368998 | 0.230235 | 0.000544949
PLATE | PL/919 | 4.1 | 86.3 | 515.4 | 426.444 | 0.350848 | 0.219807 | 0.000517949

# IfcPlate: PLT3*436 (2)
In: Undefined
Description: PLT3*436; Material: STEEL/450
Tekla Common - Bottom elevation: +4.903; Top elevation: +5.281; Phase: 1; Class: 11
Tekla Quantity - Weight: 3.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.3 m2; Height: 436 mm; Width: 3 mm; Length: 446.4 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 435.977 mm; NetArea: 0.334517 m2; GrossArea: 0.19461 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000493674 m3; GrossVolume: 0.000493674 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/972
PLATE | PL/930

# IfcPlate: PLT3*436.3 (6)
In: Undefined
Description: PLT3*436.3; Material: STEEL/450
Tekla Common - Bottom elevation: +4.800; Top elevation: +5.168; Phase: 1; Class: 11
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.3 m2; Height: 436.3 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Weight (kg) | Area per tons (m2) | Length (mm) | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
PLATE | PL/970 | 4.7 | 86.2 | 535.1 | 436.293 | 0.400162 | 0.23345 | 0.000591319
PLATE | PL/968 | 4.1 | 86.3 | 485.1 | 436.293 | 0.363862 | 0.211635 | 0.000537319
PLATE | PL/983 | 3.9 | 86.3 | 460.1 | 436.303 | 0.345721 | 0.200736 | 0.000510331
PLATE | PL/928 | 4.7 | 86.2 | 535.1 | 436.293 | 0.400162 | 0.23345 | 0.000591319
PLATE | PL/926 | 4.1 | 86.3 | 485.1 | 436.293 | 0.363862 | 0.211635 | 0.000537319
PLATE | PL/915 | 3.9 | 86.3 | 460.1 | 436.303 | 0.345721 | 0.200736 | 0.000510331

# IfcPlate: PLT3*437 (6)
In: Undefined
Description: PLT3*437; Material: STEEL/450
Tekla Common - Bottom elevation: +4.913; Top elevation: +5.281; Phase: 1; Class: 11
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.3 m2; Height: 437 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 436.967 mm; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Weight (kg) | Area per tons (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
PLATE | PL/976 | 4.7 | 86.2 | 536 | 0.4015 | 0.234204 | 0.00059331
PLATE | PL/974 | 4.1 | 86.3 | 486 | 0.3652 | 0.212356 | 0.00053931
PLATE | PL/985 | 3.9 | 86.3 | 461 | 0.34705 | 0.201432 | 0.00051231
PLATE | PL/934 | 4.7 | 86.2 | 536 | 0.4015 | 0.234204 | 0.00059331
PLATE | PL/932 | 4.1 | 86.3 | 486 | 0.3652 | 0.212356 | 0.00053931
PLATE | PL/917 | 3.9 | 86.3 | 461 | 0.34705 | 0.201432 | 0.00051231

# IfcPlate: PLT3*437.4 (2)
In: Undefined
Description: PLT3*437.4; Material: STEEL/450
Tekla Common - Bottom elevation: +4.790; Top elevation: +5.168; Phase: 1; Class: 11
Tekla Quantity - Weight: 3.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.3 m2; Height: 437.4 mm; Width: 3 mm; Length: 445.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 437.352 mm; NetArea: 0.333244 m2; GrossArea: 0.194902 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000491778 m3; GrossVolume: 0.000491778 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/966
PLATE | PL/924

# IfcPlate: PLT3*438.1 (6)
In: Undefined
Description: PLT3*438.1; Material: STEEL/450
Tekla Common - Bottom elevation: +5.148; Top elevation: +5.516; Phase: 1; Class: 11
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.3 m2; Height: 438.1 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 438.08 mm; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Weight (kg) | Area per tons (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
PLATE | PL/963 | 4.7 | 86.2 | 551 | 0.403811 | 0.241373 | 0.000596745
PLATE | PL/961 | 4.3 | 86.3 | 501 | 0.367512 | 0.219469 | 0.000542746
PLATE | PL/981 | 3.9 | 86.3 | 476 | 0.349362 | 0.208517 | 0.000515746
PLATE | PL/949 | 4.7 | 86.2 | 551 | 0.403811 | 0.241373 | 0.000596745
PLATE | PL/947 | 4.3 | 86.3 | 501 | 0.367512 | 0.219469 | 0.000542746
PLATE | PL/922 | 3.9 | 86.3 | 476 | 0.349362 | 0.208517 | 0.000515746

# IfcPlate: PLT3*438.4 (6)
In: Undefined
Description: PLT3*438.4; Material: STEEL/450
Tekla Common - Bottom elevation: +4.332; Top elevation: +4.700; Phase: 1; Class: 11
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.3 m2; Height: 438.4 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 438.352 mm; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Weight (kg) | Area per tons (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
PLATE | PL/1704 | 4.1 | 86.3 | 479.5 | 0.349883 | 0.210178 | 0.000516519
PLATE | PL/1838 | 4.3 | 86.3 | 504.5 | 0.36803 | 0.221136 | 0.000543515
PLATE | PL/1840 | 4.7 | 86.2 | 554.5 | 0.40433 | 0.243054 | 0.000597514
PLATE | PL/1836 | 4.7 | 86.2 | 554.5 | 0.40433 | 0.243054 | 0.000597514
PLATE | PL/1834 | 4.3 | 86.3 | 504.5 | 0.36803 | 0.221136 | 0.000543515
PLATE | PL/1698 | 4.1 | 86.3 | 479.5 | 0.349883 | 0.210178 | 0.000516519

# IfcPlate: PLT3*447.6 (2)
In: Undefined
Description: PLT3*447.6; Material: STEEL/450
Tekla Common - Bottom elevation: +5.138; Top elevation: +5.516; Phase: 1; Class: 11
Tekla Quantity - Weight: 3.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.3 m2; Height: 447.6 mm; Width: 3 mm; Length: 451 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 447.643 mm; NetArea: 0.336681 m2; GrossArea: 0.201878 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000496893 m3; GrossVolume: 0.000496893 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/959
PLATE | PL/945

# IfcPlate: PLT3*448 (2)
In: Undefined
Description: PLT3*448; Material: STEEL/450
Tekla Common - Bottom elevation: +4.322; Top elevation: +4.700; Phase: 1; Class: 11
Tekla Quantity - Weight: 3.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.3 m2; Height: 448 mm; Width: 3 mm; Length: 454.5 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 447.969 mm; NetArea: 0.337163 m2; GrossArea: 0.203589 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000497608 m3; GrossVolume: 0.000497608 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1962
PLATE | PL/1960

# IfcPlate: PLT3*448.4 (2)
In: Undefined
Description: PLT3*448.4; Material: STEEL/450
Tekla Common - Bottom elevation: +4.322; Top elevation: +4.700; Phase: 1; Class: 11
Tekla Quantity - Weight: 3.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.3 m2; Height: 448.4 mm; Width: 3 mm; Length: 461.1 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 448.398 mm; NetArea: 0.338041 m2; GrossArea: 0.206775 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000498911 m3; GrossVolume: 0.000498911 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/951
PLATE | PL/937

# IfcPlate: PLT3*450.8 (6)
In: Undefined
Description: PLT3*450.8; Material: STEEL/450
Tekla Common - Phase: 1; Class: 11
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.3 m2; Height: 450.8 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 450.777 mm; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
PLATE | PL/969 | +4.644 | +5.028 | 4.7 | 86.2 | 555.2 | 0.405695 | 0.250287 | 0.000599523
PLATE | PL/967 | +4.643 | +5.027 | 4.3 | 86.3 | 505.2 | 0.369388 | 0.227744 | 0.000545512
PLATE | PL/982 | +4.642 | +5.026 | 4.1 | 86.3 | 480.2 | 0.351245 | 0.216479 | 0.000518523
PLATE | PL/927 | +4.644 | +5.028 | 4.7 | 86.2 | 555.2 | 0.405695 | 0.250287 | 0.000599523
PLATE | PL/925 | +4.643 | +5.027 | 4.3 | 86.3 | 505.2 | 0.369388 | 0.227744 | 0.000545512
PLATE | PL/914 | +4.642 | +5.026 | 4.1 | 86.3 | 480.2 | 0.351245 | 0.216479 | 0.000518523

# IfcPlate: PLT3*457.2 (2)
In: Undefined
Description: PLT3*457.2; Material: STEEL/450
Tekla Common - Bottom elevation: +4.631; Top elevation: +5.025; Phase: 1; Class: 11
Tekla Quantity - Weight: 3.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.3 m2; Height: 457.2 mm; Width: 3 mm; Length: 460 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 457.233 mm; NetArea: 0.339034 m2; GrossArea: 0.210326 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000500363 m3; GrossVolume: 0.000500363 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/965
PLATE | PL/923

# IfcPlate: PLT3*461.3 (6)
In: Undefined
Description: PLT3*461.3; Material: STEEL/450
Tekla Common - Phase: 1; Class: 11
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.3 m2; Height: 461.3 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 461.265 mm; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
PLATE | PL/975 | +4.652 | +5.047 | 4.9 | 86.2 | 565 | 0.411282 | 0.260592 | 0.00060782
PLATE | PL/973 | +4.650 | +5.045 | 4.3 | 86.3 | 515 | 0.374989 | 0.237533 | 0.000553831
PLATE | PL/984 | +4.649 | +5.044 | 4.1 | 86.3 | 490 | 0.356839 | 0.226002 | 0.000526831
PLATE | PL/933 | +4.652 | +5.047 | 4.9 | 86.2 | 565 | 0.411282 | 0.260592 | 0.00060782
PLATE | PL/931 | +4.650 | +5.045 | 4.3 | 86.3 | 515 | 0.374989 | 0.237533 | 0.000553831
PLATE | PL/916 | +4.649 | +5.044 | 4.1 | 86.3 | 490 | 0.356839 | 0.226002 | 0.000526831

# IfcPlate: PLT3*466.8 (2)
In: Undefined
Description: PLT3*466.8; Material: STEEL/450
Tekla Common - Bottom elevation: +4.638; Top elevation: +5.043; Phase: 1; Class: 11
Tekla Quantity - Weight: 3.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.3 m2; Height: 466.8 mm; Width: 3 mm; Length: 470.5 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 466.754 mm; NetArea: 0.344721 m2; GrossArea: 0.219608 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00050881 m3; GrossVolume: 0.00050881 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/971
PLATE | PL/929

# IfcPlate: PLT3*481.6 (6)
In: Undefined
Description: PLT3*481.6; Material: STEEL/450
Tekla Common - Phase: 1; Class: 11
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.3 m2; Height: 481.6 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 481.596 mm; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
PLATE | PL/962 | +4.668 | +5.085 | 4.9 | 86.2 | 583.8 | 0.420229 | 0.281135 | 0.000621092
PLATE | PL/960 | +4.664 | +5.081 | 4.5 | 86.2 | 533.8 | 0.383929 | 0.257055 | 0.000567091
PLATE | PL/980 | +4.662 | +5.079 | 4.1 | 86.3 | 508.7 | 0.365771 | 0.245011 | 0.00054008
PLATE | PL/948 | +4.668 | +5.085 | 4.9 | 86.2 | 583.8 | 0.420229 | 0.281135 | 0.000621092
PLATE | PL/946 | +4.664 | +5.081 | 4.5 | 86.2 | 533.8 | 0.383929 | 0.257055 | 0.000567091
PLATE | PL/921 | +4.662 | +5.079 | 4.1 | 86.3 | 508.7 | 0.365771 | 0.245011 | 0.00054008

# IfcPlate: PLT3*485.5 (2)
In: Undefined
Description: PLT3*485.5; Material: STEEL/450
Tekla Common - Bottom elevation: +4.650; Top elevation: +5.077; Phase: 1; Class: 11
Tekla Quantity - Weight: 4.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.3 m2; Height: 485.5 mm; Width: 3 mm; Length: 490.8 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 485.472 mm; NetArea: 0.353912 m2; GrossArea: 0.238275 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000522443 m3; GrossVolume: 0.000522443 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/958
PLATE | PL/944

# IfcPlate: PLT3*486.4 (2)
In: Undefined
Description: PLT3*486.4; Material: STEEL/450
Tekla Common - Bottom elevation: +4.675; Top elevation: +5.097; Phase: 1; Class: 11
Tekla Quantity - Weight: 4.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.2 m2; Net surface area: 0.3 m2; Height: 486.4 mm; Width: 3 mm; Length: 537.3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 486.432 mm; NetArea: 0.385422 m2; GrossArea: 0.261345 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000569303 m3; GrossVolume: 0.000569303 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1837
PLATE | PL/1833

# IfcPlate: PLT3*486.6 (4)
In: Undefined
Description: PLT3*486.6; Material: STEEL/450
Tekla Common - Phase: 1; Class: 11
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.3 m2; Height: 486.6 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 486.608 mm; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
PLATE | PL/1703 | +4.673 | +5.095 | 4.3 | 86.3 | 513.3 | 0.368052 | 0.249766 | 0.000543463
PLATE | PL/1839 | +4.681 | +5.103 | 4.9 | 86.2 | 588.3 | 0.422513 | 0.28626 | 0.000624479
PLATE | PL/1835 | +4.681 | +5.103 | 4.9 | 86.2 | 588.3 | 0.422513 | 0.28626 | 0.000624479
PLATE | PL/1697 | +4.673 | +5.095 | 4.3 | 86.3 | 513.3 | 0.368052 | 0.249766 | 0.000543463

# IfcPlate: PLT3*489.8 (2)
In: Undefined
Description: PLT3*489.8; Material: STEEL/450
Tekla Common - Bottom elevation: +4.660; Top elevation: +5.092; Phase: 1; Class: 11
Tekla Quantity - Weight: 4.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.3 m2; Height: 489.8 mm; Width: 3 mm; Length: 495.9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 489.771 mm; NetArea: 0.356246 m2; GrossArea: 0.242877 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000525906 m3; GrossVolume: 0.000525906 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1961
PLATE | PL/1959

# IfcPlate: PLT3*496.8 (6)
In: Undefined
Description: PLT3*496.8; Material: STEEL/450
Tekla Common - Phase: 1; Class: 11
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.3 m2; Height: 496.8 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Length (mm) | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
PLATE | PL/954 | +4.681 | +5.113 | 4.9 | 86.2 | 596.5 | 496.753 | 0.426966 | 0.296334 | 0.000631082
PLATE | PL/952 | +4.675 | +5.108 | 4.5 | 86.2 | 546.5 | 496.773 | 0.390664 | 0.271482 | 0.000577079
PLATE | PL/977 | +4.673 | +5.105 | 4.3 | 86.3 | 521.5 | 496.751 | 0.372497 | 0.259073 | 0.000550054
PLATE | PL/940 | +4.681 | +5.113 | 4.9 | 86.2 | 596.5 | 496.753 | 0.426966 | 0.296334 | 0.000631082
PLATE | PL/938 | +4.675 | +5.108 | 4.5 | 86.2 | 546.5 | 496.773 | 0.390664 | 0.271482 | 0.000577079
PLATE | PL/918 | +4.673 | +5.105 | 4.3 | 86.3 | 521.5 | 496.751 | 0.372497 | 0.259073 | 0.000550054

# IfcPlate: PLT3*498 (2)
In: Undefined
Description: PLT3*498; Material: STEEL/450
Tekla Common - Bottom elevation: +4.660; Top elevation: +5.103; Phase: 1; Class: 11
Tekla Quantity - Weight: 4.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.3 m2; Height: 498 mm; Width: 3 mm; Length: 506 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 497.952 mm; NetArea: 0.360788 m2; GrossArea: 0.251983 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000532641 m3; GrossVolume: 0.000532641 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/950
PLATE | PL/936

# IfcPlate: PLT3*509.7 (2)
In: Undefined
Description: PLT3*509.7; Material: STEEL/450
Tekla Common - Bottom elevation: +4.670; Top elevation: +5.129; Phase: 1; Class: 11
Tekla Quantity - Weight: 4.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.3 m2; Height: 509.7 mm; Width: 3 mm; Length: 520.9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 509.73 mm; NetArea: 0.367301 m2; GrossArea: 0.265522 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000542294 m3; GrossVolume: 0.000542294 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/956
PLATE | PL/942

# IfcPlate: PLT3*511.7 (6)
In: Undefined
Description: PLT3*511.7; Material: STEEL/450
Tekla Common - Phase: 1; Class: 11
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.3 m2; Height: 511.7 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 511.683 mm; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
PLATE | PL/964 | +4.693 | +5.142 | 4.9 | 86.2 | 608.3 | 0.433319 | 0.311244 | 0.000640499
PLATE | PL/957 | +4.687 | +5.135 | 4.7 | 86.2 | 558.3 | 0.39702 | 0.28566 | 0.000586499
PLATE | PL/979 | +4.683 | +5.132 | 4.5 | 86.3 | 533.3 | 0.37887 | 0.272867 | 0.0005595
PLATE | PL/935 | +4.693 | +5.142 | 4.9 | 86.2 | 608.3 | 0.433319 | 0.311244 | 0.000640499
PLATE | PL/943 | +4.687 | +5.135 | 4.7 | 86.2 | 558.3 | 0.39702 | 0.28566 | 0.000586499
PLATE | PL/920 | +4.683 | +5.132 | 4.5 | 86.3 | 533.3 | 0.37887 | 0.272867 | 0.0005595

# IfcPlate: PLT3*520.2 (2)
In: Undefined
Description: PLT3*520.2; Material: STEEL/450
Tekla Common - Bottom elevation: +4.680; Top elevation: +5.155; Phase: 1; Class: 11
Tekla Quantity - Weight: 4.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.3 m2; Height: 520.2 mm; Width: 3 mm; Length: 535.7 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 520.186 mm; NetArea: 0.373329 m2; GrossArea: 0.27864 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000551223 m3; GrossVolume: 0.000551223 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1198
PLATE | PL/1192

# IfcPlate: PLT3*526.4 (6)
In: Undefined
Description: PLT3*526.4; Material: STEEL/450
Tekla Common - Phase: 1; Class: 11
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.3 m2; Height: 526.4 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 526.406 mm; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
PLATE | PL/1200 | +4.706 | +5.171 | 5.2 | 86.2 | 618.9 | 0.439301 | 0.325789 | 0.000649359
PLATE | PL/1199 | +4.698 | +5.163 | 4.7 | 86.2 | 568.9 | 0.403001 | 0.299469 | 0.000595359
PLATE | PL/1204 | +4.694 | +5.159 | 4.5 | 86.3 | 543.9 | 0.384851 | 0.286309 | 0.000568359
PLATE | PL/1194 | +4.706 | +5.171 | 5.2 | 86.2 | 618.9 | 0.439301 | 0.325789 | 0.000649359
PLATE | PL/1193 | +4.698 | +5.163 | 4.7 | 86.2 | 568.9 | 0.403001 | 0.299469 | 0.000595359
PLATE | PL/1190 | +4.694 | +5.159 | 4.5 | 86.3 | 543.9 | 0.384851 | 0.286309 | 0.000568359

# IfcPlate: PLT3*540.7 (2)
In: Undefined
Description: PLT3*540.7; Material: STEEL/450
Tekla Common - Bottom elevation: +4.706; Top elevation: +5.216; Phase: 1; Class: 11
Tekla Quantity - Weight: 4.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.3 m2; Height: 540.7 mm; Width: 3 mm; Length: 568.7 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 540.68 mm; NetArea: 0.386052 m2; GrossArea: 0.307488 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000570049 m3; GrossVolume: 0.000570049 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1201
PLATE | PL/1195

# IfcPlate: PLT3*550.9 (2)
In: Undefined
Description: PLT3*550.9; Material: STEEL/450
Tekla Common - Bottom elevation: +4.223; Top elevation: +4.700; Phase: 1; Class: 11
Tekla Quantity - Weight: 6.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.5 m2; Height: 550.9 mm; Width: 3 mm; Length: 628 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 550.898 mm; NetArea: 0.533681 m2; GrossArea: 0.345973 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00079021 m3; GrossVolume: 0.00079021 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1032
PLATE | PL/1005

# IfcPlate: PLT3*554.2 (2)
In: Undefined
Description: PLT3*554.2; Material: STEEL/450
Tekla Common - Bottom elevation: +4.223; Top elevation: +4.700; Phase: 1; Class: 11
Tekla Quantity - Weight: 6.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.5 m2; Height: 554.2 mm; Width: 3 mm; Length: 617.8 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 554.184 mm; NetArea: 0.533022 m2; GrossArea: 0.342362 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000789231 m3; GrossVolume: 0.000789231 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1966
PLATE | PL/1964

# IfcPlate: PLT3*555.4 (8)
In: Undefined
Description: PLT3*555.4; Material: STEEL/450
Tekla Common - Bottom elevation: +4.218; Top elevation: +4.700; Phase: 1; Class: 11
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.6 m2; Height: 555.4 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 555.358 mm; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Weight (kg) | Area per tons (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
PLATE | PL/1068 | 7.8 | 85.8 | 775.8 | 0.680393 | 0.430853 | 0.0010089
PLATE | PL/1036 | 7.4 | 85.8 | 726.9 | 0.632602 | 0.403697 | 0.000937664
PLATE | PL/1034 | 6.8 | 86 | 678 | 0.584793 | 0.376531 | 0.0008664
PLATE | PL/1059 | 6.5 | 86 | 653.5 | 0.560893 | 0.36295 | 0.000830775
PLATE | PL/987 | 7.8 | 85.8 | 775.8 | 0.680393 | 0.430853 | 0.0010089
PLATE | PL/1009 | 7.4 | 85.8 | 726.9 | 0.632602 | 0.403697 | 0.000937664
PLATE | PL/1007 | 6.8 | 86 | 678 | 0.584793 | 0.376531 | 0.0008664
PLATE | PL/996 | 6.5 | 86 | 653.5 | 0.560893 | 0.36295 | 0.000830775

# IfcPlate: PLT3*555.5 (2)
In: Undefined
Description: PLT3*555.5; Material: STEEL/450
Tekla Common - Bottom elevation: +5.038; Top elevation: +5.516; Phase: 1; Class: 11
Tekla Quantity - Weight: 6.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.5 m2; Height: 555.5 mm; Width: 3 mm; Length: 612.9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 555.519 mm; NetArea: 0.532623 m2; GrossArea: 0.3405 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000788637 m3; GrossVolume: 0.000788637 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1053
PLATE | PL/1026

# IfcPlate: PLT3*556.3 (2)
In: Undefined
Description: PLT3*556.3; Material: STEEL/450
Tekla Common - Bottom elevation: +4.804; Top elevation: +5.282; Phase: 1; Class: 11
Tekla Quantity - Weight: 6.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.5 m2; Height: 556.3 mm; Width: 3 mm; Length: 564.9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 556.342 mm; NetArea: 0.530526 m2; GrossArea: 0.314291 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000785509 m3; GrossVolume: 0.000785509 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1047
PLATE | PL/1020

# IfcPlate: PLT3*558.3 (2)
In: Undefined
Description: PLT3*558.3; Material: STEEL/450
Tekla Common - Bottom elevation: +4.218; Top elevation: +4.700; Phase: 1; Class: 11
Tekla Quantity - Weight: 6.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.6 m2; Height: 558.3 mm; Width: 3 mm; Length: 644.4 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 558.303 mm; NetArea: 0.558685 m2; GrossArea: 0.359753 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000827481 m3; GrossVolume: 0.000827481 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1708
PLATE | PL/1706

# IfcPlate: PLT3*558.7 (6)
In: Undefined
Description: PLT3*558.7; Material: STEEL/450
Tekla Common - Bottom elevation: +4.218; Top elevation: +4.700; Phase: 1; Class: 11
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.6 m2; Height: 558.7 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 558.686 mm; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Weight (kg) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
PLATE | PL/1848 | 6.8 | 668.1 | 0.58419 | 0.373241 | 0.000865503
PLATE | PL/1850 | 7.4 | 717.3 | 0.631989 | 0.400751 | 0.000936753
PLATE | PL/1852 | 8 | 766.6 | 0.679789 | 0.428261 | 0.001008
PLATE | PL/1842 | 8 | 766.6 | 0.679789 | 0.428261 | 0.001008
PLATE | PL/1846 | 7.4 | 717.3 | 0.631989 | 0.400751 | 0.000936753
PLATE | PL/1844 | 6.8 | 668.1 | 0.58419 | 0.373241 | 0.000865503

# IfcPlate: PLT3*558.9 (2)
In: Undefined
Description: PLT3*558.9; Material: STEEL/450
Tekla Common - Bottom elevation: +4.779; Top elevation: +5.282; Phase: 1; Class: 11
Tekla Quantity - Weight: 6.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.6 m2; Height: 558.9 mm; Width: 3 mm; Length: 619.5 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 558.912 mm; NetArea: 0.594761 m2; GrossArea: 0.346272 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000881286 m3; GrossVolume: 0.000881286 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1143
PLATE | PL/1101

# IfcPlate: PLT3*559.5 (6)
In: Undefined
Description: PLT3*559.5; Material: STEEL/450
Tekla Common - Phase: 1; Class: 11
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 559.5 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 559.48 mm; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
PLATE | PL/1203 | +4.739 | +5.239 | 5.2 | 86.2 | 0.5 | 639.5 | 0.451687 | 0.357806 | 0.000667683
PLATE | PL/1202 | +4.727 | +5.227 | 4.9 | 86.2 | 0.3 | 589.5 | 0.415387 | 0.329832 | 0.000613683
PLATE | PL/1205 | +4.721 | +5.222 | 4.7 | 86.3 | 0.3 | 564.5 | 0.397237 | 0.315845 | 0.000586684
PLATE | PL/1197 | +4.739 | +5.239 | 5.2 | 86.2 | 0.5 | 639.5 | 0.451687 | 0.357806 | 0.000667683
PLATE | PL/1196 | +4.727 | +5.227 | 4.9 | 86.2 | 0.3 | 589.5 | 0.415387 | 0.329832 | 0.000613683
PLATE | PL/1191 | +4.721 | +5.222 | 4.7 | 86.3 | 0.3 | 564.5 | 0.397237 | 0.315845 | 0.000586684

# IfcPlate: PLT3*560 (8)
In: Undefined
Description: PLT3*560; Material: STEEL/450
Tekla Common - Bottom elevation: +5.033; Top elevation: +5.516; Phase: 1; Class: 11
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.6 m2; Height: 560 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 560.04 mm; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Weight (kg) | Area per tons (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
PLATE | PL/1075 | 7.8 | 85.8 | 762.1 | 0.679417 | 0.426829 | 0.00100745
PLATE | PL/1057 | 7.4 | 85.8 | 712.8 | 0.631617 | 0.399172 | 0.000936198
PLATE | PL/1055 | 6.8 | 86 | 663.4 | 0.583826 | 0.37152 | 0.000864962
PLATE | PL/1066 | 6.5 | 86 | 638.7 | 0.559916 | 0.357686 | 0.000829322
PLATE | PL/994 | 7.8 | 85.8 | 762.1 | 0.679417 | 0.426829 | 0.00100745
PLATE | PL/1030 | 7.4 | 85.8 | 712.8 | 0.631617 | 0.399172 | 0.000936198
PLATE | PL/1028 | 6.8 | 86 | 663.4 | 0.583826 | 0.37152 | 0.000864962
PLATE | PL/1003 | 6.5 | 86 | 638.7 | 0.559916 | 0.357686 | 0.000829322

# IfcPlate: PLT3*560.6 (2)
In: Undefined
Description: PLT3*560.6; Material: STEEL/450
Tekla Common - Bottom elevation: +4.690; Top elevation: +5.168; Phase: 1; Class: 11
Tekla Quantity - Weight: 6.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.5 m2; Height: 560.6 mm; Width: 3 mm; Length: 563.9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 560.629 mm; NetArea: 0.529106 m2; GrossArea: 0.316156 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000783387 m3; GrossVolume: 0.000783387 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1041
PLATE | PL/1014

# IfcPlate: PLT3*563.3 (2)
In: Undefined
Description: PLT3*563.3; Material: STEEL/450
Tekla Common - Bottom elevation: +4.665; Top elevation: +5.168; Phase: 1; Class: 11
Tekla Quantity - Weight: 6.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.6 m2; Height: 563.3 mm; Width: 3 mm; Length: 618.5 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 563.255 mm; NetArea: 0.592374 m2; GrossArea: 0.348346 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000877727 m3; GrossVolume: 0.000877727 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1137
PLATE | PL/1095

# IfcPlate: PLT3*568.6 (8)
In: Undefined
Description: PLT3*568.6; Material: STEEL/450
Tekla Common - Bottom elevation: +4.685; Top elevation: +5.168; Phase: 1; Class: 11
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.6 m2; Height: 568.6 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000009 m2
