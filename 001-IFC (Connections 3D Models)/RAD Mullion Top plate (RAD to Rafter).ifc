Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView_V2.0, QuantityTakeOffAddOnView], Option [BaseQuantities:On], Option [GridExport:On], Option [Assemblies:On], Option [Bolts:On], Option [Rebars:On], Option [PourObjects:Off], Option [Welds:Off], Option [SurfaceTreatments:Off], Option [LocationBy:0], Option [ViewColors:Off], Option [SectionedSpine:Off], Option [PropertySets:On], Option [Export all:Off]
File name: 1.ifc
Time: 2026-07-16T22:04:10
Author: LAPTOP-2P0BGI6B\lablab
Organization: Structural Designer
Written by: IFC Database Version: Work
Made in: Tekla Structures 2019 Service Pack 13, IFC Export Version: 4.0.0.0 Oct 18 2021

# IfcBuildingStorey, Undefined
In: Undefined
Elevation: 0 mm

# IfcBeam: C:100-19 (8)
In: Undefined
Description: C:100-19; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Phase: 1; Class: 2
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 141.6 m2; Height: 102 mm; Width: 51 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Top elevation | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
MULLION | Z/2373 | +4.796 | 15.4 | 2.2 | 4796.4 | 4796.44 | 2.18132 | 0.00205412 | 16.1249
MULLION | Z/2301 | +4.709 | 15.1 | 2.1 | 4709 | 4708.95 | 2.14155 | 0.00201666 | 15.8308
MULLION | Z/2298 | +4.764 | 15.4 | 2.2 | 4763.5 | 4763.53 | 2.16636 | 0.00204003 | 16.0142
MULLION | Z/2295 | +4.786 | 15.4 | 2.2 | 4785.8 | 4785.76 | 2.17646 | 0.00204955 | 16.089
MULLION | Z/2292 | +4.808 | 15.4 | 2.2 | 4807.5 | 4807.52 | 2.18636 | 0.00205887 | 16.1621
MULLION | Z/2289 | +4.829 | 15.4 | 2.2 | 4829.4 | 4829.44 | 2.19632 | 0.00206826 | 16.2358
MULLION | Z/2286 | +4.857 | 15.6 | 2.2 | 4856.7 | 4856.69 | 2.20871 | 0.00207993 | 16.3274
MULLION | Z/2283 | +4.870 | 15.6 | 2.2 | 4870.1 | 4870.15 | 2.21483 | 0.00208569 | 16.3727

# IfcBeam: C:150-24 (22)
In: Undefined
Description: C:150-24; Material: STEEL/G450
Tekla Common - Phase: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 111.2 m2; Height: 152 mm; Width: 64 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Class | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg) | Finish
MULLION | Z/2374 | +0.000 | +4.898 | 2 | 27.3 | 3 | 4897.8 | 4897.83 | 3.03617 | 0.00361342 | 28.3654
2 x RAFTER | Z/2375 | +4.748 | +5.579 | 1 | 21.9 | 2.4 | 3927.1 | 3927.11 | 2.43471 | 0.00289726 | 22.7435 | 10 deg
MULLION | Z/2302 | +0.000 | +4.977 | 2 | 27.7 | 3.1 | 4977.1 | 4977.08 | 3.08527 | 0.00367189 | 28.8243
MULLION | Z/2299 | +0.000 | +4.950 | 2 | 27.6 | 3.1 | 4950.4 | 4950.35 | 3.06872 | 0.00365217 | 28.6696
MULLION | Z/2296 | +0.000 | +4.940 | 2 | 27.5 | 3.1 | 4939.8 | 4939.83 | 3.06219 | 0.00364441 | 28.6086
MULLION | Z/2293 | +0.000 | +4.930 | 2 | 27.5 | 3.1 | 4929.7 | 4929.74 | 3.05594 | 0.00363697 | 28.5502
MULLION | Z/2290 | +0.000 | +4.921 | 2 | 27.5 | 3.1 | 4920.5 | 4920.51 | 3.05023 | 0.00363016 | 28.4967
MULLION | Z/2287 | +0.000 | +4.907 | 2 | 27.3 | 3 | 4907 | 4906.99 | 3.04185 | 0.00362018 | 28.4185
MULLION | Z/2284 | +0.000 | +4.900 | 2 | 27.3 | 3 | 4900.3 | 4900.28 | 3.03769 | 0.00361523 | 28.3796
2 x RAFTER | Z/175 | +4.667 | +6.026 | 1 | 21.9 | 2.4 | 3927.1 | 3927.11 | 2.43471 | 0.00289726 | 22.7435 | 18 deg
2 x RAFTER | Z/158 | +4.708 | +5.871 | 1 | 21.9 | 2.4 | 3927.1 | 3927.11 | 2.43471 | 0.00289726 | 22.7435 | 15 deg
2 x RAFTER | Z/159 | +4.748 | +5.713 | 1 | 21.9 | 2.4 | 3927.1 | 3927.11 | 2.43471 | 0.00289726 | 22.7435 | 12 deg
2 x RAFTER | Z/269 | +4.784 | +5.549 | 1 | 21.9 | 2.4 | 3927.1 | 3927.11 | 2.43471 | 0.00289726 | 22.7435 | 9 deg
2 x RAFTER | Z/140 | +4.834 | +5.328 | 1 | 21.9 | 2.4 | 3927.1 | 3927.11 | 2.43471 | 0.00289726 | 22.7435 | 5 deg
2 x RAFTER | Z/55 | +4.858 | +5.216 | 1 | 21.9 | 2.4 | 3927.1 | 3927.11 | 2.43471 | 0.00289726 | 22.7435 | 3 deg

# IfcBeam: C:200-24 (8)
In: Undefined
Description: C:200-24; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Phase: 1; Class: 2
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 110 m2; Height: 203 mm; Width: 76 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Top elevation | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
MULLION | Z/2376 | +4.999 | 35.4 | 3.9 | 4999.1 | 4999.13 | 3.89918 | 0.00464799 | 36.4867
MULLION | Z/2303 | +5.245 | 37.2 | 4.1 | 5245 | 5244.98 | 4.09084 | 0.00487657 | 38.2811
MULLION | Z/2300 | +5.137 | 36.4 | 3.9 | 5137 | 5137.02 | 4.00668 | 0.0047762 | 37.4932
MULLION | Z/2297 | +5.094 | 36.1 | 3.9 | 5093.8 | 5093.77 | 3.97296 | 0.00473598 | 37.1774
MULLION | Z/2294 | +5.052 | 35.8 | 3.9 | 5051.9 | 5051.86 | 3.94029 | 0.00469701 | 36.8716
MULLION | Z/2291 | +5.012 | 35.5 | 3.9 | 5011.5 | 5011.5 | 3.90883 | 0.0046595 | 36.5771
MULLION | Z/2288 | +4.957 | 35.1 | 3.9 | 4957.3 | 4957.26 | 3.86654 | 0.00460906 | 36.1811
MULLION | Z/2285 | +4.930 | 34.9 | 3.8 | 4930.4 | 4930.39 | 3.84559 | 0.00458408 | 35.985

# IfcColumn: C:100-19 (8)
In: Undefined
Description: C:100-19; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Phase: 1; Class: 2
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 141.6 m2; Height: 102 mm; Width: 51 mm
Pset_ColumnCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Top elevation | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
MULLION | Z/2373 | +4.796 | 15.4 | 2.2 | 4796.4 | 4796.44 | 2.18132 | 0.00205412 | 16.1249
MULLION | Z/2301 | +4.709 | 15.1 | 2.1 | 4709 | 4708.95 | 2.14155 | 0.00201666 | 15.8308
MULLION | Z/2298 | +4.764 | 15.4 | 2.2 | 4763.5 | 4763.53 | 2.16636 | 0.00204003 | 16.0142
MULLION | Z/2295 | +4.786 | 15.4 | 2.2 | 4785.8 | 4785.76 | 2.17646 | 0.00204955 | 16.089
MULLION | Z/2292 | +4.808 | 15.4 | 2.2 | 4807.5 | 4807.52 | 2.18636 | 0.00205887 | 16.1621
MULLION | Z/2289 | +4.829 | 15.4 | 2.2 | 4829.4 | 4829.44 | 2.19632 | 0.00206826 | 16.2358
MULLION | Z/2286 | +4.857 | 15.6 | 2.2 | 4856.7 | 4856.69 | 2.20871 | 0.00207993 | 16.3274
MULLION | Z/2283 | +4.870 | 15.6 | 2.2 | 4870.1 | 4870.15 | 2.21483 | 0.00208569 | 16.3727

# IfcColumn: C:150-24 (8)
In: Undefined
Description: C:150-24; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Phase: 1; Class: 2
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 111.2 m2; Height: 152 mm; Width: 64 mm
Pset_ColumnCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Top elevation | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
MULLION | Z/2374 | +4.898 | 27.3 | 3 | 4897.8 | 4897.83 | 3.03617 | 0.00361342 | 28.3654
MULLION | Z/2302 | +4.977 | 27.7 | 3.1 | 4977.1 | 4977.08 | 3.08527 | 0.00367189 | 28.8243
MULLION | Z/2299 | +4.950 | 27.6 | 3.1 | 4950.4 | 4950.35 | 3.06872 | 0.00365217 | 28.6696
MULLION | Z/2296 | +4.940 | 27.5 | 3.1 | 4939.8 | 4939.83 | 3.06219 | 0.00364441 | 28.6086
MULLION | Z/2293 | +4.930 | 27.5 | 3.1 | 4929.7 | 4929.74 | 3.05594 | 0.00363697 | 28.5502
MULLION | Z/2290 | +4.921 | 27.5 | 3.1 | 4920.5 | 4920.51 | 3.05023 | 0.00363016 | 28.4967
MULLION | Z/2287 | +4.907 | 27.3 | 3 | 4907 | 4906.99 | 3.04185 | 0.00362018 | 28.4185
MULLION | Z/2284 | +4.900 | 27.3 | 3 | 4900.3 | 4900.28 | 3.03769 | 0.00361523 | 28.3796

# IfcColumn: C:200-24 (8)
In: Undefined
Description: C:200-24; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Phase: 1; Class: 2
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 110 m2; Height: 203 mm; Width: 76 mm
Pset_ColumnCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Top elevation | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
MULLION | Z/2376 | +4.999 | 35.4 | 3.9 | 4999.1 | 4999.13 | 3.89918 | 0.00464799 | 36.4867
MULLION | Z/2303 | +5.245 | 37.2 | 4.1 | 5245 | 5244.98 | 4.09084 | 0.00487657 | 38.2811
MULLION | Z/2300 | +5.137 | 36.4 | 3.9 | 5137 | 5137.02 | 4.00668 | 0.0047762 | 37.4932
MULLION | Z/2297 | +5.094 | 36.1 | 3.9 | 5093.8 | 5093.77 | 3.97296 | 0.00473598 | 37.1774
MULLION | Z/2294 | +5.052 | 35.8 | 3.9 | 5051.9 | 5051.86 | 3.94029 | 0.00469701 | 36.8716
MULLION | Z/2291 | +5.012 | 35.5 | 3.9 | 5011.5 | 5011.5 | 3.90883 | 0.0046595 | 36.5771
MULLION | Z/2288 | +4.957 | 35.1 | 3.9 | 4957.3 | 4957.26 | 3.86654 | 0.00460906 | 36.1811
MULLION | Z/2285 | +4.930 | 34.9 | 3.8 | 4930.4 | 4930.39 | 3.84559 | 0.00458408 | 35.985

# IfcElementAssembly (112)
In: Undefined
PredefinedType: RIGID_FRAME
Name | ASSEMBLY_POSITION_CODE = Assembly/Cast unit position code | ASSEMBLY_POS = Assembly/Cast unit Mark | Assembly/Cast unit weight (kg) | Assembly/Cast unit bottom elevation | Assembly/Cast unit top elevation | Width (mm)
RAD TOP PLATE | 10Deg/RAD top plate-RAD top plate | PL/1686 | 0.4 | +4.899 | +5.036 | 60
RAD TOP PLATE | 10Deg/RAD top plate-RAD top plate | PL/1684 | 0.2 | +4.798 | +4.926 | 55
RAD TOP PLATE | 10Deg/RAD top plate-RAD top plate | PL/1682 | 0.2 | +4.696 | +4.818 | 45
2 x MULLION | 10Deg/RAD top plate-RAD top plate | Z/2376 | 35.4 | +0.000 | +4.999 | 76
2 x MULLION | 10Deg/RAD top plate-RAD top plate | Z/2374 | 27.3 | +0.000 | +4.898 | 64
2 x MULLION | 10Deg/RAD top plate-RAD top plate | Z/2373 | 15.4 | +0.000 | +4.796 | 51
RAD TOP PLATE | 10Deg/RAD top plate-RAD top plate | PL/1685 | 0.4 | +4.899 | +5.036 | 60
RAD TOP PLATE | 10Deg/RAD top plate-RAD top plate | PL/1683 | 0.2 | +4.798 | +4.926 | 55
RAD TOP PLATE | 10Deg/RAD top plate-RAD top plate | PL/1681 | 0.2 | +4.696 | +4.818 | 45
2 x RAFTER | 10Deg/RAD top plate-RAD top plate | Z/2375 | 21.9 | +4.748 | +5.579 | 64
RAD TOP PLATE | 25Deg/RAD top plate-RAD top plate | PL/1630 | 0.4 | +4.877 | +5.043 | 55
2 x MULLION | 25Deg/RAD top plate-RAD top plate | Z/2302 | 27.7 | +0.000 | +4.977 | 64
RAD TOP PLATE | 25Deg/RAD top plate-RAD top plate | PL/1615 | 0.4 | +5.145 | +5.334 | 60
RAD TOP PLATE | 25Deg/RAD top plate-RAD top plate | PL/1613 | 0.2 | +4.609 | +4.759 | 45
RAD TOP PLATE | 18Deg/RAD top plate-RAD top plate | PL/1611 | 0.4 | +5.037 | +5.201 | 60
RAD TOP PLATE | 18Deg/RAD top plate-RAD top plate | PL/1609 | 0.4 | +4.850 | +4.998 | 55
RAD TOP PLATE | 18Deg/RAD top plate-RAD top plate | PL/1607 | 0.2 | +4.664 | +4.800 | 45
RAD TOP PLATE | 15Deg/RAD top plate-RAD top plate | PL/1605 | 0.4 | +4.994 | +5.147 | 60
RAD TOP PLATE | 15Deg/RAD top plate-RAD top plate | PL/1603 | 0.2 | +4.840 | +4.980 | 55
RAD TOP PLATE | 15Deg/RAD top plate-RAD top plate | PL/1601 | 0.2 | +4.686 | +4.816 | 45
RAD TOP PLATE | 12Deg/RAD top plate-RAD top plate | PL/1595 | 0.2 | +4.708 | +4.833 | 45
RAD TOP PLATE | 12Deg/RAD top plate-RAD top plate | PL/1597 | 0.2 | +4.830 | +4.963 | 55
RAD TOP PLATE | 12Deg/RAD top plate-RAD top plate | PL/1599 | 0.4 | +4.952 | +5.095 | 60
RAD TOP PLATE | 9Deg/RAD top plate-RAD top plate | PL/1593 | 0.4 | +4.912 | +5.045 | 60
RAD TOP PLATE | 9Deg/RAD top plate-RAD top plate | PL/1591 | 0.2 | +4.821 | +4.946 | 55
RAD TOP PLATE | 9Deg/RAD top plate-RAD top plate | PL/1589 | 0.2 | +4.729 | +4.850 | 45
RAD TOP PLATE | 5Deg/RAD top plate-RAD top plate | PL/1587 | 0.4 | +4.857 | +4.978 | 60
RAD TOP PLATE | 5Deg/RAD top plate-RAD top plate | PL/1585 | 0.2 | +4.807 | +4.923 | 55
RAD TOP PLATE | 5Deg/RAD top plate-RAD top plate | PL/1583 | 0.2 | +4.757 | +4.870 | 45
RAD TOP PLATE | 3Deg/RAD top plate-RAD top plate | PL/1581 | 0.4 | +4.830 | +4.945 | 60
RAD TOP PLATE | 3Deg/RAD top plate-RAD top plate | PL/1579 | 0.2 | +4.800 | +4.912 | 55
RAD TOP PLATE | 3Deg/RAD top plate-RAD top plate | PL/1577 | 0.2 | +4.770 | +4.880 | 45
2 x MULLION | 25Deg/RAD top plate-RAD top plate | Z/2303 | 37.2 | +0.000 | +5.245 | 76
2 x MULLION | 25Deg/RAD top plate-RAD top plate | Z/2301 | 15.1 | +0.000 | +4.709 | 51
2 x MULLION | 18Deg/RAD top plate-RAD top plate | Z/2300 | 36.4 | +0.000 | +5.137 | 76
2 x MULLION | 18Deg/RAD top plate-RAD top plate | Z/2299 | 27.6 | +0.000 | +4.950 | 64
2 x MULLION | 18Deg/RAD top plate-RAD top plate | Z/2298 | 15.4 | +0.000 | +4.764 | 51
2 x MULLION | 15Deg/RAD top plate-RAD top plate | Z/2297 | 36.1 | +0.000 | +5.094 | 76
2 x MULLION | 15Deg/RAD top plate-RAD top plate | Z/2296 | 27.5 | +0.000 | +4.940 | 64
2 x MULLION | 15Deg/RAD top plate-RAD top plate | Z/2295 | 15.4 | +0.000 | +4.786 | 51
2 x MULLION | 12Deg/RAD top plate-RAD top plate | Z/2294 | 35.8 | +0.000 | +5.052 | 76
2 x MULLION | 12Deg/RAD top plate-RAD top plate | Z/2293 | 27.5 | +0.000 | +4.930 | 64
2 x MULLION | 12Deg/RAD top plate-RAD top plate | Z/2292 | 15.4 | +0.000 | +4.808 | 51
2 x MULLION | 9Deg/RAD top plate-RAD top plate | Z/2291 | 35.5 | +0.000 | +5.012 | 76
2 x MULLION | 9Deg/RAD top plate-RAD top plate | Z/2290 | 27.5 | +0.000 | +4.921 | 64
2 x MULLION | 9Deg/RAD top plate-RAD top plate | Z/2289 | 15.4 | +0.000 | +4.829 | 51
2 x MULLION | 5Deg/RAD top plate-RAD top plate | Z/2288 | 35.1 | +0.000 | +4.957 | 76
2 x MULLION | 5Deg/RAD top plate-RAD top plate | Z/2287 | 27.3 | +0.000 | +4.907 | 64
2 x MULLION | 5Deg/RAD top plate-RAD top plate | Z/2286 | 15.6 | +0.000 | +4.857 | 51
2 x MULLION | 3Deg/RAD top plate-RAD top plate | Z/2285 | 34.9 | +0.000 | +4.930 | 76
2 x MULLION | 3Deg/RAD top plate-RAD top plate | Z/2284 | 27.3 | +0.000 | +4.900 | 64
2 x MULLION | 3Deg/RAD top plate-RAD top plate | Z/2283 | 15.6 | +0.000 | +4.870 | 51
RAD TOP PLATE | 25Deg/RAD top plate-RAD top plate | PL/1614 | 0.4 | +5.145 | +5.334 | 60
RAD TOP PLATE | 25Deg/RAD top plate-RAD top plate | PL/1616 | 0.4 | +4.877 | +5.043 | 55
RAD TOP PLATE | 25Deg/RAD top plate-RAD top plate | PL/1612 | 0.2 | +4.609 | +4.759 | 45
RAD TOP PLATE | 18Deg/RAD top plate-RAD top plate | PL/1610 | 0.4 | +5.037 | +5.201 | 60
RAD TOP PLATE | 18Deg/RAD top plate-RAD top plate | PL/1608 | 0.4 | +4.850 | +4.998 | 55
RAD TOP PLATE | 18Deg/RAD top plate-RAD top plate | PL/1606 | 0.2 | +4.664 | +4.800 | 45
RAD TOP PLATE | 15Deg/RAD top plate-RAD top plate | PL/1604 | 0.4 | +4.994 | +5.147 | 60
RAD TOP PLATE | 15Deg/RAD top plate-RAD top plate | PL/1602 | 0.2 | +4.840 | +4.980 | 55
RAD TOP PLATE | 15Deg/RAD top plate-RAD top plate | PL/1600 | 0.2 | +4.686 | +4.816 | 45
RAD TOP PLATE | 12Deg/RAD top plate-RAD top plate | PL/1598 | 0.4 | +4.952 | +5.095 | 60
RAD TOP PLATE | 12Deg/RAD top plate-RAD top plate | PL/1596 | 0.2 | +4.830 | +4.963 | 55
RAD TOP PLATE | 12Deg/RAD top plate-RAD top plate | PL/1594 | 0.2 | +4.708 | +4.833 | 45
RAD TOP PLATE | 9Deg/RAD top plate-RAD top plate | PL/1592 | 0.4 | +4.912 | +5.045 | 60
RAD TOP PLATE | 9Deg/RAD top plate-RAD top plate | PL/1590 | 0.2 | +4.821 | +4.946 | 55
RAD TOP PLATE | 9Deg/RAD top plate-RAD top plate | PL/1588 | 0.2 | +4.729 | +4.850 | 45
RAD TOP PLATE | 5Deg/RAD top plate-RAD top plate | PL/1586 | 0.4 | +4.857 | +4.978 | 60
RAD TOP PLATE | 5Deg/RAD top plate-RAD top plate | PL/1584 | 0.2 | +4.807 | +4.923 | 55
RAD TOP PLATE | 5Deg/RAD top plate-RAD top plate | PL/1582 | 0.2 | +4.757 | +4.870 | 45
RAD TOP PLATE | 3Deg/RAD top plate-RAD top plate | PL/1580 | 0.4 | +4.830 | +4.945 | 60
RAD TOP PLATE | 3Deg/RAD top plate-RAD top plate | PL/1578 | 0.2 | +4.800 | +4.912 | 55
RAD TOP PLATE | 3Deg/RAD top plate-RAD top plate | PL/1576 | 0.2 | +4.770 | +4.880 | 45
2 x RAFTER | 25Deg/RAD top plate-RAD top plate | Z/158 | 21.9 | +4.566 | +6.364 | 64
2 x RAFTER | 18Deg/RAD top plate-RAD top plate | Z/175 | 21.9 | +4.667 | +6.026 | 64
2 x RAFTER | 15Deg/RAD top plate-RAD top plate | Z/158 | 21.9 | +4.708 | +5.871 | 64
2 x RAFTER | 12Deg/RAD top plate-RAD top plate | Z/159 | 21.9 | +4.748 | +5.713 | 64
2 x RAFTER | 9Deg/RAD top plate-RAD top plate | Z/269 | 21.9 | +4.784 | +5.549 | 64
2 x RAFTER | 5Deg/RAD top plate-RAD top plate | Z/140 | 21.9 | +4.834 | +5.328 | 64
2 x RAFTER | 3Deg/RAD top plate-RAD top plate | Z/55 | 21.9 | +4.858 | +5.216 | 64

# IfcMechanicalFastener: Bolt assembly (96)
In: Undefined
Tekla Bolt - Nut count: 2; Slotted hole x: 0 mm; Location: Site; Bolt count: 2
Name | NominalDiameter (mm) = Washer diameter (mm) = Bolt size (mm) | NominalLength (mm) = Bolt length (mm) | Material = Bolt standard | Washer count | Washer type | Washer name | Nut type | Nut name | Slotted hole y (mm) | Bolt hole diameter (mm) | Bolt Name
48 x Bolt assembly | 5 | 25 | TEK_16TPIM | 8 | UNDEF_WASH | UNDEFINED_WASHER5 | UNDEF_NUT | UNDEFINED_NUTM5 | 0 | 7 | TEKSCREW_M5*25
48 x Bolt assembly | 12 | 30 | PB1230 | 2 | FLAT | WASHERM12-FLAT | 4.6-HEX | NUTM12-4.6-HEX | 61 | 14 | BOLTPB1230

# IfcMember: C:150-24 (2)
In: Undefined
Description: C:150-24; Material: STEEL/G450
Tekla Quantity - Weight: 21.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 111.2 m2; Net surface area: 2.4 m2; Height: 152 mm; Width: 64 mm; Length: 3927.1 mm
Tekla Common - Finish: 15 deg; Bottom elevation: +4.566; Top elevation: +6.364; Phase: 1; Class: 1
Pset_MemberCommon - LoadBearing: no; Reference: Z/158
BaseQuantities - Length: 3927.11 mm; OuterSurfaceArea: 2.43471 m2; GrossSurfaceArea: 0 m2; CrossSectionArea: 0.00071 m2; NetVolume: 0.00289726 m3; GrossVolume: 0.00278825 m3; NetWeight: 22.7435 kg; GrossWeight: 21.8877 kg

# IfcPlate: PLT1.6*100.5 (2)
In: Undefined
Description: PLT1.6*100.5; Material: STEEL/250
Tekla Common - Bottom elevation: +4.686; Top elevation: +4.816; Phase: 1; Class: 3
Tekla Quantity - Weight: 0.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 164.4 m2; Net surface area: 0 m2; Height: 100.5 mm; Width: 1.6 mm; Length: 169 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 100.477 mm; NetArea: 0.0297415 m2; GrossArea: 0.0169783 m2; CrossSectionArea: 0.00000256 m2; NetVolume: 0.000023052 m3; GrossVolume: 0.000023052 m3
Name | ASSEMBLY_POS = Reference
RAD TOP PLATE | PL/1601
RAD TOP PLATE | PL/1600

# IfcPlate: PLT1.6*102.5 (2)
In: Undefined
Description: PLT1.6*102.5; Material: STEEL/250
Tekla Common - Bottom elevation: +4.664; Top elevation: +4.800; Phase: 1; Class: 3
Tekla Quantity - Weight: 0.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 164.2 m2; Net surface area: 0 m2; Height: 102.5 mm; Width: 1.6 mm; Length: 173.8 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - NetArea: 0.0303936 m2; CrossSectionArea: 0.00000256 m2
Name | ASSEMBLY_POS = Reference | Width (mm) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
RAD TOP PLATE | PL/1607 | 102.495 | 0.017817 | 0.0000235626
RAD TOP PLATE | PL/1606 | 102.497 | 0.017818 | 0.0000235625

# IfcPlate: PLT1.6*107.1 (2)
In: Undefined
Description: PLT1.6*107.1; Material: STEEL/250
Tekla Common - Bottom elevation: +4.609; Top elevation: +4.759; Phase: 1; Class: 3
Tekla Quantity - Weight: 0.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 164.2 m2; Net surface area: 0 m2; Height: 107.1 mm; Width: 1.6 mm; Length: 185.7 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 107.143 mm; NetArea: 0.0321318 m2; GrossArea: 0.0198939 m2; CrossSectionArea: 0.00000256 m2
Name | ASSEMBLY_POS = Reference | NetVolume (m3) = GrossVolume (m3)
RAD TOP PLATE | PL/1613 | 0.0000249288
RAD TOP PLATE | PL/1612 | 0.0000249301

# IfcPlate: PLT1.6*112.6 (2)
In: Undefined
Description: PLT1.6*112.6; Material: STEEL/250
Tekla Common - Bottom elevation: +4.800; Top elevation: +4.912; Phase: 1; Class: 3
Tekla Quantity - Weight: 0.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 163.8 m2; Net surface area: 0 m2; Height: 112.6 mm; Width: 1.6 mm; Length: 161.4 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 112.634 mm; CrossSectionArea: 0.00000256 m2
Name | ASSEMBLY_POS = Reference | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
RAD TOP PLATE | PL/1579 | 0.0360008 | 0.0181843 | 0.0000279932
RAD TOP PLATE | PL/1578 | 0.0360007 | 0.0181835 | 0.0000279933

# IfcPlate: PLT1.6*114.4 (2)
In: Undefined
Description: PLT1.6*114.4; Material: STEEL/250
Tekla Common - Bottom elevation: +4.807; Top elevation: +4.923; Phase: 1; Class: 3
Tekla Quantity - Weight: 0.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 163.8 m2; Net surface area: 0 m2; Height: 114.4 mm; Width: 1.6 mm; Length: 165.9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 114.402 mm; GrossArea: 0.0189819 m2; CrossSectionArea: 0.00000256 m2; NetVolume: 0.0000284846 m3; GrossVolume: 0.0000284846 m3
Name | ASSEMBLY_POS = Reference | NetArea (m2)
RAD TOP PLATE | PL/1585 | 0.0366249
RAD TOP PLATE | PL/1584 | 0.0366248

# IfcPlate: PLT1.6*117.9 (2)
In: Undefined
Description: PLT1.6*117.9; Material: STEEL/250
Tekla Common - Bottom elevation: +4.821; Top elevation: +4.946; Phase: 1; Class: 3
Tekla Quantity - Weight: 0.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 163.6 m2; Net surface area: 0 m2; Height: 117.9 mm; Width: 1.6 mm; Length: 174.8 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 117.899 mm; NetArea: 0.0379262 m2; CrossSectionArea: 0.00000256 m2; NetVolume: 0.0000295097 m3; GrossVolume: 0.0000295097 m3
Name | ASSEMBLY_POS = Reference | GrossArea (m2)
RAD TOP PLATE | PL/1591 | 0.0206061
RAD TOP PLATE | PL/1590 | 0.0206059

# IfcPlate: PLT1.6*118.8 (2)
In: Undefined
Description: PLT1.6*118.8; Material: STEEL/250
Tekla Common - Bottom elevation: +4.798; Top elevation: +4.926; Phase: 1; Class: 3
Tekla Quantity - Weight: 0.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 163.6 m2; Net surface area: 0 m2; Height: 118.8 mm; Width: 1.6 mm; Length: 177.2 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 118.811 mm; NetArea: 0.0383215 m2; GrossArea: 0.021056 m2; CrossSectionArea: 0.00000256 m2; NetVolume: 0.0000298316 m3; GrossVolume: 0.0000298316 m3
Name | ASSEMBLY_POS = Reference
RAD TOP PLATE | PL/1684
RAD TOP PLATE | PL/1683

# IfcPlate: PLT1.6*120.5 (2)
In: Undefined
Description: PLT1.6*120.5; Material: STEEL/250
Tekla Common - Bottom elevation: +4.830; Top elevation: +4.963; Phase: 1; Class: 3
Tekla Quantity - Weight: 0.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 163.6 m2; Net surface area: 0 m2; Height: 120.5 mm; Width: 1.6 mm; Length: 181.4 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.00000256 m2
Name | ASSEMBLY_POS = Reference | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
RAD TOP PLATE | PL/1597 | 120.49 | 0.0389546 | 0.0218545 | 0.0000303189
RAD TOP PLATE | PL/1596 | 120.492 | 0.0389547 | 0.0218556 | 0.0000303188

# IfcPlate: PLT1.6*123.1 (2)
In: Undefined
Description: PLT1.6*123.1; Material: STEEL/250
Tekla Common - Bottom elevation: +4.840; Top elevation: +4.980; Phase: 1; Class: 3
Tekla Quantity - Weight: 0.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 163.6 m2; Net surface area: 0 m2; Height: 123.1 mm; Width: 1.6 mm; Length: 188 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - NetArea: 0.0400402 m2; CrossSectionArea: 0.00000256 m2
Name | ASSEMBLY_POS = Reference | Width (mm) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
RAD TOP PLATE | PL/1603 | 123.055 | 0.0231354 | 0.0000311733
RAD TOP PLATE | PL/1602 | 123.057 | 0.0231366 | 0.0000311732

# IfcPlate: PLT1.6*125.6 (2)
In: Undefined
Description: PLT1.6*125.6; Material: STEEL/250
Tekla Common - Bottom elevation: +4.850; Top elevation: +4.998; Phase: 1; Class: 3
Tekla Quantity - Weight: 0.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 163.6 m2; Net surface area: 0 m2; Height: 125.6 mm; Width: 1.6 mm; Length: 194.7 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - NetArea: 0.041191 m2; CrossSectionArea: 0.00000256 m2
Name | ASSEMBLY_POS = Reference | Width (mm) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
RAD TOP PLATE | PL/1609 | 125.595 | 0.0244556 | 0.0000320788
RAD TOP PLATE | PL/1608 | 125.597 | 0.0244568 | 0.0000320786

# IfcPlate: PLT1.6*131.4 (2)
In: Undefined
Description: PLT1.6*131.4; Material: STEEL/250
Tekla Common - Bottom elevation: +4.877; Top elevation: +5.043; Phase: 1; Class: 3
Tekla Quantity - Weight: 0.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 164.9 m2; Net surface area: 0 m2; Height: 131.4 mm; Width: 1.6 mm; Length: 211 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.00000256 m2
Name | ASSEMBLY_POS = Reference | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
RAD TOP PLATE | PL/1630 | 131.379 | 0.0445587 | 0.0277269 | 0.0000344283
RAD TOP PLATE | PL/1616 | 131.376 | 0.0445684 | 0.0277255 | 0.0000344355

# IfcPlate: PLT1.6*162.9 (2)
In: Undefined
Description: PLT1.6*162.9; Material: STEEL/250
Tekla Common - Bottom elevation: +4.830; Top elevation: +4.945; Phase: 1; Class: 3
Tekla Quantity - Weight: 0.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 162.9 m2; Net surface area: 0.1 m2; Height: 162.9 mm; Width: 1.6 mm; Length: 169.1 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 162.913 mm; NetArea: 0.0541858 m2; CrossSectionArea: 0.00000256 m2
Name | ASSEMBLY_POS = Reference | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
RAD TOP PLATE | PL/1581 | 0.027547 | 0.0000423422
RAD TOP PLATE | PL/1580 | 0.0275471 | 0.0000423423

# IfcPlate: PLT1.6*164.8 (2)
In: Undefined
Description: PLT1.6*164.8; Material: STEEL/250
Tekla Common - Bottom elevation: +4.857; Top elevation: +4.978; Phase: 1; Class: 3
Tekla Quantity - Weight: 0.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 162.9 m2; Net surface area: 0.1 m2; Height: 164.8 mm; Width: 1.6 mm; Length: 175.3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 164.84 mm; NetArea: 0.0553801 m2; CrossSectionArea: 0.00000256 m2; NetVolume: 0.0000432877 m3; GrossVolume: 0.0000432877 m3
Name | ASSEMBLY_POS = Reference | GrossArea (m2)
RAD TOP PLATE | PL/1587 | 0.0288996
RAD TOP PLATE | PL/1586 | 0.0288997

# IfcPlate: PLT1.6*168.7 (2)
In: Undefined
Description: PLT1.6*168.7; Material: STEEL/250
Tekla Common - Bottom elevation: +4.912; Top elevation: +5.045; Phase: 1; Class: 3
Tekla Quantity - Weight: 0.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 162.9 m2; Net surface area: 0.1 m2; Height: 168.7 mm; Width: 1.6 mm; Length: 187.7 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.00000256 m2
Name | ASSEMBLY_POS = Reference | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
RAD TOP PLATE | PL/1593 | 168.681 | 0.057862 | 0.0316634 | 0.000045251
RAD TOP PLATE | PL/1592 | 168.682 | 0.0578621 | 0.0316648 | 0.0000452509

# IfcPlate: PLT1.6*169.7 (2)
In: Undefined
Description: PLT1.6*169.7; Material: STEEL/250
Tekla Common - Bottom elevation: +4.899; Top elevation: +5.036; Phase: 1; Class: 3
Tekla Quantity - Weight: 0.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 162.9 m2; Net surface area: 0.1 m2; Height: 169.7 mm; Width: 1.6 mm; Length: 190.8 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 169.65 mm; GrossArea: 0.032377 m2; CrossSectionArea: 0.00000256 m2
Name | ASSEMBLY_POS = Reference | NetArea (m2) | NetVolume (m3) = GrossVolume (m3)
RAD TOP PLATE | PL/1686 | 0.0585123 | 0.0000457641
RAD TOP PLATE | PL/1685 | 0.0585124 | 0.000045768

# IfcPlate: PLT1.6*171.5 (2)
In: Undefined
Description: PLT1.6*171.5; Material: STEEL/250
Tekla Common - Bottom elevation: +4.952; Top elevation: +5.095; Phase: 1; Class: 3
Tekla Quantity - Weight: 0.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 162.7 m2; Net surface area: 0.1 m2; Height: 171.5 mm; Width: 1.6 mm; Length: 197 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 171.535 mm; NetArea: 0.0598182 m2; GrossArea: 0.0337933 m2; CrossSectionArea: 0.00000256 m2
Name | ASSEMBLY_POS = Reference | NetVolume (m3) = GrossVolume (m3)
RAD TOP PLATE | PL/1599 | 0.0000467988
RAD TOP PLATE | PL/1598 | 0.0000467987

# IfcPlate: PLT1.6*174.4 (2)
In: Undefined
Description: PLT1.6*174.4; Material: STEEL/250
Tekla Common - Bottom elevation: +4.994; Top elevation: +5.147; Phase: 1; Class: 3
Tekla Quantity - Weight: 0.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 162.7 m2; Net surface area: 0.1 m2; Height: 174.4 mm; Width: 1.6 mm; Length: 206.4 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 174.351 mm; CrossSectionArea: 0.00000256 m2; NetVolume: 0.0000484193 m3; GrossVolume: 0.0000484193 m3
Name | ASSEMBLY_POS = Reference | NetArea (m2) | GrossArea (m2)
RAD TOP PLATE | PL/1605 | 0.0618676 | 0.0359797
RAD TOP PLATE | PL/1604 | 0.0618675 | 0.0359793

# IfcPlate: PLT1.6*177.1 (2)
In: Undefined
Description: PLT1.6*177.1; Material: STEEL/250
Tekla Common - Bottom elevation: +5.037; Top elevation: +5.201; Phase: 1; Class: 3
Tekla Quantity - Weight: 0.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 162.7 m2; Net surface area: 0.1 m2; Height: 177.1 mm; Width: 1.6 mm; Length: 215.9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.00000256 m2
Name | ASSEMBLY_POS = Reference | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
RAD TOP PLATE | PL/1611 | 177.143 | 0.0640296 | 0.0382417 | 0.0000501271
RAD TOP PLATE | PL/1610 | 177.146 | 0.0640297 | 0.0382438 | 0.0000501268

# IfcPlate: PLT1.6*183.6 (2)
In: Undefined
Description: PLT1.6*183.6; Material: STEEL/250
Tekla Common - Bottom elevation: +5.145; Top elevation: +5.334; Phase: 1; Class: 3
Tekla Quantity - Weight: 0.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 162.5 m2; Net surface area: 0.1 m2; Height: 183.6 mm; Width: 1.6 mm; Length: 239.4 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 183.622 mm; NetArea: 0.0697787 m2; GrossArea: 0.043963 m2; CrossSectionArea: 0.00000256 m2; NetVolume: 0.0000547034 m3; GrossVolume: 0.0000547034 m3
Name | ASSEMBLY_POS = Reference
RAD TOP PLATE | PL/1615
RAD TOP PLATE | PL/1614

# IfcPlate: PLT1.6*92.1 (2)
In: Undefined
Description: PLT1.6*92.1; Material: STEEL/250
Tekla Common - Bottom elevation: +4.770; Top elevation: +4.880; Phase: 1; Class: 3
Tekla Quantity - Weight: 0.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 164.4 m2; Net surface area: 0 m2; Height: 92.1 mm; Width: 1.6 mm; Length: 149.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.00000256 m2
Name | ASSEMBLY_POS = Reference | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
RAD TOP PLATE | PL/1577 | 92.1175 | 0.0274749 | 0.0137838 | 0.0000212742
RAD TOP PLATE | PL/1576 | 92.1171 | 0.0274748 | 0.0137831 | 0.0000212743

# IfcPlate: PLT1.6*93.5 (2)
In: Undefined
Description: PLT1.6*93.5; Material: STEEL/250
Tekla Common - Bottom elevation: +4.757; Top elevation: +4.870; Phase: 1; Class: 3
Tekla Quantity - Weight: 0.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 164.4 m2; Net surface area: 0 m2; Height: 93.5 mm; Width: 1.6 mm; Length: 152.9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.00000256 m2
Name | ASSEMBLY_POS = Reference | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
RAD TOP PLATE | PL/1583 | 93.5251 | 0.0278205 | 0.0142997 | 0.0000215456
RAD TOP PLATE | PL/1582 | 93.5245 | 0.0278204 | 0.0142989 | 0.0000215457

# IfcPlate: PLT1.6*96.3 (2)
In: Undefined
Description: PLT1.6*96.3; Material: STEEL/250
Tekla Common - Bottom elevation: +4.729; Top elevation: +4.850; Phase: 1; Class: 3
Tekla Quantity - Weight: 0.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 164.4 m2; Net surface area: 0 m2; Height: 96.3 mm; Width: 1.6 mm; Length: 159.3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 96.3225 mm; NetArea: 0.0285457 m2; GrossArea: 0.0153487 m2; CrossSectionArea: 0.00000256 m2; NetVolume: 0.0000221144 m3; GrossVolume: 0.0000221144 m3
Name | ASSEMBLY_POS = Reference
RAD TOP PLATE | PL/1589
RAD TOP PLATE | PL/1588

# IfcPlate: PLT1.6*97 (2)
In: Undefined
Description: PLT1.6*97; Material: STEEL/250
Tekla Common - Bottom elevation: +4.696; Top elevation: +4.818; Phase: 1; Class: 3
Tekla Quantity - Weight: 0.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 164.4 m2; Net surface area: 0 m2; Height: 97 mm; Width: 1.6 mm; Length: 161 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 97.0428 mm; GrossArea: 0.0156281 m2; CrossSectionArea: 0.00000256 m2
Name | ASSEMBLY_POS = Reference | NetArea (m2) | NetVolume (m3) = GrossVolume (m3)
RAD TOP PLATE | PL/1682 | 0.0287518 | 0.0000222785
RAD TOP PLATE | PL/1681 | 0.0287527 | 0.0000222754

# IfcPlate: PLT1.6*98.4 (2)
In: Undefined
Description: PLT1.6*98.4; Material: STEEL/250
Tekla Common - Bottom elevation: +4.708; Top elevation: +4.833; Phase: 1; Class: 3
Tekla Quantity - Weight: 0.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 164.4 m2; Net surface area: 0 m2; Height: 98.4 mm; Width: 1.6 mm; Length: 164.2 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - NetArea: 0.0291252 m2; CrossSectionArea: 0.00000256 m2; NetVolume: 0.0000225688 m3; GrossVolume: 0.0000225688 m3
Name | ASSEMBLY_POS = Reference | Width (mm) | GrossArea (m2)
RAD TOP PLATE | PL/1595 | 98.4123 | 0.0161549
RAD TOP PLATE | PL/1594 | 98.4126 | 0.0161551
