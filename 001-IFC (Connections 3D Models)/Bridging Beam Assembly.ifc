Properties of the parts of a building model (IFC2X3), part 1 of 3

# File
Description: ViewDefinition[CoordinationView_V2.0, QuantityTakeOffAddOnView], Option [BaseQuantities:On], Option [GridExport:On], Option [Assemblies:On], Option [Bolts:On], Option [Rebars:On], Option [PourObjects:Off], Option [Welds:Off], Option [SurfaceTreatments:Off], Option [LocationBy:0], Option [ViewColors:Off], Option [SectionedSpine:Off], Option [PropertySets:On], Option [Export all:Off]
File name: Bridging Beam Assembly.ifc
Time: 2026-09-11T11:38:25
Author: MSI\User
Organization: Structural Designer
Written by: IFC Database Version: Work
Made in: Tekla Structures 2019 Service Pack 13, IFC Export Version: 4.0.0.0 Oct 18 2021

# IfcBuildingStorey, Undefined
In: Undefined
Elevation: 0 mm

# IfcBeam: C:150-15 (66)
In: Undefined
Description: C:150-15; Material: STEEL/300PLUS
Tekla Common - Phase: 1; Class: 1
Tekla Quantity - Volume: 0 m3; Area per tons: 176.4 m2; Height: 152 mm; Width: 64 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Gross footprint area (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
6 x FASCIA | Z/426 | +5.823 | +5.975 | 9 | 0.2 | 1.6 | 2600 | 1.59472 | 0.0011895 | 9.33757
8 x FASCIA | Z/420 | +5.824 | +5.976 | 9.4 | 0.2 | 1.7 | 2700 | 1.65602 | 0.00123525 | 9.69671
12 x FASCIA | Z/409 | +5.823 | +5.975 | 8.1 | 0.1 | 1.5 | 2330 | 1.42921 | 0.00106598 | 8.3679
2 x FASCIA | Z/420 | +5.800 | +5.952 | 9.4 | 0.2 | 1.7 | 2700 | 1.65602 | 0.00123525 | 9.69671
2 x FASCIA | Z/420 | +5.778 | +5.930 | 9.4 | 0.2 | 1.7 | 2700 | 1.65602 | 0.00123525 | 9.69671
18 x FASCIA | Z/426 | +5.824 | +5.976 | 9 | 0.2 | 1.6 | 2600 | 1.59472 | 0.0011895 | 9.33757
6 x FASCIA | Z/400 | +5.824 | +5.976 | 7.9 | 0.1 | 1.5 | 2260 | 1.3863 | 0.00103395 | 8.11651
2 x FASCIA | Z/386 | +5.824 | +5.976 | 7.7 | 0.1 | 1.2 | 2200 | 1.34952 | 0.0010065 | 7.90102
2 x FASCIA | Z/386 | +5.799 | +5.951 | 7.7 | 0.1 | 1.2 | 2200 | 1.34952 | 0.0010065 | 7.90102
8 x FASCIA | Z/386 | +5.778 | +5.930 | 7.7 | 0.1 | 1.2 | 2200 | 1.34952 | 0.0010065 | 7.90102

# IfcBeam: C:150-24 (48)
In: Undefined
Description: C:150-24; Material: STEEL/G450
Tekla Common - Phase: 1; Class: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 152 mm; Width: 64 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Finish | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
4 x RAFTER | Z/222 | 12 deg | +5.764 | +6.010 | 2.6 | 111.7 | 0.4 | 464.2 | 464.162 | 0.28907 | 0.00034244 | 2.68815
2 x RAFTER | Z/2555 | 12 deg | +5.764 | +6.010 | 2.6 | 111.7 | 0.4 | 464.2 | 464.162 | 0.28907 | 0.00034244 | 2.68815
COLUMN | Z/2637 | 25 deg | +4.860 | +5.976 | 6.2 | 111.4 | 0.6 | 1115.7 | 1115.83 | 0.692844 | 0.000823215 | 6.46224
COLUMN | Z/2513 | 25 deg | +4.860 | +5.976 | 6.2 | 111.4 | 0.6 | 1115.7 | 1115.83 | 0.692844 | 0.000823215 | 6.46224
4 x RAFTER | Z/222 | 12 deg | +5.759 | +6.004 | 2.6 | 111.7 | 0.4 | 464.2 | 464.162 | 0.28907 | 0.00034244 | 2.68815
2 x RAFTER | Z/2555 | 12 deg | +5.759 | +6.004 | 2.6 | 111.7 | 0.4 | 464.2 | 464.162 | 0.28907 | 0.00034244 | 2.68815
COLUMN | Z/2636 | 25 deg | +4.860 | +5.951 | 6.2 | 111.4 | 0.6 | 1091.3 | 1091.29 | 0.677639 | 0.00080511 | 6.32012
COLUMN | Z/2512 | 25 deg | +4.860 | +5.951 | 6.2 | 111.4 | 0.6 | 1091.3 | 1091.29 | 0.677639 | 0.00080511 | 6.32012
8 x RAFTER | Z/222 | 12 deg | +5.755 | +6.000 | 2.6 | 111.7 | 0.4 | 464.2 | 464.162 | 0.28907 | 0.00034244 | 2.68815
4 x RAFTER | Z/2555 | 12 deg | +5.755 | +6.000 | 2.6 | 111.7 | 0.4 | 464.2 | 464.162 | 0.28907 | 0.00034244 | 2.68815
2 x COLUMN | Z/2633 | 25 deg | +4.860 | +5.930 | 5.9 | 111.4 | 0.6 | 1069.8 | 1069.83 | 0.664342 | 0.000789278 | 6.19583
2 x COLUMN | Z/2509 | 25 deg | +4.860 | +5.930 | 5.9 | 111.4 | 0.6 | 1069.8 | 1069.83 | 0.664342 | 0.000789278 | 6.19583
4 x RAFTER | Z/222 | 12 deg | +5.718 | +5.964 | 2.6 | 111.7 | 0.4 | 464.2 | 464.162 | 0.28907 | 0.00034244 | 2.68815
2 x RAFTER | Z/2555 | 12 deg | +5.718 | +5.964 | 2.6 | 111.7 | 0.4 | 464.2 | 464.162 | 0.28907 | 0.00034244 | 2.68815
COLUMN | Z/2635 | 25 deg | +4.860 | +5.930 | 5.9 | 111.4 | 0.6 | 1069.8 | 1069.83 | 0.664342 | 0.000789278 | 6.19583
COLUMN | Z/2511 | 25 deg | +4.860 | +5.930 | 5.9 | 111.4 | 0.6 | 1069.8 | 1069.83 | 0.664342 | 0.000789278 | 6.19583
4 x RAFTER | Z/222 | 12 deg | +5.738 | +5.983 | 2.6 | 111.7 | 0.4 | 464.2 | 464.162 | 0.28907 | 0.00034244 | 2.68815
2 x RAFTER | Z/2555 | 12 deg | +5.738 | +5.983 | 2.6 | 111.7 | 0.4 | 464.2 | 464.162 | 0.28907 | 0.00034244 | 2.68815
COLUMN | Z/2634 | 25 deg | +4.860 | +5.930 | 5.9 | 111.4 | 0.6 | 1069.8 | 1069.83 | 0.664342 | 0.000789278 | 6.19583
COLUMN | Z/2510 | 25 deg | +4.860 | +5.930 | 5.9 | 111.4 | 0.6 | 1069.8 | 1069.83 | 0.664342 | 0.000789278 | 6.19583

# IfcBeam: C:200-24 (96)
In: Undefined
Description: C:200-24; Material: STEEL/G450
Tekla Common - Phase: 1; Class: 1
Tekla Quantity - Volume: 0 m3; Height: 203 mm; Width: 76 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Finish | Bottom elevation | Top elevation | Weight (kg) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
12 x RAFTER | Z/247 | 12 deg | +5.725 | +6.038 | 3.9 | 0 | 110.5 | 0.4 | 549.9 | 549.853 | 0.430525 | 0.000511232 | 4.01317
2 x RAFTER | Z/2998 | 12 deg | +5.725 | +6.038 | 3.9 | 0 | 110.5 | 0.4 | 549.9 | 549.854 | 0.430526 | 0.000511233 | 4.01318
3 x COLUMN | Z/3038 | 25 deg | +4.860 | +5.976 | 7.9 | 0 | 110.2 | 0.9 | 1115.7 | 1115.7 | 0.87166 | 0.00103733 | 8.14307
3 x COLUMN | Z/2648 | 25 deg | +4.860 | +5.976 | 7.9 | 0 | 110.2 | 0.9 | 1115.7 | 1115.7 | 0.87166 | 0.00103733 | 8.14307
12 x RAFTER | Z/247 | 12 deg | +5.745 | +6.058 | 3.9 | 0 | 110.5 | 0.4 | 549.9 | 549.853 | 0.430525 | 0.000511232 | 4.01317
2 x RAFTER | Z/2998 | 12 deg | +5.745 | +6.058 | 3.9 | 0 | 110.5 | 0.4 | 549.9 | 549.854 | 0.430526 | 0.000511233 | 4.01318
3 x COLUMN | Z/3037 | 25 deg | +4.860 | +5.976 | 7.9 | 0 | 110.2 | 0.9 | 1115.7 | 1115.7 | 0.87166 | 0.00103733 | 8.14307
3 x COLUMN | Z/2643 | 25 deg | +4.860 | +5.976 | 7.9 | 0 | 110.2 | 0.9 | 1115.7 | 1115.7 | 0.87166 | 0.00103733 | 8.14307
12 x RAFTER | Z/247 | 12 deg | +5.762 | +6.075 | 3.9 | 0 | 110.5 | 0.4 | 549.9 | 549.853 | 0.430525 | 0.000511232 | 4.01317
2 x RAFTER | Z/2998 | 12 deg | +5.762 | +6.075 | 3.9 | 0 | 110.5 | 0.4 | 549.9 | 549.854 | 0.430526 | 0.000511233 | 4.01318
3 x COLUMN | Z/3036 | 25 deg | +4.860 | +5.976 | 7.9 | 0 | 110.2 | 0.9 | 1115.7 | 1115.7 | 0.87166 | 0.00103733 | 8.14307
3 x COLUMN | Z/2642 | 25 deg | +4.860 | +5.976 | 7.9 | 0 | 110.2 | 0.9 | 1115.7 | 1115.7 | 0.87166 | 0.00103733 | 8.14307
4 x RAFTER | Z/2998 | 12 deg | +5.725 | +6.038 | 3.9 | 0 | 110.5 | 0.4 | 549.9 | 549.858 | 0.430529 | 0.000511236 | 4.0132
2 x RAFTER | Z/2998 | 12 deg | +5.745 | +6.058 | 3.9 | 0 | 110.5 | 0.4 | 549.9 | 549.848 | 0.430521 | 0.000511227 | 4.01313
2 x RAFTER | Z/2998 | 12 deg | +5.762 | +6.075 | 3.9 | 0 | 110.5 | 0.4 | 549.9 | 549.853 | 0.430525 | 0.000511232 | 4.01317
2 x BRIDGING BEAM | Z/2997 |  | +5.723 | +5.926 | 13.4 | 0.1 | 110.2 | 1.5 | 1904 | 1904 | 1.48622 | 0.00177026 | 13.8966
2 x BRIDGING BEAM | Z/2996 |  | +5.723 | +5.926 | 13.4 | 0.1 | 110.2 | 1.5 | 1904 | 1904 | 1.48622 | 0.00177026 | 13.8966
2 x BEAM | Z/385 |  | +5.717 | +5.920 | 13.7 | 0.1 | 110.2 | 1.5 | 1916 | 1916 | 1.49557 | 0.00178142 | 13.9841
2 x BEAM | Z/2618 |  | +5.717 | +5.920 | 13.7 | 0.1 | 110.2 | 1.5 | 1916 | 1916 | 1.49557 | 0.00178142 | 13.9841
2 x RAFTER | Z/2998 | 12 deg | +5.745 | +6.058 | 3.9 | 0 | 110.5 | 0.4 | 549.9 | 549.858 | 0.430529 | 0.000511236 | 4.0132
2 x BRIDGING BEAM | Z/2997 |  | +5.743 | +5.946 | 13.4 | 0.1 | 110.2 | 1.5 | 1904 | 1904 | 1.48622 | 0.00177026 | 13.8966
2 x BRIDGING BEAM | Z/2996 |  | +5.743 | +5.946 | 13.4 | 0.1 | 110.2 | 1.5 | 1904 | 1904 | 1.48622 | 0.00177026 | 13.8966
4 x BEAM | Z/385 |  | +5.727 | +5.930 | 13.7 | 0.1 | 110.2 | 1.5 | 1916 | 1916 | 1.49557 | 0.00178142 | 13.9841
4 x BEAM | Z/2618 |  | +5.727 | +5.930 | 13.7 | 0.1 | 110.2 | 1.5 | 1916 | 1916 | 1.49557 | 0.00178142 | 13.9841
2 x RAFTER | Z/2998 | 12 deg | +5.762 | +6.075 | 3.9 | 0 | 110.5 | 0.4 | 549.9 | 549.858 | 0.430529 | 0.000511236 | 4.0132
2 x BRIDGING BEAM | Z/2997 |  | +5.763 | +5.966 | 13.4 | 0.1 | 110.2 | 1.5 | 1904 | 1904 | 1.48622 | 0.00177026 | 13.8966
2 x BRIDGING BEAM | Z/2996 |  | +5.763 | +5.966 | 13.4 | 0.1 | 110.2 | 1.5 | 1904 | 1904 | 1.48622 | 0.00177026 | 13.8966

# IfcBeam: C:250-24 (108)
In: Undefined
Description: C:250-24; Material: STEEL/G450
Tekla Common - Phase: 1; Class: 1
Tekla Quantity - Volume: 0 m3; Height: 254 mm; Width: 76 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Finish | Bottom elevation | Top elevation | Weight (kg) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
12 x RAFTER | Z/289 | 12 deg | +5.686 | +6.086 | 5.9 | 0 | 110 | 0.6 | 729.8 | 729.799 | 0.644031 | 0.000766114 | 6.014
4 x RAFTER | Z/2591 | 12 deg | +5.686 | +6.086 | 5.9 | 0 | 110 | 0.6 | 729.8 | 729.805 | 0.644036 | 0.00076612 | 6.01404
2 x COLUMN | Z/3112 | 25 deg | +4.860 | +5.975 | 8.8 | 0 | 110 | 0.9 | 1115.5 | 1115.52 | 0.983311 | 0.00117103 | 9.19258
2 x COLUMN | Z/3041 | 25 deg | +4.860 | +5.975 | 8.8 | 0 | 110 | 0.9 | 1115.5 | 1115.52 | 0.983311 | 0.00117103 | 9.19258
8 x RAFTER | Z/289 | 12 deg | +5.705 | +6.106 | 5.9 | 0 | 110 | 0.6 | 729.8 | 729.799 | 0.644031 | 0.000766114 | 6.014
2 x RAFTER | Z/2591 | 12 deg | +5.705 | +6.106 | 5.9 | 0 | 110 | 0.6 | 729.8 | 729.805 | 0.644036 | 0.00076612 | 6.01404
2 x COLUMN | Z/3111 | 25 deg | +4.860 | +5.975 | 8.8 | 0 | 110 | 0.9 | 1115.5 | 1115.52 | 0.983311 | 0.00117103 | 9.19258
2 x COLUMN | Z/3040 | 25 deg | +4.860 | +5.975 | 8.8 | 0 | 110 | 0.9 | 1115.5 | 1115.52 | 0.983311 | 0.00117103 | 9.19258
8 x RAFTER | Z/289 | 12 deg | +5.722 | +6.123 | 5.9 | 0 | 110 | 0.6 | 729.8 | 729.799 | 0.644031 | 0.000766114 | 6.014
2 x RAFTER | Z/2591 | 12 deg | +5.722 | +6.123 | 5.9 | 0 | 110 | 0.6 | 729.8 | 729.805 | 0.644036 | 0.00076612 | 6.01404
2 x COLUMN | Z/3110 | 25 deg | +4.860 | +5.975 | 8.8 | 0 | 110 | 0.9 | 1115.5 | 1115.52 | 0.983311 | 0.00117103 | 9.19258
2 x COLUMN | Z/3039 | 25 deg | +4.860 | +5.975 | 8.8 | 0 | 110 | 0.9 | 1115.5 | 1115.52 | 0.983311 | 0.00117103 | 9.19258
2 x RAFTER | Z/2591 | 12 deg | +5.686 | +6.086 | 5.9 | 0 | 110 | 0.6 | 729.8 | 729.801 | 0.644032 | 0.000766116 | 6.01401
2 x RAFTER | Z/2591 | 12 deg | +5.705 | +6.106 | 5.9 | 0 | 110 | 0.6 | 729.8 | 729.801 | 0.644032 | 0.000766116 | 6.01401
2 x RAFTER | Z/2591 | 12 deg | +5.722 | +6.123 | 5.9 | 0 | 110 | 0.6 | 729.8 | 729.801 | 0.644032 | 0.000766116 | 6.01401
COLUMN | Z/3112 | 25 deg | +4.860 | +5.976 | 9 | 0 | 110 | 0.9 | 1115.7 | 1115.7 | 0.98347 | 0.00117122 | 9.19406
2 x BEAM | Z/3071 |  | +5.687 | +5.941 | 15.3 | 0.1 | 109.8 | 1.7 | 1904 | 1904 | 1.67686 | 0.00199874 | 15.6901
2 x BEAM | Z/3070 |  | +5.687 | +5.941 | 15.3 | 0.1 | 109.8 | 1.7 | 1904 | 1904 | 1.67686 | 0.00199874 | 15.6901
COLUMN | Z/3041 | 25 deg | +4.860 | +5.976 | 9 | 0 | 109.8 | 0.9 | 1115.7 | 1115.7 | 0.98347 | 0.00117122 | 9.19406
2 x BRIDGING BEAM | Z/3005 |  | +5.712 | +5.966 | 15.3 | 0.1 | 109.8 | 1.7 | 1904 | 1904 | 1.67686 | 0.00199874 | 15.6901
2 x BRIDGING BEAM | Z/3004 |  | +5.712 | +5.966 | 15.3 | 0.1 | 109.8 | 1.7 | 1904 | 1904 | 1.67686 | 0.00199874 | 15.6901
2 x BEAM | Z/2620 |  | +5.722 | +5.976 | 15.3 | 0.1 | 109.8 | 1.7 | 1916 | 1916 | 1.68741 | 0.00201134 | 15.789
2 x BEAM | Z/2619 |  | +5.722 | +5.976 | 15.3 | 0.1 | 109.8 | 1.7 | 1916 | 1916 | 1.68741 | 0.00201134 | 15.789
2 x RAFTER | Z/2591 | 12 deg | +5.706 | +6.106 | 5.9 | 0 | 110 | 0.6 | 729.8 | 729.805 | 0.644036 | 0.00076612 | 6.01404
4 x RAFTER | Z/289 | 12 deg | +5.706 | +6.106 | 5.9 | 0 | 110 | 0.6 | 729.8 | 729.799 | 0.644031 | 0.000766114 | 6.014
COLUMN | Z/3111 | 25 deg | +4.860 | +5.976 | 9 | 0 | 109.8 | 0.9 | 1115.7 | 1115.7 | 0.98347 | 0.00117122 | 9.19406
2 x BEAM | Z/3071 |  | +5.702 | +5.956 | 15.3 | 0.1 | 109.8 | 1.7 | 1904 | 1904 | 1.67686 | 0.00199874 | 15.6901
2 x BEAM | Z/3070 |  | +5.702 | +5.956 | 15.3 | 0.1 | 109.8 | 1.7 | 1904 | 1904 | 1.67686 | 0.00199874 | 15.6901
COLUMN | Z/3040 | 25 deg | +4.860 | +5.976 | 9 | 0 | 109.8 | 0.9 | 1115.7 | 1115.7 | 0.98347 | 0.00117122 | 9.19406
4 x BRIDGING BEAM | Z/3005 |  | +5.722 | +5.976 | 15.3 | 0.1 | 109.8 | 1.7 | 1904 | 1904 | 1.67686 | 0.00199874 | 15.6901
4 x BRIDGING BEAM | Z/3004 |  | +5.722 | +5.976 | 15.3 | 0.1 | 109.8 | 1.7 | 1904 | 1904 | 1.67686 | 0.00199874 | 15.6901
2 x BEAM | Z/2620 |  | +5.697 | +5.951 | 15.3 | 0.1 | 109.8 | 1.7 | 1916 | 1916 | 1.68741 | 0.00201134 | 15.789
2 x BEAM | Z/2619 |  | +5.697 | +5.951 | 15.3 | 0.1 | 109.8 | 1.7 | 1916 | 1916 | 1.68741 | 0.00201134 | 15.789
2 x RAFTER | Z/2591 | 12 deg | +5.723 | +6.123 | 5.9 | 0 | 110 | 0.6 | 729.8 | 729.805 | 0.644036 | 0.00076612 | 6.01404
4 x RAFTER | Z/289 | 12 deg | +5.723 | +6.123 | 5.9 | 0 | 110 | 0.6 | 729.8 | 729.799 | 0.644031 | 0.000766114 | 6.014
COLUMN | Z/3110 | 25 deg | +4.860 | +5.976 | 9 | 0 | 109.8 | 0.9 | 1115.7 | 1115.7 | 0.98347 | 0.00117122 | 9.19406
2 x BEAM | Z/3071 |  | +5.722 | +5.976 | 15.3 | 0.1 | 109.8 | 1.7 | 1904 | 1904 | 1.67686 | 0.00199874 | 15.6901
2 x BEAM | Z/3070 |  | +5.722 | +5.976 | 15.3 | 0.1 | 109.8 | 1.7 | 1904 | 1904 | 1.67686 | 0.00199874 | 15.6901
COLUMN | Z/3039 | 25 deg | +4.860 | +5.976 | 9 | 0 | 109.8 | 0.9 | 1115.7 | 1115.7 | 0.98347 | 0.00117122 | 9.19406
2 x BEAM | Z/2620 |  | +5.676 | +5.930 | 15.3 | 0.1 | 109.8 | 1.7 | 1916 | 1916 | 1.68741 | 0.00201134 | 15.789
2 x BEAM | Z/2619 |  | +5.676 | +5.930 | 15.3 | 0.1 | 109.8 | 1.7 | 1916 | 1916 | 1.68741 | 0.00201134 | 15.789

# IfcBeam: C:300-24 (24)
In: Undefined
Description: C:300-24; Material: STEEL/G450
Tekla Common - Phase: 1; Class: 1
Tekla Quantity - Weight: 19 kg; Volume: 0 m3; Gross footprint area: 0.2 m2; Area per tons: 108.6 m2; Net surface area: 2.1 m2; Height: 300 mm; Width: 96 mm; Length: 1904 mm
Pset_BeamCommon - LoadBearing: no
BaseQuantities - Length: 1904 mm; OuterSurfaceArea: 2.05814 m2; NetVolume: 0.0024557 m3; NetWeight: 19.2773 kg
Name | Bottom elevation | Top elevation | ASSEMBLY_POS = Reference
6 x BEAM | +5.675 | +5.975 | Z/3083
6 x BEAM | +5.675 | +5.975 | Z/3082
6 x BRIDGING BEAM | +5.676 | +5.976 | Z/3007
6 x BRIDGING BEAM | +5.676 | +5.976 | Z/3006

# IfcBeam: C:300-30 (60)
In: Undefined
Description: C:300-30; Material: STEEL/G450
Tekla Common - Phase: 1; Class: 1
Tekla Quantity - Volume: 0 m3; Height: 300 mm; Width: 96 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Finish | Bottom elevation | Top elevation | Weight (kg) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
RAFTER | Z/430 | 12 deg | +5.652 | +6.094 | 9 | 0 | 87.7 | 0.9 | 715 | 714.952 | 0.783986 | 0.00116466 | 9.14256
2 x RAFTER | Z/2599 | 12 deg | +5.652 | +6.094 | 8.8 | 0 | 87.7 | 0.9 | 715 | 714.952 | 0.783986 | 0.00116466 | 9.14256
7 x RAFTER | Z/430 | 12 deg | +5.652 | +6.094 | 8.8 | 0 | 87.7 | 0.9 | 715 | 714.952 | 0.783986 | 0.00116466 | 9.14256
2 x COLUMN | Z/3169 | 25 deg | +4.860 | +5.976 | 14 | 0 | 87.7 | 1.2 | 1116.4 | 1116.35 | 1.22231 | 0.00181853 | 14.2755
2 x COLUMN | Z/3118 | 25 deg | +4.860 | +5.976 | 14 | 0 | 87.7 | 1.2 | 1116.4 | 1116.35 | 1.22231 | 0.00181853 | 14.2755
4 x RAFTER | Z/430 | 12 deg | +5.646 | +6.089 | 8.8 | 0 | 87.7 | 0.9 | 715 | 714.952 | 0.783986 | 0.00116466 | 9.14256
2 x RAFTER | Z/2599 | 12 deg | +5.646 | +6.089 | 8.8 | 0 | 87.7 | 0.9 | 715 | 714.952 | 0.783986 | 0.00116466 | 9.14256
COLUMN | Z/3171 | 25 deg | +4.860 | +5.952 | 13.7 | 0 | 87.7 | 1.2 | 1091.8 | 1091.81 | 1.19552 | 0.00177856 | 13.9617
COLUMN | Z/3120 | 25 deg | +4.860 | +5.952 | 13.7 | 0 | 87.7 | 1.2 | 1091.8 | 1091.81 | 1.19552 | 0.00177856 | 13.9617
4 x RAFTER | Z/430 | 12 deg | +5.642 | +6.084 | 8.8 | 0 | 87.7 | 0.9 | 715 | 714.952 | 0.783986 | 0.00116466 | 9.14256
2 x RAFTER | Z/2599 | 12 deg | +5.642 | +6.084 | 8.8 | 0 | 87.7 | 0.9 | 715 | 714.952 | 0.783986 | 0.00116466 | 9.14256
COLUMN | Z/3170 | 25 deg | +4.860 | +5.930 | 13.4 | 0 | 87.7 | 1.2 | 1070.3 | 1070.34 | 1.17207 | 0.00174358 | 13.6871
COLUMN | Z/3119 | 25 deg | +4.860 | +5.930 | 13.4 | 0 | 87.7 | 1.2 | 1070.3 | 1070.34 | 1.17207 | 0.00174358 | 13.6871
2 x BEAM | Z/3154 |  | +5.651 | +5.951 | 23.6 | 0.2 | 87.4 | 2.1 | 1884 | 1884 | 2.06059 | 0.00306904 | 24.0919
2 x BEAM | Z/3153 |  | +5.651 | +5.951 | 23.6 | 0.2 | 87.4 | 2.1 | 1884 | 1884 | 2.06059 | 0.00306904 | 24.0919
2 x RAFTER | Z/2599 | 12 deg | +5.652 | +6.094 | 8.8 | 0 | 87.7 | 0.9 | 715 | 714.962 | 0.783997 | 0.00116467 | 9.14268
2 x BEAM | Z/3154 |  | +5.671 | +5.971 | 23.6 | 0.2 | 87.4 | 2.1 | 1884 | 1884 | 2.06059 | 0.00306904 | 24.0919
2 x BEAM | Z/3153 |  | +5.671 | +5.971 | 23.6 | 0.2 | 87.4 | 2.1 | 1884 | 1884 | 2.06059 | 0.00306904 | 24.0919
4 x RAFTER | Z/430 | 12 deg | +5.671 | +6.113 | 8.8 | 0 | 87.7 | 0.9 | 715 | 714.952 | 0.783986 | 0.00116466 | 9.14256
2 x RAFTER | Z/2599 | 12 deg | +5.671 | +6.113 | 8.8 | 0 | 87.7 | 0.9 | 715 | 714.962 | 0.783997 | 0.00116467 | 9.14268
COLUMN | Z/3168 | 25 deg | +4.860 | +5.976 | 14 | 0 | 87.7 | 1.2 | 1116.4 | 1116.35 | 1.22231 | 0.00181853 | 14.2755
COLUMN | Z/3117 | 25 deg | +4.860 | +5.976 | 14 | 0 | 87.7 | 1.2 | 1116.4 | 1116.35 | 1.22231 | 0.00181853 | 14.2755
2 x BEAM | Z/3154 |  | +5.676 | +5.976 | 23.6 | 0.2 | 87.4 | 2.1 | 1884 | 1884 | 2.06059 | 0.00306904 | 24.0919
2 x BEAM | Z/3153 |  | +5.676 | +5.976 | 23.6 | 0.2 | 87.4 | 2.1 | 1884 | 1884 | 2.06059 | 0.00306904 | 24.0919
4 x RAFTER | Z/430 | 12 deg | +5.688 | +6.130 | 8.8 | 0 | 87.7 | 0.9 | 715 | 714.952 | 0.783986 | 0.00116466 | 9.14256
2 x RAFTER | Z/2599 | 12 deg | +5.688 | +6.130 | 8.8 | 0 | 87.7 | 0.9 | 715 | 714.962 | 0.783997 | 0.00116467 | 9.14268
COLUMN | Z/3167 | 25 deg | +4.860 | +5.976 | 14 | 0 | 87.7 | 1.2 | 1116.4 | 1116.35 | 1.22231 | 0.00181853 | 14.2755
COLUMN | Z/3116 | 25 deg | +4.860 | +5.976 | 14 | 0 | 87.7 | 1.2 | 1116.4 | 1116.35 | 1.22231 | 0.00181853 | 14.2755

# IfcBeam: C:350-30 (60)
In: Undefined
Description: C:350-30; Material: STEEL/G450
Tekla Common - Phase: 1; Class: 1
Tekla Quantity - Volume: 0 m3; Height: 350 mm; Width: 125 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
4 x RAFTER | Z/431 | +5.612 | +6.105 | 10.8 | 0 | 87.4 | 0.9 | 725 | 724.988 | 0.947822 | 0.00140938 | 11.0636 | Tekla Common - Finish: 12 deg
2 x RAFTER | Z/2606 | +5.612 | +6.105 | 10.8 | 0 | 87.4 | 0.9 | 725 | 724.99 | 0.947825 | 0.00140938 | 11.0636 | Tekla Common - Finish: 12 deg
COLUMN | Z/3636 | +4.860 | +5.975 | 16.7 | 0 | 87.4 | 1.5 | 1115.1 | 1115.07 | 1.45571 | 0.0021677 | 17.0164 | Tekla Common - Finish: 25 deg
2 x BEAM | Z/3627 | +5.610 | +5.960 | 27.7 | 0.2 | 87.2 | 2.4 | 1855 | 1855 | 2.4191 | 0.00360612 | 28.308
2 x BEAM | Z/3626 | +5.610 | +5.960 | 27.7 | 0.2 | 87.2 | 2.4 | 1855 | 1855 | 2.4191 | 0.00360612 | 28.308
COLUMN | Z/3615 | +4.860 | +5.975 | 16.7 | 0 | 87.4 | 1.5 | 1115.1 | 1115.07 | 1.45571 | 0.0021677 | 17.0164 | Tekla Common - Finish: 25 deg
2 x BEAM | Z/3156 | +5.626 | +5.976 | 28.2 | 0.2 | 87.2 | 2.4 | 1884 | 1884 | 2.45686 | 0.0036625 | 28.7506
2 x BEAM | Z/3155 | +5.626 | +5.976 | 28.2 | 0.2 | 87.2 | 2.4 | 1884 | 1884 | 2.45686 | 0.0036625 | 28.7506
6 x BEAM | Z/3085 | +5.625 | +5.975 | 28.5 | 0.2 | 87.2 | 2.4 | 1904 | 1904 | 2.4829 | 0.00370138 | 29.0558
6 x BEAM | Z/3084 | +5.625 | +5.975 | 28.5 | 0.2 | 87.2 | 2.4 | 1904 | 1904 | 2.4829 | 0.00370138 | 29.0558
4 x RAFTER | Z/431 | +5.631 | +6.125 | 10.8 | 0 | 87.4 | 0.9 | 725 | 724.988 | 0.947822 | 0.00140938 | 11.0636 | Tekla Common - Finish: 12 deg
2 x RAFTER | Z/2606 | +5.631 | +6.125 | 10.8 | 0 | 87.4 | 0.9 | 725 | 724.99 | 0.947825 | 0.00140938 | 11.0636 | Tekla Common - Finish: 12 deg
COLUMN | Z/3635 | +4.860 | +5.975 | 16.7 | 0 | 87.4 | 1.5 | 1115.1 | 1115.07 | 1.45571 | 0.0021677 | 17.0164 | Tekla Common - Finish: 25 deg
4 x BEAM | Z/3627 | +5.625 | +5.975 | 27.7 | 0.2 | 87.2 | 2.4 | 1855 | 1855 | 2.4191 | 0.00360612 | 28.308
4 x BEAM | Z/3626 | +5.625 | +5.975 | 27.7 | 0.2 | 87.2 | 2.4 | 1855 | 1855 | 2.4191 | 0.00360612 | 28.308
COLUMN | Z/3614 | +4.860 | +5.975 | 16.7 | 0 | 87.4 | 1.5 | 1115.1 | 1115.07 | 1.45571 | 0.0021677 | 17.0164 | Tekla Common - Finish: 25 deg
2 x BEAM | Z/3156 | +5.602 | +5.952 | 28.2 | 0.2 | 87.2 | 2.4 | 1884 | 1884 | 2.45686 | 0.0036625 | 28.7506
2 x BEAM | Z/3155 | +5.602 | +5.952 | 28.2 | 0.2 | 87.2 | 2.4 | 1884 | 1884 | 2.45686 | 0.0036625 | 28.7506
4 x RAFTER | Z/431 | +5.648 | +6.142 | 10.8 | 0 | 87.4 | 0.9 | 725 | 724.988 | 0.947822 | 0.00140938 | 11.0636 | Tekla Common - Finish: 12 deg
2 x RAFTER | Z/2606 | +5.648 | +6.142 | 10.8 | 0 | 87.4 | 0.9 | 725 | 724.99 | 0.947825 | 0.00140938 | 11.0636 | Tekla Common - Finish: 12 deg
COLUMN | Z/3634 | +4.860 | +5.975 | 16.7 | 0 | 87.4 | 1.5 | 1115.1 | 1115.07 | 1.45571 | 0.0021677 | 17.0164 | Tekla Common - Finish: 25 deg
COLUMN | Z/3613 | +4.860 | +5.975 | 16.7 | 0 | 87.4 | 1.5 | 1115.1 | 1115.07 | 1.45571 | 0.0021677 | 17.0164 | Tekla Common - Finish: 25 deg
2 x BEAM | Z/3156 | +5.580 | +5.930 | 28.2 | 0.2 | 87.2 | 2.4 | 1884 | 1884 | 2.45686 | 0.0036625 | 28.7506
2 x BEAM | Z/3155 | +5.580 | +5.930 | 28.2 | 0.2 | 87.2 | 2.4 | 1884 | 1884 | 2.45686 | 0.0036625 | 28.7506

# IfcBeam: PLT1.6*60 (144)
In: Undefined
Description: PLT1.6*60; Material: STEEL/250
Tekla Common - Phase: 1; Class: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0 m2; Height: 60 mm; Width: 1.6 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
6 x FASCIA BRACKET | Z/2531 | +5.820 | +5.977 | 0.3 | 164.3 | 387.9 | 387.901 | 0.0482712 | 0.0000374227 | 0.293768
12 x FASCIA BRACKET | Z/2531 | +5.821 | +5.979 | 0.3 | 164.3 | 387.9 | 387.881 | 0.0482687 | 0.0000374208 | 0.293753
24 x FASCIA BRACKET | Z/2531 | +5.821 | +5.978 | 0.3 | 164.3 | 387.9 | 387.881 | 0.0482687 | 0.0000374208 | 0.293753
6 x FASCIA BRACKET | Z/2520 | +5.820 | +5.977 | 0.3 | 164.3 | 339.9 | 339.901 | 0.0423576 | 0.0000328147 | 0.257596
12 x FASCIA BRACKET | Z/2520 | +5.797 | +5.954 | 0.3 | 164.3 | 339.9 | 339.881 | 0.0423551 | 0.0000328128 | 0.25758
18 x FASCIA BRACKET | Z/2520 | +5.821 | +5.978 | 0.3 | 164.3 | 339.9 | 339.881 | 0.0423551 | 0.0000328128 | 0.25758
6 x FASCIA BRACKET | Z/52 | +5.820 | +5.977 | 0.2 | 164.6 | 297.9 | 297.881 | 0.0371807 | 0.0000287808 | 0.225929
6 x FASCIA BRACKET | Z/52 | +5.775 | +5.933 | 0.2 | 164.6 | 297.9 | 297.881 | 0.0371807 | 0.0000287808 | 0.225929
18 x FASCIA BRACKET | Z/52 | +5.821 | +5.978 | 0.2 | 164.6 | 297.9 | 297.881 | 0.0371807 | 0.0000287808 | 0.225929
6 x FASCIA BRACKET | Z/2520 | +5.821 | +5.979 | 0.3 | 164.3 | 339.9 | 339.881 | 0.0423551 | 0.0000328128 | 0.25758
6 x FASCIA BRACKET | Z/52 | +5.821 | +5.979 | 0.2 | 164.6 | 297.9 | 297.881 | 0.0371807 | 0.0000287808 | 0.225929
12 x FASCIA BRACKET | Z/52 | +5.775 | +5.932 | 0.2 | 164.6 | 297.9 | 297.881 | 0.0371807 | 0.0000287808 | 0.225929
6 x FASCIA BRACKET | Z/2531 | +5.775 | +5.932 | 0.3 | 164.3 | 387.9 | 387.881 | 0.0482687 | 0.0000374208 | 0.293753
6 x FASCIA BRACKET | Z/2520 | +5.775 | +5.932 | 0.3 | 164.3 | 339.9 | 339.881 | 0.0423551 | 0.0000328128 | 0.25758

# IfcBeam: PLT3*60 (54)
In: Undefined
Description: PLT3*60; Material: STEEL/250
Tekla Common - Bottom elevation: +5.819; Top elevation: +5.980; Phase: 1; Class: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0 m2; Height: 60 mm; Width: 3 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Weight (kg) | Area per tons (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
18 x FASCIA BRACKET | Z/2556 | 0.6 | 89.9 | 386.4 | 386.425 | 0.0496201 | 0.00007029 | 0.551776
18 x FASCIA BRACKET | Z/2554 | 0.5 | 89.9 | 338.4 | 338.425 | 0.0435721 | 0.00006165 | 0.483952
18 x FASCIA BRACKET | Z/2553 | 0.3 | 90.2 | 296.4 | 296.425 | 0.0382801 | 0.00005409 | 0.424606

# IfcBeam: TH:120-95 (44)
In: Undefined
Description: TH:120-95
Tekla Common - Phase: 1; Class: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 0 m2; Height: 120 mm; Width: 165 mm
Pset_BeamCommon - LoadBearing: no
Name | Material | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x TH | STEEL/300PLUS | Z/403 | +5.278 | +5.443 | 3 | 1.1 | 1600 | 7.29632e-07 | 0.000561926 | 4.41112
2 x TH | STEEL/300PLUS | Z/403 | +6.088 | +6.227 | 3 | 1.1 | 1600 | 7.29632e-07 | 0.000561926 | 4.41112
4 x TH | STEEL/300PLUS | Z/423 | +5.313 | +5.478 | 3 | 1.2 | 1696 | 7.7341e-07 | 0.000595642 | 4.67579
2 x TH | STEEL/300PLUS | Z/423 | +6.077 | +6.216 | 3 | 1.2 | 1696 | 7.7341e-07 | 0.000595642 | 4.67579
6 x TH | STEEL/300PLUS | Z/406 | +5.421 | +5.586 | 3 | 1.2 | 1676 | 7.64289e-07 | 0.000588618 | 4.62065
4 x TH | STEEL/300PLUS | Z/406 | +6.069 | +6.208 | 3 | 1.2 | 1676 | 7.64289e-07 | 0.000588618 | 4.62065
2 x TH | STEEL/300PLUS | Z/423 | +6.064 | +6.204 | 3 | 1.2 | 1696 | 7.7341e-07 | 0.000595642 | 4.67579
6 x GIRT | STEEL/G450 | Z/3002 | +5.388 | +5.553 | 4.6 | 1.7 | 2600 | 0.00000118565 | 0.00091313 | 7.16807
6 x PURLIN | STEEL/G450 | Z/3003 | +6.021 | +6.160 | 4.6 | 1.7 | 2600 | 0.00000118565 | 0.00091313 | 7.16807
2 x TH | STEEL/300PLUS | Z/406 | +6.035 | +6.175 | 3 | 1.2 | 1676 | 7.64289e-07 | 0.000588618 | 4.62065
4 x TH | STEEL/300PLUS | Z/389 | +5.429 | +5.594 | 3 | 1.2 | 1664 | 7.58817e-07 | 0.000584403 | 4.58757
2 x TH | STEEL/300PLUS | Z/389 | +5.992 | +6.132 | 3 | 1.2 | 1664 | 7.58817e-07 | 0.000584403 | 4.58757
2 x TH | STEEL/300PLUS | Z/389 | +5.946 | +6.086 | 3 | 1.2 | 1664 | 7.58817e-07 | 0.000584403 | 4.58757

# IfcBeam: TH:75-95 (44)
In: Undefined
Description: TH:75-95
Tekla Common - Phase: 1; Class: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 0 m2; Height: 75 mm; Width: 125 mm
Pset_BeamCommon - LoadBearing: no
Name | Material | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x TH | STEEL/300PLUS | Z/401 | +5.298 | +5.423 | 3 | 0.6 | 1600 | 7.29632e-07 | 0.000371041 | 2.91267
2 x TH | STEEL/300PLUS | Z/401 | +6.129 | +6.219 | 3 | 0.6 | 1600 | 7.29632e-07 | 0.000371041 | 2.91267
4 x TH | STEEL/300PLUS | Z/421 | +5.333 | +5.458 | 3 | 0.9 | 1696 | 7.7341e-07 | 0.000393303 | 3.08743
2 x TH | STEEL/300PLUS | Z/421 | +6.071 | +6.161 | 3 | 0.9 | 1696 | 7.7341e-07 | 0.000393303 | 3.08743
6 x TH | STEEL/300PLUS | Z/404 | +5.441 | +5.566 | 3 | 0.9 | 1676 | 7.64289e-07 | 0.000388665 | 3.05102
4 x TH | STEEL/300PLUS | Z/404 | +6.110 | +6.200 | 3 | 0.9 | 1676 | 7.64289e-07 | 0.000388665 | 3.05102
2 x TH | STEEL/300PLUS | Z/421 | +6.105 | +6.195 | 3 | 0.9 | 1696 | 7.7341e-07 | 0.000393303 | 3.08743
6 x GIRT | STEEL/G450 | Z/2995 | +5.408 | +5.533 | 4.6 | 1.2 | 2600 | 0.00000118565 | 0.000602942 | 4.73309
6 x PURLIN | STEEL/G450 | Z/2999 | +6.062 | +6.152 | 4.6 | 1.2 | 2600 | 0.00000118565 | 0.000602942 | 4.73309
2 x TH | STEEL/300PLUS | Z/404 | +6.076 | +6.166 | 3 | 0.9 | 1676 | 7.64289e-07 | 0.000388665 | 3.05102
4 x TH | STEEL/300PLUS | Z/387 | +5.449 | +5.574 | 3 | 0.9 | 1664 | 7.58817e-07 | 0.000385883 | 3.02918
4 x TH | STEEL/300PLUS | Z/387 | +5.987 | +6.077 | 3 | 0.9 | 1664 | 7.58817e-07 | 0.000385883 | 3.02918

# IfcBeam: TH:96-95 (44)
In: Undefined
Description: TH:96-95
Tekla Common - Phase: 1; Class: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 0 m2; Height: 96 mm; Width: 150 mm
Pset_BeamCommon - LoadBearing: no
Name | Material | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x TH | STEEL/300PLUS | Z/402 | +5.286 | +5.436 | 3 | 0.9 | 1600 | 7.29632e-07 | 0.000459476 | 3.60689
2 x TH | STEEL/300PLUS | Z/402 | +6.109 | +6.223 | 3 | 0.9 | 1600 | 7.29632e-07 | 0.000459476 | 3.60689
4 x TH | STEEL/300PLUS | Z/422 | +5.321 | +5.471 | 3 | 0.9 | 1696 | 7.7341e-07 | 0.000487044 | 3.8233
2 x TH | STEEL/300PLUS | Z/422 | +6.073 | +6.187 | 3 | 0.9 | 1696 | 7.7341e-07 | 0.000487044 | 3.8233
6 x TH | STEEL/300PLUS | Z/405 | +5.428 | +5.578 | 3 | 0.9 | 1676 | 7.64289e-07 | 0.000481301 | 3.77821
4 x TH | STEEL/300PLUS | Z/405 | +6.090 | +6.204 | 3 | 0.9 | 1676 | 7.64289e-07 | 0.000481301 | 3.77821
2 x TH | STEEL/300PLUS | Z/422 | +6.085 | +6.199 | 3 | 0.9 | 1696 | 7.7341e-07 | 0.000487044 | 3.8233
6 x GIRT | STEEL/G450 | Z/3000 | +5.396 | +5.546 | 4.6 | 1.5 | 2600 | 0.00000118565 | 0.000746648 | 5.86119
6 x PURLIN | STEEL/G450 | Z/3001 | +6.042 | +6.155 | 4.6 | 1.5 | 2600 | 0.00000118565 | 0.000746648 | 5.86119
2 x TH | STEEL/300PLUS | Z/405 | +6.056 | +6.170 | 3 | 0.9 | 1676 | 7.64289e-07 | 0.000481301 | 3.77821
4 x TH | STEEL/300PLUS | Z/388 | +5.437 | +5.587 | 3 | 0.9 | 1664 | 7.58817e-07 | 0.000477855 | 3.75116
2 x TH | STEEL/300PLUS | Z/388 | +5.989 | +6.102 | 3 | 0.9 | 1664 | 7.58817e-07 | 0.000477855 | 3.75116
2 x TH | STEEL/300PLUS | Z/388 | +5.967 | +6.081 | 3 | 0.9 | 1664 | 7.58817e-07 | 0.000477855 | 3.75116

# IfcColumn: C:150-24 (12)
In: Undefined
Description: C:150-24; Material: STEEL/G450
Tekla Common - Finish: 25 deg; Bottom elevation: +4.860; Phase: 1; Class: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 111.4 m2; Net surface area: 0.6 m2; Height: 152 mm; Width: 64 mm
Pset_ColumnCommon - LoadBearing: no
Name | Top elevation | ASSEMBLY_POS = Reference | Weight (kg) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
COLUMN | +5.976 | Z/2637 | 6.2 | 1115.7 | 1115.83 | 0.692844 | 0.000823215 | 6.46224
COLUMN | +5.976 | Z/2513 | 6.2 | 1115.7 | 1115.83 | 0.692844 | 0.000823215 | 6.46224
COLUMN | +5.951 | Z/2636 | 6.2 | 1091.3 | 1091.29 | 0.677639 | 0.00080511 | 6.32012
COLUMN | +5.951 | Z/2512 | 6.2 | 1091.3 | 1091.29 | 0.677639 | 0.00080511 | 6.32012
2 x COLUMN | +5.930 | Z/2633 | 5.9 | 1069.8 | 1069.83 | 0.664342 | 0.000789278 | 6.19583
2 x COLUMN | +5.930 | Z/2509 | 5.9 | 1069.8 | 1069.83 | 0.664342 | 0.000789278 | 6.19583
COLUMN | +5.930 | Z/2635 | 5.9 | 1069.8 | 1069.83 | 0.664342 | 0.000789278 | 6.19583
COLUMN | +5.930 | Z/2511 | 5.9 | 1069.8 | 1069.83 | 0.664342 | 0.000789278 | 6.19583
COLUMN | +5.930 | Z/2634 | 5.9 | 1069.8 | 1069.83 | 0.664342 | 0.000789278 | 6.19583
COLUMN | +5.930 | Z/2510 | 5.9 | 1069.8 | 1069.83 | 0.664342 | 0.000789278 | 6.19583

# IfcColumn: C:200-24 (18)
In: Undefined
Description: C:200-24; Material: STEEL/G450
Tekla Common - Finish: 25 deg; Bottom elevation: +4.860; Top elevation: +5.976; Phase: 1; Class: 1
Tekla Quantity - Weight: 7.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 110.2 m2; Net surface area: 0.9 m2; Height: 203 mm; Width: 76 mm; Length: 1115.7 mm
BaseQuantities - Length: 1115.7 mm; OuterSurfaceArea: 0.87166 m2; NetVolume: 0.00103733 m3; NetWeight: 8.14307 kg
Pset_ColumnCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference
3 x COLUMN | Z/3038
3 x COLUMN | Z/2648
3 x COLUMN | Z/3037
3 x COLUMN | Z/2643
3 x COLUMN | Z/3036
3 x COLUMN | Z/2642

# IfcColumn: C:250-24 (18)
In: Undefined
Description: C:250-24; Material: STEEL/G450
Tekla Common - Finish: 25 deg; Bottom elevation: +4.860; Phase: 1; Class: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 109.8 m2; Net surface area: 0.9 m2; Height: 254 mm; Width: 76 mm
Pset_ColumnCommon - LoadBearing: no
Name | Top elevation | ASSEMBLY_POS = Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg) | Weight (kg) | Tekla Quantity, Length (mm)
2 x COLUMN | +5.975 | Z/3112 | 1115.52 | 0.983311 | 0.00117103 | 9.19258 | 8.8 | 1115.5
2 x COLUMN | +5.975 | Z/3041 | 1115.52 | 0.983311 | 0.00117103 | 9.19258 | 8.8 | 1115.5
2 x COLUMN | +5.975 | Z/3111 | 1115.52 | 0.983311 | 0.00117103 | 9.19258 | 8.8 | 1115.5
2 x COLUMN | +5.975 | Z/3040 | 1115.52 | 0.983311 | 0.00117103 | 9.19258 | 8.8 | 1115.5
2 x COLUMN | +5.975 | Z/3110 | 1115.52 | 0.983311 | 0.00117103 | 9.19258 | 8.8 | 1115.5
2 x COLUMN | +5.975 | Z/3039 | 1115.52 | 0.983311 | 0.00117103 | 9.19258 | 8.8 | 1115.5
COLUMN | +5.976 | Z/3112 | 1115.7 | 0.98347 | 0.00117122 | 9.19406 | 9 | 1115.7
COLUMN | +5.976 | Z/3041 | 1115.7 | 0.98347 | 0.00117122 | 9.19406 | 9 | 1115.7
COLUMN | +5.976 | Z/3111 | 1115.7 | 0.98347 | 0.00117122 | 9.19406 | 9 | 1115.7
COLUMN | +5.976 | Z/3040 | 1115.7 | 0.98347 | 0.00117122 | 9.19406 | 9 | 1115.7
COLUMN | +5.976 | Z/3110 | 1115.7 | 0.98347 | 0.00117122 | 9.19406 | 9 | 1115.7
COLUMN | +5.976 | Z/3039 | 1115.7 | 0.98347 | 0.00117122 | 9.19406 | 9 | 1115.7

# IfcColumn: C:300-30 (12)
In: Undefined
Description: C:300-30; Material: STEEL/G450
Tekla Common - Finish: 25 deg; Bottom elevation: +4.860; Phase: 1; Class: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.7 m2; Net surface area: 1.2 m2; Height: 300 mm; Width: 96 mm
Pset_ColumnCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Top elevation | Weight (kg) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x COLUMN | Z/3169 | +5.976 | 14 | 1116.4 | 1116.35 | 1.22231 | 0.00181853 | 14.2755
2 x COLUMN | Z/3118 | +5.976 | 14 | 1116.4 | 1116.35 | 1.22231 | 0.00181853 | 14.2755
COLUMN | Z/3171 | +5.952 | 13.7 | 1091.8 | 1091.81 | 1.19552 | 0.00177856 | 13.9617
COLUMN | Z/3120 | +5.952 | 13.7 | 1091.8 | 1091.81 | 1.19552 | 0.00177856 | 13.9617
COLUMN | Z/3170 | +5.930 | 13.4 | 1070.3 | 1070.34 | 1.17207 | 0.00174358 | 13.6871
COLUMN | Z/3119 | +5.930 | 13.4 | 1070.3 | 1070.34 | 1.17207 | 0.00174358 | 13.6871
COLUMN | Z/3168 | +5.976 | 14 | 1116.4 | 1116.35 | 1.22231 | 0.00181853 | 14.2755
COLUMN | Z/3117 | +5.976 | 14 | 1116.4 | 1116.35 | 1.22231 | 0.00181853 | 14.2755
COLUMN | Z/3167 | +5.976 | 14 | 1116.4 | 1116.35 | 1.22231 | 0.00181853 | 14.2755
COLUMN | Z/3116 | +5.976 | 14 | 1116.4 | 1116.35 | 1.22231 | 0.00181853 | 14.2755

# IfcColumn: C:350-30 (6)
In: Undefined
Description: C:350-30; Material: STEEL/G450
Tekla Common - Finish: 25 deg; Bottom elevation: +4.860; Top elevation: +5.975; Phase: 1; Class: 1
Tekla Quantity - Weight: 16.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.4 m2; Net surface area: 1.5 m2; Height: 350 mm; Width: 125 mm; Length: 1115.1 mm
BaseQuantities - Length: 1115.07 mm; OuterSurfaceArea: 1.45571 m2; NetVolume: 0.0021677 m3; NetWeight: 17.0164 kg
Pset_ColumnCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference
COLUMN | Z/3636
COLUMN | Z/3615
COLUMN | Z/3635
COLUMN | Z/3614
COLUMN | Z/3634
COLUMN | Z/3613

# IfcDiscreteAccessory: BRIDGING BRACKET (132)
In: Undefined
Description: PLT6*145; Material: STEEL/250
Tekla Common - Phase: 1; Class: 9
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.1 m2; Height: 145 mm; Width: 6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000036 m2
Name | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Length (mm) | Reference | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
20 x BRIDGING BRACKET | +5.640 | +5.960 | 2.2 | 45 | 320 | z/2765 | 0.09838 | 0.0464 | 0.0002784
4 x BRIDGING BRACKET | +5.641 | +5.961 | 2.2 | 45 | 320 | z/2765 | 0.09838 | 0.0464 | 0.0002784
4 x BRIDGING BRACKET | +5.625 | +5.945 | 2.2 | 45 | 320 | z/2765 | 0.09838 | 0.0464 | 0.0002784
4 x BRIDGING BRACKET | +5.617 | +5.937 | 2.2 | 45 | 320 | z/2765 | 0.09838 | 0.0464 | 0.0002784
4 x BRIDGING BRACKET | +5.595 | +5.915 | 2.2 | 45 | 320 | z/2765 | 0.09838 | 0.0464 | 0.0002784
4 x BRIDGING BRACKET | +5.666 | +5.936 | 1.8 | 45.2 | 270 | z/2689 | 0.08328 | 0.03915 | 0.0002349
12 x BRIDGING BRACKET | +5.690 | +5.960 | 1.8 | 45.2 | 270 | z/2689 | 0.08328 | 0.03915 | 0.0002349
16 x BRIDGING BRACKET | +5.691 | +5.961 | 1.8 | 45.2 | 270 | z/2689 | 0.08328 | 0.03915 | 0.0002349
4 x BRIDGING BRACKET | +5.686 | +5.956 | 1.8 | 45.2 | 270 | z/2689 | 0.08328 | 0.03915 | 0.0002349
4 x BRIDGING BRACKET | +5.704 | +5.924 | 1.5 | 45.4 | 220 | z/2652 | 0.06818 | 0.0319 | 0.0001914
4 x BRIDGING BRACKET | +5.729 | +5.949 | 1.5 | 45.4 | 220 | z/2652 | 0.06818 | 0.0319 | 0.0001914
16 x BRIDGING BRACKET | +5.739 | +5.959 | 1.5 | 45.4 | 220 | z/2652 | 0.06818 | 0.0319 | 0.0001914
4 x BRIDGING BRACKET | +5.719 | +5.939 | 1.5 | 45.4 | 220 | z/2652 | 0.06818 | 0.0319 | 0.0001914
4 x BRIDGING BRACKET | +5.714 | +5.934 | 1.5 | 45.4 | 220 | z/2652 | 0.06818 | 0.0319 | 0.0001914
4 x BRIDGING BRACKET | +5.693 | +5.913 | 1.5 | 45.4 | 220 | z/2652 | 0.06818 | 0.0319 | 0.0001914
4 x BRIDGING BRACKET | +5.739 | +5.909 | 1.2 | 45.7 | 170 | z/2621 | 0.05308 | 0.02465 | 0.0001479
4 x BRIDGING BRACKET | +5.733 | +5.903 | 1.2 | 45.7 | 170 | z/2621 | 0.05308 | 0.02465 | 0.0001479
4 x BRIDGING BRACKET | +5.759 | +5.929 | 1.2 | 45.7 | 170 | z/2621 | 0.05308 | 0.02465 | 0.0001479
8 x BRIDGING BRACKET | +5.743 | +5.913 | 1.2 | 45.7 | 170 | z/2621 | 0.05308 | 0.02465 | 0.0001479
4 x BRIDGING BRACKET | +5.779 | +5.949 | 1.2 | 45.7 | 170 | z/2621 | 0.05308 | 0.02465 | 0.0001479

# IfcDiscreteAccessory: FASCIA STIFFENER (66)
In: Undefined
Description: PLT3*120; Material: STEEL/250
Tekla Common - Phase: 1; Class: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.1 m2; Height: 120 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.00036 m2
Name | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Length (mm) | Reference | NetArea (m2) = GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
6 x FASCIA STIFFENER | +5.623 | +5.973 | 1 | 87.8 | 350 | Z/243 | 0.08682 | 0.000126
2 x FASCIA STIFFENER | +5.626 | +5.976 | 1 | 87.8 | 350 | Z/243 | 0.08682 | 0.000126
6 x FASCIA STIFFENER | +5.625 | +5.975 | 1 | 87.8 | 350 | Z/243 | 0.08682 | 0.000126
2 x FASCIA STIFFENER | +5.602 | +5.952 | 1 | 87.8 | 350 | Z/243 | 0.08682 | 0.000126
2 x FASCIA STIFFENER | +5.580 | +5.930 | 1 | 87.8 | 350 | Z/243 | 0.08682 | 0.000126
2 x FASCIA STIFFENER | +5.651 | +5.951 | 0.8 | 87.8 | 300 | Z/237 | 0.07452 | 0.000108
6 x FASCIA STIFFENER | +5.675 | +5.975 | 0.8 | 87.8 | 300 | Z/237 | 0.07452 | 0.000108
8 x FASCIA STIFFENER | +5.676 | +5.976 | 0.8 | 87.8 | 300 | Z/237 | 0.07452 | 0.000108
2 x FASCIA STIFFENER | +5.671 | +5.971 | 0.8 | 87.8 | 300 | Z/237 | 0.07452 | 0.000108
2 x FASCIA STIFFENER | +5.687 | +5.941 | 0.6 | 88.1 | 254 | Z/223 | 0.063204 | 0.00009144
2 x FASCIA STIFFENER | +5.712 | +5.966 | 0.6 | 88.1 | 254 | Z/223 | 0.063204 | 0.00009144
8 x FASCIA STIFFENER | +5.722 | +5.976 | 0.6 | 88.1 | 254 | Z/223 | 0.063204 | 0.00009144
2 x FASCIA STIFFENER | +5.702 | +5.956 | 0.6 | 88.1 | 254 | Z/223 | 0.063204 | 0.00009144
2 x FASCIA STIFFENER | +5.697 | +5.951 | 0.6 | 88.1 | 254 | Z/223 | 0.063204 | 0.00009144
2 x FASCIA STIFFENER | +5.676 | +5.930 | 0.6 | 88.1 | 254 | Z/223 | 0.063204 | 0.00009144
2 x FASCIA STIFFENER | +5.723 | +5.926 | 0.6 | 88.3 | 203 | Z/367 | 0.050658 | 0.00007308
2 x FASCIA STIFFENER | +5.717 | +5.920 | 0.6 | 88.3 | 203 | Z/367 | 0.050658 | 0.00007308
2 x FASCIA STIFFENER | +5.743 | +5.946 | 0.6 | 88.3 | 203 | Z/367 | 0.050658 | 0.00007308
4 x FASCIA STIFFENER | +5.727 | +5.930 | 0.6 | 88.3 | 203 | Z/367 | 0.050658 | 0.00007308
2 x FASCIA STIFFENER | +5.763 | +5.966 | 0.6 | 88.3 | 203 | Z/367 | 0.050658 | 0.00007308

# IfcElementAssembly (1320)
In: Undefined
PredefinedType: RIGID_FRAME
Name | ASSEMBLY_POS = Assembly/Cast unit Mark | Assembly/Cast unit weight (kg) | Assembly/Cast unit bottom elevation | Assembly/Cast unit top elevation | Width (mm) | ASSEMBLY_POSITION_CODE = Assembly/Cast unit position code
BRIDGING U-PLATE | Z/3149 | 4.4 | +5.622 | +5.980 | 129
BEAM | Z/3155 | 28.2 | +5.626 | +5.976 | 125
COLUMN | Z/3615 | 16.7 | +4.860 | +5.975 | 125
COLUMN | Z/3118 | 14 | +4.860 | +5.976 | 96
COLUMN | Z/3041 | 8.9 | +4.860 | +5.975 | 76
BEAM | Z/3084 | 28.5 | +5.625 | +5.975 | 125
BEAM | Z/3626 | 27.7 | +5.610 | +5.960 | 125
BRIDGING U-PLATE | Z/3625 | 4.4 | +5.606 | +5.964 | 358
RAFTER | Z/2606 | 10.8 | +5.612 | +6.105 | 125
RAFTER | Z/2599 | 8.9 | +5.652 | +6.094 | 96
BRIDGING U-PLATE | Z/3069 | 4.4 | +5.621 | +5.979 | 129
RAFTER | Z/2591 | 5.9 | +5.686 | +6.086 | 76
2 x RAFTER | Z/431 | 10.8 | +5.612 | +6.105 | 125
3 x FASCIA BRACKET | Z/2531 | 0.3 | +5.820 | +5.977 | 157.2
FASCIA STIFFENER | Z/243 | 1 | +5.623 | +5.973 | 3
COLUMN | Z/3636 | 16.7 | +4.860 | +5.975 | 125
2 x RAFTER | Z/430 | 8.9 | +5.652 | +6.094 | 96
3 x FASCIA BRACKET | Z/2531 | 0.3 | +5.821 | +5.979 | 157.2
FASCIA STIFFENER | Z/243 | 1 | +5.626 | +5.976 | 3
COLUMN | Z/3169 | 14 | +4.860 | +5.976 | 96
2 x RAFTER | Z/289 | 5.9 | +5.686 | +6.086 | 76
3 x FASCIA BRACKET | Z/2531 | 0.3 | +5.821 | +5.978 | 157.2
COLUMN | Z/3112 | 8.9 | +4.860 | +5.975 | 76
FASCIA STIFFENER | Z/243 | 1 | +5.625 | +5.975 | 3
PLATE | Z/3109 | 7.4 | +5.571 | +5.998 | 224
BRIDGING-COLUMN STIFF | Z/3054 | 5.2 | +5.626 | +5.976 | 209.2
PLATE | Z/3166 | 11 | +5.457 | +6.032 | 244
BRIDGING-COLUMN STIFF | Z/3144 | 5.9 | +5.626 | +5.976 | 228
PLATE | Z/3633 | 12.3 | +5.455 | +6.042 | 273
BRIDGING-COLUMN STIFF | Z/3622 | 6.7 | +5.625 | +5.975 | 257
BB TRUSS BRACKET | Z/3624 | 5.4 | +5.610 | +6.032 | 147.699
BB TRUSS BRACKET | Z/3623 | 5.4 | +5.610 | +6.032 | 147.699
BB TRUSS BRACKET | Z/3146 | 4.3 | +5.637 | +6.023 | 527.132
BB TRUSS BRACKET | Z/3145 | 4.3 | +5.637 | +6.023 | 147.699
BB TRUSS BRACKET | Z/3059 | 2.6 | +5.686 | +5.986 | 358.65
BB TRUSS BRACKET | Z/3060 | 2.6 | +5.686 | +5.986 | 358.65
TH | Z/403 | 2.9 | +5.278 | +5.443 | 165
PLATE | Z/666 | 10.1 | +5.455 | +6.042 | 128
TH | Z/403 | 2.9 | +6.088 | +6.227 | 165
FASCIA | Z/426 | 8.9 | +5.823 | +5.975 | 64
BEAM | Z/3627 | 27.7 | +5.610 | +5.960 | 125
TH | Z/423 | 2.9 | +5.313 | +5.478 | 165
PLATE | Z/1542 | 8.9 | +5.457 | +6.032 | 99
TH | Z/423 | 2.9 | +6.077 | +6.216 | 165
FASCIA | Z/420 | 9.4 | +5.824 | +5.976 | 64
BEAM | Z/3156 | 28.2 | +5.626 | +5.976 | 125
TH | Z/406 | 2.9 | +5.421 | +5.586 | 165
PLATE | Z/1287 | 5.2 | +5.571 | +5.998 | 79
FASCIA | Z/409 | 8.1 | +5.823 | +5.975 | 64
TH | Z/406 | 2.9 | +6.069 | +6.208 | 165
BEAM | Z/3085 | 28.5 | +5.625 | +5.975 | 125
BRIDGING U-PLATE | Z/3150 | 4.4 | +5.598 | +5.956 | 129 | C300-C300/BB350(TH96)-BB350(TH120)
BEAM | Z/3155 | 28.2 | +5.602 | +5.952 | 125 | C300-C300/BB350(TH96)-BB350(TH120)
COLUMN | Z/3614 | 16.7 | +4.860 | +5.975 | 125 | C350/BB350(TH96)-BB350(TH120)
COLUMN | Z/3120 | 13.7 | +4.860 | +5.952 | 96 | C300/BB350(TH96)-BB350(TH120)
COLUMN | Z/3040 | 8.9 | +4.860 | +5.975 | 76 | C250/BB350(TH96)-BB350(TH120)
BEAM | Z/3084 | 28.5 | +5.625 | +5.975 | 125 | C250-C250/BB350(TH96)-BB350(TH120)
BEAM | Z/3626 | 27.7 | +5.625 | +5.975 | 125 | C350-C350/BB350(TH96)-BB350(TH120)
BRIDGING U-PLATE | Z/3150 | 4.4 | +5.621 | +5.979 | 358 | C350-C350/BB350(TH96)-BB350(TH120)
2 x RAFTER | Z/2606 | 10.8 | +5.631 | +6.125 | 125 | C350-C350/BB350(TH96)-BB350(TH120)
2 x RAFTER | Z/2599 | 8.9 | +5.646 | +6.089 | 96 | C300-C300/BB350(TH96)-BB350(TH120)
BRIDGING U-PLATE | Z/3068 | 4.4 | +5.621 | +5.979 | 129 | C250-C250/BB350(TH96)-BB350(TH120)
2 x RAFTER | Z/2591 | 5.9 | +5.705 | +6.106 | 76 | C250-C250/BB350(TH96)-BB350(TH120)
4 x RAFTER | Z/431 | 10.8 | +5.631 | +6.125 | 125 | C350/BB350(TH96)-BB350(TH120)
2 x FASCIA BRACKET | Z/2520 | 0.3 | +5.820 | +5.977 | 157.2 | C350/BB350(TH96)-BB350(TH120)
FASCIA BRACKET | Z/2520 | 0.3 | +5.820 | +5.977 | 157.2 | C350-C350/BB350(TH96)-BB350(TH120)
FASCIA STIFFENER | Z/243 | 1 | +5.623 | +5.973 | 3 | C350-C350/BB350(TH96)-BB350(TH120)
COLUMN | Z/3635 | 16.7 | +4.860 | +5.975 | 125 | C350/BB350(TH96)-BB350(TH120)
4 x RAFTER | Z/430 | 8.9 | +5.646 | +6.089 | 96 | C300/BB350(TH96)-BB350(TH120)
2 x FASCIA BRACKET | Z/2520 | 0.3 | +5.797 | +5.954 | 157.2 | C300/BB350(TH96)-BB350(TH120)
FASCIA BRACKET | Z/2520 | 0.3 | +5.797 | +5.954 | 157.2 | C300-C300/BB350(TH96)-BB350(TH120)
FASCIA STIFFENER | Z/243 | 1 | +5.602 | +5.952 | 3 | C300-C300/BB350(TH96)-BB350(TH120)
COLUMN | Z/3171 | 13.7 | +4.860 | +5.952 | 96 | C300/BB350(TH96)-BB350(TH120)
4 x RAFTER | Z/289 | 5.9 | +5.705 | +6.106 | 76 | C250/BB350(TH96)-BB350(TH120)
2 x FASCIA BRACKET | Z/2520 | 0.3 | +5.821 | +5.978 | 157.2 | C250/BB350(TH96)-BB350(TH120)
FASCIA BRACKET | Z/2520 | 0.3 | +5.821 | +5.978 | 157.2 | C250-C250/BB350(TH96)-BB350(TH120)
COLUMN | Z/3111 | 8.9 | +4.860 | +5.975 | 76 | C250/BB350(TH96)-BB350(TH120)
FASCIA STIFFENER | Z/243 | 1 | +5.625 | +5.975 | 3 | C250-C250/BB350(TH96)-BB350(TH120)
PLATE | Z/3107 | 7.4 | +5.590 | +6.017 | 224 | C250/BB350(TH96)-BB350(TH120)
BRIDGING-COLUMN STIFF | Z/3054 | 5.2 | +5.626 | +5.976 | 209.2 | C250/BB350(TH96)-BB350(TH120)
PLATE | Z/3164 | 11 | +5.451 | +6.027 | 244 | C300/BB350(TH96)-BB350(TH120)
BRIDGING-COLUMN STIFF | Z/3144 | 5.9 | +5.602 | +5.952 | 228 | C300/BB350(TH96)-BB350(TH120)
PLATE | Z/3631 | 12.3 | +5.475 | +6.061 | 273 | C350/BB350(TH96)-BB350(TH120)
BRIDGING-COLUMN STIFF | Z/3620 | 6.7 | +5.625 | +5.975 | 257 | C350/BB350(TH96)-BB350(TH120)
2 x BB TRUSS BRACKET | Z/3624 | 5.4 | +5.629 | +6.051 | 147.699 | C350-C350/BB350(TH96)-BB350(TH120)
2 x BB TRUSS BRACKET | Z/3623 | 5.4 | +5.629 | +6.051 | 147.699 | C350-C350/BB350(TH96)-BB350(TH120)
BB TRUSS BRACKET | Z/3146 | 4.3 | +5.632 | +6.017 | 527.132 | C300-C300/BB350(TH96)-BB350(TH120)
BB TRUSS BRACKET | Z/3145 | 4.3 | +5.632 | +6.017 | 147.699 | C300-C300/BB350(TH96)-BB350(TH120)
BB TRUSS BRACKET | Z/3059 | 2.6 | +5.705 | +6.006 | 358.65 | C250-C250/BB350(TH96)-BB350(TH120)
BB TRUSS BRACKET | Z/3060 | 2.6 | +5.705 | +6.006 | 358.65 | C250-C250/BB350(TH96)-BB350(TH120)
TH | Z/402 | 2.9 | +5.286 | +5.436 | 150 | C350-C350/BB350(TH96)-BB350(TH120)
PLATE | Z/666 | 10.1 | +5.475 | +6.061 | 128 | C350/BB350(TH96)-BB350(TH120)
2 x TH | Z/402 | 2.9 | +6.109 | +6.223 | 150 | C350-C350/BB350(TH96)-BB350(TH120)
FASCIA | Z/426 | 8.9 | +5.823 | +5.975 | 64 | C350-C350/BB350(TH96)-BB350(TH120)
BEAM | Z/3627 | 27.7 | +5.625 | +5.975 | 125 | C350-C350/BB350(TH96)-BB350(TH120)
TH | Z/422 | 2.9 | +5.321 | +5.471 | 150 | C300-C300/BB350(TH96)-BB350(TH120)
PLATE | Z/1542 | 8.9 | +5.451 | +6.027 | 99 | C300/BB350(TH96)-BB350(TH120)
2 x TH | Z/422 | 2.9 | +6.073 | +6.187 | 150 | C300-C300/BB350(TH96)-BB350(TH120)
FASCIA | Z/420 | 9.4 | +5.800 | +5.952 | 64 | C300-C300/BB350(TH96)-BB350(TH120)
BEAM | Z/3156 | 28.2 | +5.602 | +5.952 | 125 | C300-C300/BB350(TH96)-BB350(TH120)
TH | Z/405 | 2.9 | +5.428 | +5.578 | 150 | C250-C250/BB350(TH96)-BB350(TH120)
PLATE | Z/1287 | 5.2 | +5.590 | +6.017 | 79 | C250/BB350(TH96)-BB350(TH120)
FASCIA | Z/409 | 8.1 | +5.823 | +5.975 | 64 | C250-C250/BB350(TH96)-BB350(TH120)
2 x TH | Z/405 | 2.9 | +6.090 | +6.204 | 150 | C250-C250/BB350(TH96)-BB350(TH120)
BEAM | Z/3085 | 28.5 | +5.625 | +5.975 | 125 | C250-C250/BB350(TH96)-BB350(TH120)
BRIDGING U-PLATE | Z/3149 | 4.4 | +5.576 | +5.934 | 129 | C300-C300/BB350(TH75)-BB350(TH96)
BEAM | Z/3155 | 28.2 | +5.580 | +5.930 | 125 | C300-C300/BB350(TH75)-BB350(TH96)
COLUMN | Z/3613 | 16.7 | +4.860 | +5.975 | 125 | C350/BB350(TH75)-BB350(TH96)
COLUMN | Z/3119 | 13.4 | +4.860 | +5.930 | 96 | C300/BB350(TH75)-BB350(TH96)
COLUMN | Z/3039 | 8.9 | +4.860 | +5.975 | 76 | C250/BB350(TH75)-BB350(TH96)
BEAM | Z/3084 | 28.5 | +5.625 | +5.975 | 125 | C250-C250/BB350(TH75)-BB350(TH96)
BEAM | Z/3626 | 27.7 | +5.625 | +5.975 | 125 | C350-C350/BB350(TH75)-BB350(TH96)
BRIDGING U-PLATE | Z/3149 | 4.4 | +5.621 | +5.979 | 358 | C350-C350/BB350(TH75)-BB350(TH96)
2 x RAFTER | Z/2599 | 8.9 | +5.642 | +6.084 | 96 | C300-C300/BB350(TH75)-BB350(TH96)
BRIDGING U-PLATE | Z/3067 | 4.4 | +5.621 | +5.979 | 129 | C250-C250/BB350(TH75)-BB350(TH96)
2 x RAFTER | Z/2591 | 5.9 | +5.722 | +6.123 | 76 | C250-C250/BB350(TH75)-BB350(TH96)
4 x RAFTER | Z/431 | 10.8 | +5.648 | +6.142 | 125 | C350/BB350(TH75)-BB350(TH96)
2 x RAFTER | Z/2606 | 10.8 | +5.648 | +6.142 | 125 | C350-C350/BB350(TH75)-BB350(TH96)
2 x FASCIA BRACKET | Z/52 | 0.2 | +5.820 | +5.977 | 157.2 | C350/BB350(TH75)-BB350(TH96)
FASCIA BRACKET | Z/52 | 0.2 | +5.820 | +5.977 | 157.2 | C350-C350/BB350(TH75)-BB350(TH96)
FASCIA STIFFENER | Z/243 | 1 | +5.623 | +5.973 | 3 | C350-C350/BB350(TH75)-BB350(TH96)
COLUMN | Z/3634 | 16.7 | +4.860 | +5.975 | 125 | C350/BB350(TH75)-BB350(TH96)
4 x RAFTER | Z/430 | 8.9 | +5.642 | +6.084 | 96 | C300/BB350(TH75)-BB350(TH96)
2 x FASCIA BRACKET | Z/52 | 0.2 | +5.775 | +5.933 | 157.2 | C300/BB350(TH75)-BB350(TH96)
FASCIA BRACKET | Z/52 | 0.2 | +5.775 | +5.933 | 157.2 | C300-C300/BB350(TH75)-BB350(TH96)
FASCIA STIFFENER | Z/243 | 1 | +5.580 | +5.930 | 3 | C300-C300/BB350(TH75)-BB350(TH96)
COLUMN | Z/3170 | 13.4 | +4.860 | +5.930 | 96 | C300/BB350(TH75)-BB350(TH96)
4 x RAFTER | Z/289 | 5.9 | +5.722 | +6.123 | 76 | C250/BB350(TH75)-BB350(TH96)
2 x FASCIA BRACKET | Z/52 | 0.2 | +5.821 | +5.978 | 157.2 | C250/BB350(TH75)-BB350(TH96)
FASCIA BRACKET | Z/52 | 0.2 | +5.821 | +5.978 | 157.2 | C250-C250/BB350(TH75)-BB350(TH96)
COLUMN | Z/3110 | 8.9 | +4.860 | +5.975 | 76 | C250/BB350(TH75)-BB350(TH96)
FASCIA STIFFENER | Z/243 | 1 | +5.625 | +5.975 | 3 | C250-C250/BB350(TH75)-BB350(TH96)
PLATE | Z/3105 | 7.4 | +5.607 | +6.034 | 224 | C250/BB350(TH75)-BB350(TH96)
BRIDGING-COLUMN STIFF | Z/3054 | 5.2 | +5.626 | +5.976 | 209.2 | C250/BB350(TH75)-BB350(TH96)
PLATE | Z/3162 | 11 | +5.447 | +6.023 | 244 | C300/BB350(TH75)-BB350(TH96)
BRIDGING-COLUMN STIFF | Z/3144 | 5.9 | +5.580 | +5.930 | 228 | C300/BB350(TH75)-BB350(TH96)
PLATE | Z/3629 | 12.3 | +5.492 | +6.078 | 273 | C350/BB350(TH75)-BB350(TH96)
BRIDGING-COLUMN STIFF | Z/3620 | 6.7 | +5.625 | +5.975 | 257 | C350/BB350(TH75)-BB350(TH96)
BB TRUSS BRACKET | Z/3146 | 4.3 | +5.628 | +6.013 | 527.132 | C300-C300/BB350(TH75)-BB350(TH96)
BB TRUSS BRACKET | Z/3059 | 2.6 | +5.722 | +6.023 | 358.65 | C250-C250/BB350(TH75)-BB350(TH96)
BB TRUSS BRACKET | Z/3060 | 2.6 | +5.722 | +6.023 | 358.65 | C250-C250/BB350(TH75)-BB350(TH96)
TH | Z/401 | 2.9 | +5.298 | +5.423 | 125 | C350-C350/BB350(TH75)-BB350(TH96)
PLATE | Z/666 | 10.1 | +5.492 | +6.078 | 128 | C350/BB350(TH75)-BB350(TH96)
2 x BB TRUSS BRACKET | Z/3624 | 5.4 | +5.646 | +6.068 | 147.699 | C350-C350/BB350(TH75)-BB350(TH96)
2 x BB TRUSS BRACKET | Z/3623 | 5.4 | +5.646 | +6.068 | 147.699 | C350-C350/BB350(TH75)-BB350(TH96)
2 x TH | Z/401 | 2.9 | +6.129 | +6.219 | 125 | C350-C350/BB350(TH75)-BB350(TH96)
FASCIA | Z/426 | 8.9 | +5.823 | +5.975 | 64 | C350-C350/BB350(TH75)-BB350(TH96)
BEAM | Z/3627 | 27.7 | +5.625 | +5.975 | 125 | C350-C350/BB350(TH75)-BB350(TH96)
TH | Z/421 | 2.9 | +5.333 | +5.458 | 125 | C300-C300/BB350(TH75)-BB350(TH96)
PLATE | Z/1542 | 8.9 | +5.447 | +6.023 | 99 | C300/BB350(TH75)-BB350(TH96)
BB TRUSS BRACKET | Z/3145 | 4.3 | +5.628 | +6.013 | 147.699 | C300-C300/BB350(TH75)-BB350(TH96)
2 x TH | Z/421 | 2.9 | +6.071 | +6.161 | 125 | C300-C300/BB350(TH75)-BB350(TH96)
FASCIA | Z/420 | 9.4 | +5.778 | +5.930 | 64 | C300-C300/BB350(TH75)-BB350(TH96)
BEAM | Z/3156 | 28.2 | +5.580 | +5.930 | 125 | C300-C300/BB350(TH75)-BB350(TH96)
TH | Z/404 | 2.9 | +5.441 | +5.566 | 125 | C250-C250/BB350(TH75)-BB350(TH96)
PLATE | Z/1287 | 5.2 | +5.607 | +6.034 | 79 | C250/BB350(TH75)-BB350(TH96)
2 x TH | Z/404 | 2.9 | +6.110 | +6.200 | 125 | C250-C250/BB350(TH75)-BB350(TH96)
FASCIA | Z/409 | 8.1 | +5.823 | +5.975 | 64 | C250-C250/BB350(TH75)-BB350(TH96)
BEAM | Z/3085 | 28.5 | +5.625 | +5.975 | 125 | C250-C250/BB350(TH75)-BB350(TH96)
BRIDGING U-PLATE | Z/3152 | 3.6 | +5.647 | +5.955 | 100 | C300-C300/BB300(TH120)-BB350(TH75)
BEAM | Z/3153 | 23.6 | +5.651 | +5.951 | 96 | C300-C300/BB300(TH120)-BB350(TH75)
COLUMN | Z/3118 | 14 | +4.860 | +5.976 | 96 | C300/BB300(TH120)-BB350(TH75)
COLUMN | Z/3041 | 8.9 | +4.860 | +5.975 | 76 | C250/BB300(TH120)-BB350(TH75)
COLUMN | Z/2648 | 7.9 | +4.860 | +5.976 | 76 | C200/BB300(TH120)-BB350(TH75)
BEAM | Z/3082 | 19 | +5.675 | +5.975 | 96 | C250-C250/BB300(TH120)-BB350(TH75)
BRIDGING BEAM | Z/3006 | 19 | +5.676 | +5.976 | 96 | C200-C200/BB300(TH120)-BB350(TH75)
2 x FASCIA BRACKET | Z/2556 | 0.6 | +5.819 | +5.980 | 161 | C200/BB300(TH120)-BB350(TH75)
FASCIA BRACKET | Z/2556 | 0.6 | +5.819 | +5.980 | 161 | C200-C200/BB300(TH120)-BB350(TH75)
2 x RAFTER | Z/2599 | 8.9 | +5.652 | +6.094 | 96 | C300-C300/BB300(TH120)-BB350(TH75)
BRIDGING U-PLATE | Z/3066 | 3.6 | +5.671 | +5.979 | 100 | C250-C250/BB300(TH120)-BB350(TH75)
2 x RAFTER | Z/2591 | 5.9 | +5.686 | +6.086 | 76 | C250-C250/BB300(TH120)-BB350(TH75)
BRIDGING U-PLATE | Z/2979 | 3.6 | +5.672 | +5.980 | 308 | C200-C200/BB300(TH120)-BB350(TH75)
2 x RAFTER | Z/2998 | 3.9 | +5.725 | +6.038 | 76 | C200-C200/BB300(TH120)-BB350(TH75)
FASCIA STIFFENER | Z/237 | 0.8 | +5.651 | +5.951 | 3 | C300-C300/BB300(TH120)-BB350(TH75)
4 x RAFTER | Z/430 | 8.9 | +5.652 | +6.094 | 96 | C300/BB300(TH120)-BB350(TH75)
2 x FASCIA BRACKET | Z/2531 | 0.3 | +5.821 | +5.979 | 157.2 | C300/BB300(TH120)-BB350(TH75)
FASCIA BRACKET | Z/2531 | 0.3 | +5.821 | +5.979 | 157.2 | C300-C300/BB300(TH120)-BB350(TH75)
COLUMN | Z/3169 | 14 | +4.860 | +5.976 | 96 | C300/BB300(TH120)-BB350(TH75)
4 x RAFTER | Z/289 | 5.9 | +5.686 | +6.086 | 76 | C250/BB300(TH120)-BB350(TH75)
2 x FASCIA BRACKET | Z/2531 | 0.3 | +5.821 | +5.978 | 157.2 | C250/BB300(TH120)-BB350(TH75)
FASCIA BRACKET | Z/2531 | 0.3 | +5.821 | +5.978 | 157.2 | C250-C250/BB300(TH120)-BB350(TH75)
COLUMN | Z/3112 | 8.9 | +4.860 | +5.975 | 76 | C250/BB300(TH120)-BB350(TH75)
FASCIA STIFFENER | Z/237 | 0.8 | +5.675 | +5.975 | 3 | C250-C250/BB300(TH120)-BB350(TH75)
4 x RAFTER | Z/247 | 3.9 | +5.725 | +6.038 | 76 | C200/BB300(TH120)-BB350(TH75)
COLUMN | Z/3038 | 7.9 | +4.860 | +5.976 | 76 | C200/BB300(TH120)-BB350(TH75)
FASCIA STIFFENER | Z/237 | 0.8 | +5.676 | +5.976 | 3 | C200-C200/BB300(TH120)-BB350(TH75)
PLATE | Z/3160 | 10.6 | +5.457 | +6.032 | 244 | C300/BB300(TH120)-BB350(TH75)
BRIDGING-COLUMN STIFF | Z/3142 | 5.4 | +5.626 | +5.976 | 228 | C300/BB300(TH120)-BB350(TH75)
PLATE | Z/3101 | 7.1 | +5.571 | +5.998 | 224 | C250/BB300(TH120)-BB350(TH75)
BRIDGING-COLUMN STIFF | Z/3052 | 4.8 | +5.626 | +5.976 | 209.2 | C250/BB300(TH120)-BB350(TH75)
PLATE | Z/3023 | 4.8 | +5.656 | +5.970 | 224 | C200/BB300(TH120)-BB350(TH75)
BRIDGING-COLUMN STIFF | Z/2966 | 4.4 | +5.626 | +5.976 | 209.2 | C200/BB300(TH120)-BB350(TH75)
2 x BB TRUSS BRACKET | Z/3148 | 4.6 | +5.651 | +6.023 | 147.699 | C300-C300/BB300(TH120)-BB350(TH75)
2 x BB TRUSS BRACKET | Z/3147 | 4.6 | +5.651 | +6.023 | 147.699 | C300-C300/BB300(TH120)-BB350(TH75)
BB TRUSS BRACKET | Z/3058 | 2.9 | +5.673 | +5.986 | 147.999 | C250-C250/BB300(TH120)-BB350(TH75)
BB TRUSS BRACKET | Z/3057 | 2.9 | +5.673 | +5.986 | 147.999 | C250-C250/BB300(TH120)-BB350(TH75)
BB TRUSS BRACKET | Z/2971 | 1.7 | +5.725 | +5.958 | 147.999 | C200-C200/BB300(TH120)-BB350(TH75)
BB TRUSS BRACKET | Z/2970 | 1.7 | +5.725 | +5.958 | 147.999 | C200-C200/BB300(TH120)-BB350(TH75)
TH | Z/423 | 2.9 | +5.313 | +5.478 | 165 | C300-C300/BB300(TH120)-BB350(TH75)
BEAM | Z/3154 | 23.6 | +5.651 | +5.951 | 96 | C300-C300/BB300(TH120)-BB350(TH75)
PLATE | Z/1542 | 8.9 | +5.457 | +6.032 | 99 | C300/BB300(TH120)-BB350(TH75)
2 x TH | Z/423 | 2.9 | +6.064 | +6.204 | 165 | C300-C300/BB300(TH120)-BB350(TH75)
FASCIA | Z/420 | 9.4 | +5.824 | +5.976 | 64 | C300-C300/BB300(TH120)-BB350(TH75)
TH | Z/406 | 2.9 | +5.421 | +5.586 | 165 | C250-C250/BB300(TH120)-BB350(TH75)
PLATE | Z/1287 | 5.2 | +5.571 | +5.998 | 79 | C250/BB300(TH120)-BB350(TH75)
2 x TH | Z/406 | 2.9 | +6.069 | +6.208 | 165 | C250-C250/BB300(TH120)-BB350(TH75)
FASCIA | Z/409 | 8.1 | +5.823 | +5.975 | 64 | C250-C250/BB300(TH120)-BB350(TH75)
BEAM | Z/3083 | 19 | +5.675 | +5.975 | 96 | C250-C250/BB300(TH120)-BB350(TH75)
GIRT | Z/3002 | 4.6 | +5.388 | +5.553 | 165 | C200-C200/BB300(TH120)-BB350(TH75)
PLATE | Z/548 | 3.1 | +5.656 | +5.970 | 79 | C200/BB300(TH120)-BB350(TH75)
2 x PURLIN | Z/3003 | 4.6 | +6.021 | +6.160 | 165 | C200-C200/BB300(TH120)-BB350(TH75)
FASCIA | Z/426 | 8.9 | +5.824 | +5.976 | 64 | C200-C200/BB300(TH120)-BB350(TH75)
BRIDGING BEAM | Z/3007 | 19 | +5.676 | +5.976 | 96 | C200-C200/BB300(TH120)-BB350(TH75)
BRIDGING U-PLATE | Z/3151 | 3.6 | +5.667 | +5.975 | 100 | C300-C300/BB300(TH96)-BB300(TH120)
BEAM | Z/3153 | 23.6 | +5.671 | +5.971 | 96 | C300-C300/BB300(TH96)-BB300(TH120)
COLUMN | Z/3117 | 14 | +4.860 | +5.976 | 96 | C300/BB300(TH96)-BB300(TH120)
COLUMN | Z/3040 | 8.9 | +4.860 | +5.975 | 76 | C250/BB300(TH96)-BB300(TH120)
COLUMN | Z/2643 | 7.9 | +4.860 | +5.976 | 76 | C200/BB300(TH96)-BB300(TH120)
BEAM | Z/3082 | 19 | +5.675 | +5.975 | 96 | C250-C250/BB300(TH96)-BB300(TH120)
BRIDGING BEAM | Z/3006 | 19 | +5.676 | +5.976 | 96 | C200-C200/BB300(TH96)-BB300(TH120)
2 x FASCIA BRACKET | Z/2554 | 0.5 | +5.819 | +5.980 | 161 | C200/BB300(TH96)-BB300(TH120)
FASCIA BRACKET | Z/2554 | 0.5 | +5.819 | +5.980 | 161 | C200-C200/BB300(TH96)-BB300(TH120)
2 x RAFTER | Z/2599 | 8.9 | +5.671 | +6.113 | 96 | C300-C300/BB300(TH96)-BB300(TH120)
BRIDGING U-PLATE | Z/3065 | 3.6 | +5.671 | +5.979 | 100 | C250-C250/BB300(TH96)-BB300(TH120)
2 x RAFTER | Z/2591 | 5.9 | +5.705 | +6.106 | 76 | C250-C250/BB300(TH96)-BB300(TH120)
BRIDGING U-PLATE | Z/2978 | 3.6 | +5.672 | +5.980 | 308 | C200-C200/BB300(TH96)-BB300(TH120)
2 x RAFTER | Z/2998 | 3.9 | +5.745 | +6.058 | 76 | C200-C200/BB300(TH96)-BB300(TH120)
FASCIA STIFFENER | Z/237 | 0.8 | +5.671 | +5.971 | 3 | C300-C300/BB300(TH96)-BB300(TH120)
4 x RAFTER | Z/430 | 8.9 | +5.671 | +6.113 | 96 | C300/BB300(TH96)-BB300(TH120)
2 x FASCIA BRACKET | Z/2520 | 0.3 | +5.821 | +5.979 | 157.2 | C300/BB300(TH96)-BB300(TH120)
FASCIA BRACKET | Z/2520 | 0.3 | +5.821 | +5.979 | 157.2 | C300-C300/BB300(TH96)-BB300(TH120)
COLUMN | Z/3168 | 14 | +4.860 | +5.976 | 96 | C300/BB300(TH96)-BB300(TH120)
4 x RAFTER | Z/289 | 5.9 | +5.705 | +6.106 | 76 | C250/BB300(TH96)-BB300(TH120)
2 x FASCIA BRACKET | Z/2520 | 0.3 | +5.821 | +5.978 | 157.2 | C250/BB300(TH96)-BB300(TH120)
FASCIA BRACKET | Z/2520 | 0.3 | +5.821 | +5.978 | 157.2 | C250-C250/BB300(TH96)-BB300(TH120)
COLUMN | Z/3111 | 8.9 | +4.860 | +5.975 | 76 | C250/BB300(TH96)-BB300(TH120)
FASCIA STIFFENER | Z/237 | 0.8 | +5.675 | +5.975 | 3 | C250-C250/BB300(TH96)-BB300(TH120)
4 x RAFTER | Z/247 | 3.9 | +5.745 | +6.058 | 76 | C200/BB300(TH96)-BB300(TH120)
COLUMN | Z/3037 | 7.9 | +4.860 | +5.976 | 76 | C200/BB300(TH96)-BB300(TH120)
FASCIA STIFFENER | Z/237 | 0.8 | +5.676 | +5.976 | 3 | C200-C200/BB300(TH96)-BB300(TH120)
PLATE | Z/3160 | 10.6 | +5.476 | +6.052 | 244 | C300/BB300(TH96)-BB300(TH120)
BRIDGING-COLUMN STIFF | Z/3140 | 5.4 | +5.626 | +5.976 | 228 | C300/BB300(TH96)-BB300(TH120)
PLATE | Z/3099 | 7.1 | +5.590 | +6.017 | 224 | C250/BB300(TH96)-BB300(TH120)
BRIDGING-COLUMN STIFF | Z/3052 | 4.8 | +5.626 | +5.976 | 209.2 | C250/BB300(TH96)-BB300(TH120)
PLATE | Z/3021 | 4.8 | +5.675 | +5.989 | 224 | C200/BB300(TH96)-BB300(TH120)
BRIDGING-COLUMN STIFF | Z/2966 | 4.4 | +5.626 | +5.976 | 209.2 | C200/BB300(TH96)-BB300(TH120)
