Properties of the parts of a building model (IFC2X3), part 3 of 3

# IfcElementAssembly (1320)
Name | ASSEMBLY_POS = Assembly/Cast unit Mark | Assembly/Cast unit weight (kg) | Assembly/Cast unit bottom elevation | Assembly/Cast unit top elevation | Width (mm) | ASSEMBLY_POSITION_CODE = Assembly/Cast unit position code
FASCIA | Z/409 | 8.1 | +5.823 | +5.975 | 64 | C250-C250/BB300(TH120)
BEAM | Z/3083 | 19 | +5.675 | +5.975 | 96 | C250-C250/BB300(TH120)
FASCIA | Z/409 | 8.1 | +5.823 | +5.975 | 64 | C250-C250/BB300(TH96)
BEAM | Z/3083 | 19 | +5.675 | +5.975 | 96 | C250-C250/BB300(TH96)
FASCIA | Z/409 | 8.1 | +5.823 | +5.975 | 64 | C250-C250/BB300(TH75)
BEAM | Z/3083 | 19 | +5.675 | +5.975 | 96 | C250-C250/BB300(TH75)
FASCIA | Z/400 | 7.9 | +5.824 | +5.976 | 64 | C250-C250/BB250(TH120)
PLATE | Z/3093 | 6.7 | +5.571 | +5.998 | 224 | C250/BB250(TH120)
PLATE | Z/1289 | 5.2 | +5.571 | +5.998 | 79 | C250/BB250(TH120)
BEAM | Z/3071 | 15.3 | +5.687 | +5.941 | 76 | C250-C250/BB250(TH120)
FASCIA | Z/400 | 7.9 | +5.824 | +5.976 | 64 | C250-C250/BB250(TH96)
PLATE | Z/3091 | 6.7 | +5.590 | +6.017 | 224 | C250/BB250(TH96)
PLATE | Z/1289 | 5.2 | +5.590 | +6.017 | 79 | C250/BB250(TH96)
BEAM | Z/3071 | 15.3 | +5.702 | +5.956 | 76 | C250-C250/BB250(TH96)
FASCIA | Z/400 | 7.9 | +5.824 | +5.976 | 64 | C250-C250/BB250(TH75)
BB TRUSS BRACKET | Z/3055 | 3.1 | +5.722 | +6.023 | 147.999 | C250-C250/BB250(TH75)
PLATE | Z/3089 | 6.7 | +5.607 | +6.034 | 224 | C250/BB250(TH75)
PLATE | Z/1289 | 5.2 | +5.607 | +6.034 | 79 | C250/BB250(TH75)
BEAM | Z/3071 | 15.3 | +5.722 | +5.976 | 76 | C250-C250/BB250(TH75)
GIRT | Z/3002 | 4.6 | +5.388 | +5.553 | 165 | C200-C200/BB300(TH120)
GIRT | Z/3000 | 4.6 | +5.396 | +5.546 | 150 | C200-C200/BB300(TH96)
GIRT | Z/2995 | 4.6 | +5.408 | +5.533 | 125 | C200-C200/BB300(TH75)
GIRT | Z/3002 | 4.6 | +5.388 | +5.553 | 165 | C200-C200/BB250(TH120)
GIRT | Z/3000 | 4.6 | +5.396 | +5.546 | 150 | C200-C200/BB250(TH96)
GIRT | Z/2995 | 4.6 | +5.408 | +5.533 | 125 | C200-C200/BB250(TH75)
GIRT | Z/3002 | 4.6 | +5.388 | +5.553 | 165 | C200-C200/BB200(TH120)
GIRT | Z/3000 | 4.6 | +5.396 | +5.546 | 150 | C200-C200/BB200(TH96)
GIRT | Z/2995 | 4.6 | +5.408 | +5.533 | 125 | C200-C200/BB200(TH75)
PLATE | Z/227 | 3.1 | +5.656 | +5.970 | 79 | C200/BB300(TH120)
PLATE | Z/227 | 3.1 | +5.675 | +5.989 | 79 | C200/BB300(TH96)
PLATE | Z/227 | 3.1 | +5.692 | +6.006 | 79 | C200/BB300(TH75)
FASCIA | Z/426 | 8.9 | +5.824 | +5.976 | 64 | C200-C200/BB300(TH120)
BRIDGING BEAM | Z/3007 | 19 | +5.676 | +5.976 | 96 | C200-C200/BB300(TH120)
FASCIA | Z/426 | 8.9 | +5.824 | +5.976 | 64 | C200-C200/BB300(TH96)
BRIDGING BEAM | Z/3007 | 19 | +5.676 | +5.976 | 96 | C200-C200/BB300(TH96)
FASCIA | Z/426 | 8.9 | +5.824 | +5.976 | 64 | C200-C200/BB300(TH75)
BRIDGING BEAM | Z/3007 | 19 | +5.676 | +5.976 | 96 | C200-C200/BB300(TH75)
PLATE | Z/227 | 3.1 | +5.656 | +5.970 | 79 | C200/BB250(TH120)
PLATE | Z/227 | 3.1 | +5.675 | +5.989 | 79 | C200/BB250(TH96)
PLATE | Z/227 | 3.1 | +5.692 | +6.006 | 79 | C200/BB250(TH75)
PLATE | Z/3016 | 4.6 | +5.656 | +5.970 | 224 | C200/BB250(TH120)
PLATE | Z/3014 | 4.6 | +5.675 | +5.989 | 224 | C200/BB250(TH96)
PLATE | Z/3012 | 4.6 | +5.692 | +6.006 | 224 | C200/BB250(TH75)
FASCIA | Z/426 | 8.9 | +5.824 | +5.976 | 64 | C200-C200/BB250(TH120)
BRIDGING BEAM | Z/3005 | 15.3 | +5.712 | +5.966 | 76 | C200-C200/BB250(TH120)
FASCIA | Z/426 | 8.9 | +5.824 | +5.976 | 64 | C200-C200/BB250(TH96)
BRIDGING BEAM | Z/3005 | 15.3 | +5.722 | +5.976 | 76 | C200-C200/BB250(TH96)
FASCIA | Z/426 | 8.9 | +5.824 | +5.976 | 64 | C200-C200/BB250(TH75)
BRIDGING BEAM | Z/3005 | 15.3 | +5.722 | +5.976 | 76 | C200-C200/BB250(TH75)
BB TRUSS BRACKET | Z/2608 | 1.7 | +5.763 | +5.995 | 147.999 | C200-C200/BB200(TH75)
BB TRUSS BRACKET | Z/2967 | 1.7 | +5.763 | +5.995 | 147.999 | C200-C200/BB200(TH75)
PLATE | Z/3010 | 4.1 | +5.656 | +5.970 | 224 | C200/BB200(TH120)
PLATE | Z/227 | 3.1 | +5.656 | +5.970 | 79 | C200/BB200(TH120)
FASCIA | Z/426 | 8.9 | +5.824 | +5.976 | 64 | C200-C200/BB200(TH120)
BRIDGING BEAM | Z/2997 | 13.4 | +5.723 | +5.926 | 76 | C200-C200/BB200(TH120)
PLATE | Z/3010 | 4.1 | +5.675 | +5.989 | 224 | C200/BB200(TH96)
PLATE | Z/227 | 3.1 | +5.675 | +5.989 | 79 | C200/BB200(TH96)
FASCIA | Z/426 | 8.9 | +5.824 | +5.976 | 64 | C200-C200/BB200(TH96)
BRIDGING BEAM | Z/2997 | 13.4 | +5.743 | +5.946 | 76 | C200-C200/BB200(TH96)
PLATE | Z/3008 | 4.1 | +5.692 | +6.006 | 224 | C200/BB200(TH75)
PLATE | Z/227 | 3.1 | +5.692 | +6.006 | 79 | C200/BB200(TH75)
FASCIA | Z/426 | 8.9 | +5.824 | +5.976 | 64 | C200-C200/BB200(TH75)
BRIDGING BEAM | Z/2997 | 13.4 | +5.763 | +5.966 | 76 | C200-C200/BB200(TH75)
TH | Z/389 | 2.9 | +5.429 | +5.594 | 165 | C150-C150/BB250(TH120)
TH | Z/388 | 2.9 | +5.437 | +5.587 | 150 | C150-C150/BB250(TH96)
TH | Z/387 | 2.9 | +5.449 | +5.574 | 125 | C150-C150/BB250(TH75)
TH | Z/389 | 2.9 | +5.429 | +5.594 | 165 | C150-C150/BB200(TH120)
TH | Z/388 | 2.9 | +5.437 | +5.587 | 150 | C150-C150/BB200(TH96)
TH | Z/387 | 2.9 | +5.449 | +5.574 | 125 | C150-C150/BB200(TH75)
PLATE | Z/220 | 2.5 | +5.646 | +5.949 | 67 | C150/BB250(TH75)
PLATE | Z/2518 | 2.5 | +5.651 | +5.954 | 67 | C150/BB250(TH96)
PLATE | Z/2519 | 2.5 | +5.656 | +5.959 | 67 | C150/BB250(TH120)
PLATE | Z/2631 | 3.9 | +5.656 | +5.959 | 212 | C150/BB250(TH120)
PLATE | Z/2629 | 3.9 | +5.651 | +5.954 | 212 | C150/BB250(TH96)
PLATE | Z/2627 | 3.9 | +5.646 | +5.949 | 212 | C150/BB250(TH75)
FASCIA | Z/386 | 7.7 | +5.824 | +5.976 | 64 | C150-C150/BB250(TH120)
FASCIA | Z/386 | 7.7 | +5.799 | +5.951 | 64 | C150-C150/BB250(TH96)
FASCIA | Z/386 | 7.7 | +5.778 | +5.930 | 64 | C150-C150/BB250(TH75)
PLATE | Z/2625 | 3.7 | +5.610 | +5.913 | 212 | C150/BB200(TH120)
PLATE | Z/2519 | 2.5 | +5.610 | +5.913 | 67 | C150/BB200(TH120)
FASCIA | Z/386 | 7.7 | +5.778 | +5.930 | 64 | C150-C150/BB200(TH120)
PLATE | Z/2623 | 3.7 | +5.629 | +5.932 | 212 | C150/BB200(TH96)
PLATE | Z/2518 | 2.5 | +5.629 | +5.932 | 67 | C150/BB200(TH96)
FASCIA | Z/386 | 7.7 | +5.778 | +5.930 | 64 | C150-C150/BB200(TH96)
PLATE | Z/2621 | 3.7 | +5.646 | +5.949 | 212 | C150/BB200(TH75)
PLATE | Z/220 | 2.5 | +5.646 | +5.949 | 67 | C150/BB200(TH75)
FASCIA | Z/386 | 7.7 | +5.778 | +5.930 | 64 | C150-C150/BB200(TH75)

# IfcMechanicalFastener: Bolt assembly (1596)
In: Undefined
Tekla Bolt - Location: Site
Name | NominalDiameter (mm) = Washer diameter (mm) = Bolt size (mm) | NominalLength (mm) = Bolt length (mm) | Material = Bolt standard | Washer count | Washer type | Washer name | Nut count = Bolt count | Nut type | Nut name | Slotted hole y (mm) | Slotted hole x (mm) | Bolt hole diameter (mm) | Bolt Name
72 x Bolt assembly | 16 | 35 | 8.8S | 4 | HARD | WASHERM16-HARD | 4 | 8.8-HEX | NUTM16-8.8-HEX | 8 | 4 | 22 | BOLTM16*35
108 x Bolt assembly | 16 | 40 | 8.8S | 3 | HARD | WASHERM16-HARD | 3 | 8.8-HEX | NUTM16-8.8-HEX | 0 | 0 | 22 | BOLTM16*40
72 x Bolt assembly | 16 | 35 | 8.8S | 3 | HARD | WASHERM16-HARD | 3 | 8.8-HEX | NUTM16-8.8-HEX | 0 | 0 | 18 | BOLTM16*35
126 x Bolt assembly | 16 | 40 | 8.8S | 4 | HARD | WASHERM16-HARD | 4 | 8.8-HEX | NUTM16-8.8-HEX | 0 | 0 | 18 | BOLTM16*40
18 x Bolt assembly | 16 | 40 | 8.8S | 6 | HARD | WASHERM16-HARD | 6 | 8.8-HEX | NUTM16-8.8-HEX | 0 | 0 | 18 | BOLTM16*40
36 x Bolt assembly | 16 | 40 | 8.8S | 6 | HARD | WASHERM16-HARD | 6 | 8.8-HEX | NUTM16-8.8-HEX | 4 | 8 | 18 | BOLTM16*40
36 x Bolt assembly | 16 | 40 | 8.8S | 6 | HARD | WASHERM16-HARD | 6 | 8.8-HEX | NUTM16-8.8-HEX | 8 | 4 | 18 | BOLTM16*40
312 x Bolt assembly | 5 | 25 | TEK_16TPIM | 4 | UNDEF_WASH | UNDEFINED_WASHER10G | 2 | UNDEF_NUT | UNDEFINED_NUTM5 | 0 | 0 | 7 | TEKSCREW_M5*25
121 x Bolt assembly | 5 | 11.6 | TEK_16TPIM | 8 | UNDEF_WASH | UNDEFINED_WASHER10G | 4 | UNDEF_NUT | UNDEFINED_NUTM5 | 0 | 0 | 7 | TEKSCREW_M5*25
132 x Bolt assembly | 5 | 25 | TEK_16TPIM | 2 | UNDEF_WASH | UNDEFINED_WASHER10G | 2 | UNDEF_NUT | UNDEFINED_NUTM5 | 0 | 0 | 7 | TEKSCREW_M5*25
36 x Bolt assembly | 16 | 35 | 8.8S | 4 | HARD | WASHERM16-HARD | 4 | 8.8-HEX | NUTM16-8.8-HEX | 4 | 8 | 18 | BOLTM16*35
36 x Bolt assembly | 16 | 35 | 8.8S | 4 | HARD | WASHERM16-HARD | 4 | 8.8-HEX | NUTM16-8.8-HEX | 8 | 4 | 18 | BOLTM16*35
54 x Bolt assembly | 5 | 11.6 | TEK_16TPIM | 4 | UNDEF_WASH | UNDEFINED_WASHER10G | 2 | UNDEF_NUT | UNDEFINED_NUTM5 | 0 | 0 | 7 | TEKSCREW_M5*25
36 x Bolt assembly | 12 | 30 | PB1230 | 3 | FLAT | WASHERM12-FLAT | 3 | 4.6-HEX | NUTM12-4.6-HEX | 0 | 0 | 14 | BOLTPB1230
62 x Bolt assembly | 5 | 25 | TEK_16TPIM | 8 | UNDEF_WASH | UNDEFINED_WASHER10G | 4 | UNDEF_NUT | UNDEFINED_NUTM5 | 0 | 0 | 7 | TEKSCREW_M5*25
60 x Bolt assembly | 12 | 25 | 8.8S | 4 | HARD | WASHERM12-HARD | 4 | 8.8-HEX | NUTM12-8.8-HEX | 8 | 4 | 18 | BOLTM12*25
30 x Bolt assembly | 12 | 35 | 8.8S | 4 | HARD | WASHERM12-HARD | 4 | 8.8-HEX | NUTM12-8.8-HEX | 0 | 0 | 14 | BOLTM12*35
60 x Bolt assembly | 12 | 30 | 8.8S | 4 | HARD | WASHERM12-HARD | 4 | 8.8-HEX | NUTM12-8.8-HEX | 4 | 8 | 14 | BOLTM12*30
60 x Bolt assembly | 12 | 30 | 8.8S | 4 | HARD | WASHERM12-HARD | 4 | 8.8-HEX | NUTM12-8.8-HEX | 8 | 4 | 14 | BOLTM12*30
24 x Bolt assembly | 12 | 30 | PB1230 | 3 | FLAT | WASHERM12-FLAT | 3 | 4.6-HEX | NUTM12-4.6-HEX | 4 | 8 | 14 | BOLTPB1230
36 x Bolt assembly | 12 | 30 | PB1230 | 4 | FLAT | WASHERM12-FLAT | 4 | 4.6-HEX | NUTM12-4.6-HEX | 4 | 0 | 14 | BOLTPB1230
24 x Bolt assembly | 12 | 30 | PB1230 | 3 | FLAT | WASHERM12-FLAT | 3 | 4.6-HEX | NUTM12-4.6-HEX | 0 | 0 | 18 | BOLTPB1230
30 x Bolt assembly | 5 | 25 | TEK_16TPIM | 8 | UNDEF_WASH | UNDEFINED_WASHER10G | 2 | UNDEF_NUT | UNDEFINED_NUTM5 | 0 | 0 | 7 | TEKSCREW_M5*25
15 x Bolt assembly | 5 | 25 | TEK_16TPIM | 16 | UNDEF_WASH | UNDEFINED_WASHER10G | 4 | UNDEF_NUT | UNDEFINED_NUTM5 | 0 | 0 | 7 | TEKSCREW_M5*25

# IfcPlate: PLT3*159.7 (24)
In: Undefined
Description: PLT3*159.7; Material: STEEL/450
Tekla Common - Phase: 1; Class: 1
Tekla Quantity - Weight: 1.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.7 m2; Net surface area: 0.1 m2; Height: 159.7 mm; Width: 3 mm; Length: 392.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 159.663 mm; NetArea: 0.103751 m2; GrossArea: 0.0626777 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000150671 m3; GrossVolume: 0.000150671 m3
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation
2 x BB TRUSS BRACKET | Z/2610 | +5.768 | +5.948
2 x BB TRUSS BRACKET | Z/2611 | +5.768 | +5.948
2 x BB TRUSS BRACKET | Z/2610 | +5.763 | +5.943
2 x BB TRUSS BRACKET | Z/2611 | +5.763 | +5.943
4 x BB TRUSS BRACKET | Z/2610 | +5.759 | +5.938
4 x BB TRUSS BRACKET | Z/2611 | +5.759 | +5.938
2 x BB TRUSS BRACKET | Z/2610 | +5.722 | +5.902
2 x BB TRUSS BRACKET | Z/2611 | +5.722 | +5.902
2 x BB TRUSS BRACKET | Z/2610 | +5.742 | +5.921
2 x BB TRUSS BRACKET | Z/2611 | +5.742 | +5.921

# IfcPlate: PLT3*209.7 (36)
In: Undefined
Description: PLT3*209.7; Material: STEEL/450
Tekla Common - Phase: 1; Class: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.2 m2; Height: 209.7 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Net surface area (m2) | Length (mm) | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) | GrossVolume (m3)
BB TRUSS BRACKET | Z/2971 | +5.725 | +5.958 | 1.8 | 0.1 | 414.5 | 209.669 | 0.148878 | 0.0869167 | 0.00021763 | 0.00021763
BB TRUSS BRACKET | Z/2970 | +5.725 | +5.958 | 1.8 | 0.1 | 414.5 | 209.667 | 0.148877 | 0.0869155 | 0.000217629 | 0.000217629
BB TRUSS BRACKET | Z/2971 | +5.744 | +5.978 | 1.8 | 0.1 | 414.5 | 209.669 | 0.148878 | 0.0869167 | 0.00021763 | 0.00021763
BB TRUSS BRACKET | Z/2970 | +5.744 | +5.978 | 1.8 | 0.1 | 414.5 | 209.667 | 0.148877 | 0.0869155 | 0.000217629 | 0.000217629
BB TRUSS BRACKET | Z/2971 | +5.761 | +5.995 | 1.8 | 0.1 | 414.5 | 209.669 | 0.148878 | 0.0869167 | 0.00021763 | 0.00021763
BB TRUSS BRACKET | Z/2970 | +5.761 | +5.995 | 1.8 | 0.1 | 414.5 | 209.667 | 0.148877 | 0.0869155 | 0.000217629 | 0.000217629
BB TRUSS BRACKET | Z/2969 | +5.717 | +5.958 | 1.9 | 0.2 | 455.4 | 209.667 | 0.163842 | 0.0954891 | 0.000239709 | 0.000239709
BB TRUSS BRACKET | Z/2968 | +5.717 | +5.958 | 1.9 | 0.2 | 455.4 | 209.665 | 0.163841 | 0.095488 | 0.000239708 | 0.000239708
BB TRUSS BRACKET | Z/2969 | +5.736 | +5.978 | 1.9 | 0.2 | 455.4 | 209.667 | 0.163842 | 0.0954891 | 0.000239709 | 0.000239709
BB TRUSS BRACKET | Z/2968 | +5.736 | +5.978 | 1.9 | 0.2 | 455.4 | 209.665 | 0.163841 | 0.095488 | 0.000239708 | 0.000239708
BB TRUSS BRACKET | Z/2969 | +5.753 | +5.995 | 1.9 | 0.2 | 455.4 | 209.667 | 0.163842 | 0.0954891 | 0.000239709 | 0.000239709
BB TRUSS BRACKET | Z/2968 | +5.753 | +5.995 | 1.9 | 0.2 | 455.4 | 209.665 | 0.163841 | 0.095488 | 0.000239708 | 0.000239708
BB TRUSS BRACKET | Z/2967 | +5.726 | +5.958 | 1.8 | 0.2 | 453.4 | 209.667 | 0.160559 | 0.0950655 | 0.000234854 | 0.000239709
BB TRUSS BRACKET | Z/2608 | +5.726 | +5.958 | 1.8 | 0.2 | 453.4 | 209.665 | 0.160558 | 0.0950644 | 0.000234853 | 0.000239708
BB TRUSS BRACKET | Z/2967 | +5.746 | +5.978 | 1.8 | 0.2 | 453.4 | 209.667 | 0.160559 | 0.0950655 | 0.000234854 | 0.000239709
BB TRUSS BRACKET | Z/2608 | +5.746 | +5.978 | 1.8 | 0.2 | 453.4 | 209.665 | 0.160558 | 0.0950644 | 0.000234853 | 0.000239708
BB TRUSS BRACKET | Z/2967 | +5.763 | +5.995 | 1.8 | 0.2 | 453.4 | 209.667 | 0.160559 | 0.0950655 | 0.000234854 | 0.000239709
BB TRUSS BRACKET | Z/2608 | +5.763 | +5.995 | 1.8 | 0.2 | 453.4 | 209.665 | 0.160558 | 0.0950644 | 0.000234853 | 0.000239708
BB TRUSS BRACKET | Z/2970 | +5.725 | +5.958 | 1.8 | 0.1 | 414.5 | 209.669 | 0.148878 | 0.0869167 | 0.00021763 | 0.00021763
BB TRUSS BRACKET | Z/2971 | +5.725 | +5.958 | 1.8 | 0.1 | 414.5 | 209.667 | 0.148877 | 0.0869155 | 0.000217629 | 0.000217629
BB TRUSS BRACKET | Z/2970 | +5.744 | +5.978 | 1.8 | 0.1 | 414.5 | 209.669 | 0.148878 | 0.0869167 | 0.00021763 | 0.00021763
BB TRUSS BRACKET | Z/2971 | +5.744 | +5.978 | 1.8 | 0.1 | 414.5 | 209.667 | 0.148877 | 0.0869155 | 0.000217629 | 0.000217629
BB TRUSS BRACKET | Z/2970 | +5.761 | +5.995 | 1.8 | 0.1 | 414.5 | 209.669 | 0.148878 | 0.0869167 | 0.00021763 | 0.00021763
BB TRUSS BRACKET | Z/2971 | +5.761 | +5.995 | 1.8 | 0.1 | 414.5 | 209.667 | 0.148877 | 0.0869155 | 0.000217629 | 0.000217629
BB TRUSS BRACKET | Z/2968 | +5.717 | +5.958 | 1.9 | 0.2 | 455.4 | 209.667 | 0.163842 | 0.0954891 | 0.000239709 | 0.000239709
BB TRUSS BRACKET | Z/2969 | +5.717 | +5.958 | 1.9 | 0.2 | 455.4 | 209.665 | 0.163841 | 0.095488 | 0.000239708 | 0.000239708
BB TRUSS BRACKET | Z/2968 | +5.736 | +5.978 | 1.9 | 0.2 | 455.4 | 209.667 | 0.163842 | 0.0954891 | 0.000239709 | 0.000239709
BB TRUSS BRACKET | Z/2969 | +5.736 | +5.978 | 1.9 | 0.2 | 455.4 | 209.665 | 0.163841 | 0.095488 | 0.000239708 | 0.000239708
BB TRUSS BRACKET | Z/2968 | +5.753 | +5.995 | 1.9 | 0.2 | 455.4 | 209.667 | 0.163842 | 0.0954891 | 0.000239709 | 0.000239709
BB TRUSS BRACKET | Z/2969 | +5.753 | +5.995 | 1.9 | 0.2 | 455.4 | 209.665 | 0.163841 | 0.095488 | 0.000239708 | 0.000239708
BB TRUSS BRACKET | Z/2608 | +5.726 | +5.958 | 1.8 | 0.2 | 453.4 | 209.667 | 0.160559 | 0.0950655 | 0.000234854 | 0.000239709
BB TRUSS BRACKET | Z/2967 | +5.726 | +5.958 | 1.8 | 0.2 | 453.4 | 209.665 | 0.160558 | 0.0950644 | 0.000234853 | 0.000239708
BB TRUSS BRACKET | Z/2608 | +5.746 | +5.978 | 1.8 | 0.2 | 453.4 | 209.667 | 0.160559 | 0.0950655 | 0.000234854 | 0.000239709
BB TRUSS BRACKET | Z/2967 | +5.746 | +5.978 | 1.8 | 0.2 | 453.4 | 209.665 | 0.160558 | 0.0950644 | 0.000234853 | 0.000239708
BB TRUSS BRACKET | Z/2608 | +5.763 | +5.995 | 1.8 | 0.2 | 453.4 | 209.667 | 0.160559 | 0.0950655 | 0.000234854 | 0.000239709
BB TRUSS BRACKET | Z/2967 | +5.763 | +5.995 | 1.8 | 0.2 | 453.4 | 209.665 | 0.160558 | 0.0950644 | 0.000234853 | 0.000239708

# IfcPlate: PLT3*232.9 (12)
In: Undefined
Description: PLT3*232.9; Material: STEEL/450
Tekla Common - Phase: 1; Class: 2
Tekla Quantity - Weight: 1.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.4 m2; Net surface area: 0.2 m2; Height: 232.9 mm; Width: 3 mm; Length: 350 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 232.879 mm; NetArea: 0.169434 m2; GrossArea: 0.0815076 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000247169 m3; GrossVolume: 0.000247169 m3
Name | Bottom elevation | Top elevation | ASSEMBLY_POS = Reference
BRIDGING-COLUMN STIFF | +5.626 | +5.976 | Z/2607
BRIDGING-COLUMN STIFF | +5.601 | +5.951 | Z/2607
BRIDGING-COLUMN STIFF | +5.580 | +5.930 | Z/2607
BRIDGING-COLUMN STIFF | +5.580 | +5.930 | Z/2604
2 x BRIDGING-COLUMN STIFF | +5.580 | +5.930 | Z/2598
BRIDGING-COLUMN STIFF | +5.626 | +5.976 | Z/2605
BRIDGING-COLUMN STIFF | +5.601 | +5.951 | Z/2605
BRIDGING-COLUMN STIFF | +5.580 | +5.930 | Z/2605
BRIDGING-COLUMN STIFF | +5.580 | +5.930 | Z/2603
2 x BRIDGING-COLUMN STIFF | +5.580 | +5.930 | Z/2597

# IfcPlate: PLT3*259.7 (18)
In: Undefined
Description: PLT3*259.7; Material: STEEL/450
Tekla Common - Phase: 1; Class: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.7 m2; Net surface area: 0.4 m2; Height: 259.7 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 259.65 mm; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) | GrossVolume (m3)
2 x BB TRUSS BRACKET | Z/3058 | +5.673 | +5.986 | 3 | 562.4 | 0.25599 | 0.146032 | 0.000376436 | 0.000376436
2 x BB TRUSS BRACKET | Z/3057 | +5.673 | +5.986 | 3 | 562.4 | 0.25599 | 0.146032 | 0.000376436 | 0.000376436
2 x BB TRUSS BRACKET | Z/3058 | +5.693 | +6.006 | 3 | 562.4 | 0.25599 | 0.146032 | 0.000376436 | 0.000376436
2 x BB TRUSS BRACKET | Z/3057 | +5.693 | +6.006 | 3 | 562.4 | 0.25599 | 0.146032 | 0.000376436 | 0.000376436
2 x BB TRUSS BRACKET | Z/3058 | +5.710 | +6.023 | 3 | 562.4 | 0.25599 | 0.146032 | 0.000376436 | 0.000376436
2 x BB TRUSS BRACKET | Z/3057 | +5.710 | +6.023 | 3 | 562.4 | 0.25599 | 0.146032 | 0.000376436 | 0.000376436
BB TRUSS BRACKET | Z/3056 | +5.685 | +5.986 | 3.1 | 599.1 | 0.267147 | 0.155553 | 0.000392952 | 0.000404657
BB TRUSS BRACKET | Z/3056 | +5.705 | +6.006 | 3.1 | 599.1 | 0.267147 | 0.155553 | 0.000392952 | 0.000404657
BB TRUSS BRACKET | Z/3056 | +5.722 | +6.023 | 3.1 | 599.1 | 0.267147 | 0.155553 | 0.000392952 | 0.000404657
BB TRUSS BRACKET | Z/3055 | +5.685 | +5.986 | 3.1 | 599.1 | 0.267147 | 0.155553 | 0.000392952 | 0.000404657
BB TRUSS BRACKET | Z/3055 | +5.705 | +6.006 | 3.1 | 599.1 | 0.267147 | 0.155553 | 0.000392952 | 0.000404657
BB TRUSS BRACKET | Z/3055 | +5.722 | +6.023 | 3.1 | 599.1 | 0.267147 | 0.155553 | 0.000392952 | 0.000404657

# IfcPlate: PLT3*300.6 (12)
In: Undefined
Description: PLT3*300.6; Material: STEEL/450
Tekla Common - Phase: 1; Class: 1
Tekla Quantity - Weight: 2.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.7 m2; Net surface area: 0.2 m2; Height: 300.6 mm; Width: 3 mm; Length: 498.3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 300.572 mm; NetArea: 0.228357 m2; GrossArea: 0.149772 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00033552 m3; GrossVolume: 0.00033552 m3
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation
2 x BB TRUSS BRACKET | Z/3059 | +5.686 | +5.986
2 x BB TRUSS BRACKET | Z/3060 | +5.686 | +5.986
2 x BB TRUSS BRACKET | Z/3059 | +5.705 | +6.006
2 x BB TRUSS BRACKET | Z/3060 | +5.705 | +6.006
2 x BB TRUSS BRACKET | Z/3059 | +5.722 | +6.023
2 x BB TRUSS BRACKET | Z/3060 | +5.722 | +6.023

# IfcPlate: PLT3*301 (6)
In: Undefined
Description: PLT3*301; Material: STEEL/450
Tekla Common - Phase: 1; Class: 1
Tekla Quantity - Weight: 3.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.7 m2; Net surface area: 0.4 m2; Height: 301 mm; Width: 3 mm; Length: 596.3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 301.049 mm; NetArea: 0.267147 m2; GrossArea: 0.179515 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000392954 m3; GrossVolume: 0.000404657 m3
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation
BB TRUSS BRACKET | Z/3055 | +5.685 | +5.986
BB TRUSS BRACKET | Z/3055 | +5.705 | +6.006
BB TRUSS BRACKET | Z/3055 | +5.722 | +6.023
BB TRUSS BRACKET | Z/3056 | +5.685 | +5.986
BB TRUSS BRACKET | Z/3056 | +5.705 | +6.006
BB TRUSS BRACKET | Z/3056 | +5.722 | +6.023

# IfcPlate: PLT3*307.9 (18)
In: Undefined
Description: PLT3*307.9; Material: STEEL/450
Tekla Common - Bottom elevation: +5.626; Top elevation: +5.976; Phase: 1; Class: 2
Tekla Quantity - Weight: 2.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.9 m2; Net surface area: 0.2 m2; Height: 307.9 mm; Width: 3 mm; Length: 350 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 307.879 mm; NetArea: 0.222384 m2; GrossArea: 0.107758 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000325919 m3; GrossVolume: 0.000325919 m3
Name | ASSEMBLY_POS = Reference
3 x BRIDGING-COLUMN STIFF | Z/2966
BRIDGING-COLUMN STIFF | Z/2964
2 x BRIDGING-COLUMN STIFF | Z/2962
BRIDGING-COLUMN STIFF | Z/2960
BRIDGING-COLUMN STIFF | Z/2958
BRIDGING-COLUMN STIFF | Z/2956
3 x BRIDGING-COLUMN STIFF | Z/2965
BRIDGING-COLUMN STIFF | Z/2963
2 x BRIDGING-COLUMN STIFF | Z/2961
BRIDGING-COLUMN STIFF | Z/2959
BRIDGING-COLUMN STIFF | Z/2957
BRIDGING-COLUMN STIFF | Z/2955

# IfcPlate: PLT3*308.7 (24)
In: Undefined
Description: PLT3*308.7; Material: STEEL/450
Tekla Common - Phase: 1; Class: 11
Tekla Quantity - Weight: 2.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.7 m2; Net surface area: 0.2 m2; Height: 308.7 mm; Width: 3 mm; Length: 451.2 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - NetArea: 0.216526 m2; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Width (mm) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
PLATE | Z/2508 | +5.656 | +5.959 | 308.673 | 0.139264 | 0.000318537
PLATE | Z/2632 | +5.656 | +5.959 | 308.673 | 0.139264 | 0.000318537
PLATE | Z/2507 | +5.651 | +5.954 | 308.673 | 0.139264 | 0.000318537
PLATE | Z/2630 | +5.651 | +5.954 | 308.673 | 0.139264 | 0.000318537
2 x PLATE | Z/1000 | +5.646 | +5.949 | 308.673 | 0.139264 | 0.000318537
PLATE | Z/2628 | +5.646 | +5.949 | 308.673 | 0.139264 | 0.000318537
PLATE | Z/2508 | +5.610 | +5.913 | 308.673 | 0.139264 | 0.000318537
PLATE | Z/2626 | +5.610 | +5.913 | 308.673 | 0.139264 | 0.000318537
PLATE | Z/2507 | +5.629 | +5.932 | 308.673 | 0.139264 | 0.000318537
PLATE | Z/2624 | +5.629 | +5.932 | 308.673 | 0.139264 | 0.000318537
PLATE | Z/2622 | +5.646 | +5.949 | 308.673 | 0.139264 | 0.000318537
2 x PLATE | Z/220 | +5.646 | +5.949 | 308.662 | 0.139258 | 0.000318536
PLATE | Z/2518 | +5.651 | +5.954 | 308.662 | 0.139258 | 0.000318536
PLATE | Z/2519 | +5.656 | +5.959 | 308.662 | 0.139258 | 0.000318536
PLATE | Z/2631 | +5.656 | +5.959 | 308.662 | 0.139258 | 0.000318536
PLATE | Z/2629 | +5.651 | +5.954 | 308.662 | 0.139258 | 0.000318536
PLATE | Z/2627 | +5.646 | +5.949 | 308.662 | 0.139258 | 0.000318536
PLATE | Z/2519 | +5.610 | +5.913 | 308.662 | 0.139258 | 0.000318536
PLATE | Z/2625 | +5.610 | +5.913 | 308.662 | 0.139258 | 0.000318536
PLATE | Z/2518 | +5.629 | +5.932 | 308.662 | 0.139258 | 0.000318536
PLATE | Z/2623 | +5.629 | +5.932 | 308.662 | 0.139258 | 0.000318536
PLATE | Z/2621 | +5.646 | +5.949 | 308.662 | 0.139258 | 0.000318536

# IfcPlate: PLT3*309.6 (18)
In: Undefined
Description: PLT3*309.6; Material: STEEL/450
Tekla Common - Phase: 1; Class: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.4 m2; Net surface area: 0.4 m2; Height: 309.6 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000009 m2
Name | Bottom elevation | Top elevation | ASSEMBLY_POS = Reference | Weight (kg) | Length (mm) | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) | GrossVolume (m3)
BB TRUSS BRACKET | +5.637 | +6.023 | Z/3145 | 4.3 | 675.1 | 309.6 | 0.371675 | 0.209004 | 0.000548417 | 0.000548417
BB TRUSS BRACKET | +5.632 | +6.017 | Z/3145 | 4.3 | 675.1 | 309.6 | 0.371675 | 0.209004 | 0.000548417 | 0.000548417
BB TRUSS BRACKET | +5.628 | +6.013 | Z/3145 | 4.3 | 675.1 | 309.6 | 0.371675 | 0.209004 | 0.000548417 | 0.000548417
2 x BB TRUSS BRACKET | +5.651 | +6.023 | Z/3148 | 4.6 | 728.9 | 309.63 | 0.394272 | 0.225683 | 0.000581973 | 0.000598234
2 x BB TRUSS BRACKET | +5.651 | +6.023 | Z/3147 | 4.6 | 728.9 | 309.63 | 0.394272 | 0.225683 | 0.000581973 | 0.000598234
2 x BB TRUSS BRACKET | +5.671 | +6.042 | Z/3148 | 4.6 | 728.9 | 309.63 | 0.394272 | 0.225683 | 0.000581973 | 0.000598234
2 x BB TRUSS BRACKET | +5.671 | +6.042 | Z/3147 | 4.6 | 728.9 | 309.63 | 0.394272 | 0.225683 | 0.000581973 | 0.000598234
2 x BB TRUSS BRACKET | +5.688 | +6.059 | Z/3148 | 4.6 | 728.9 | 309.63 | 0.394272 | 0.225683 | 0.000581973 | 0.000598234
2 x BB TRUSS BRACKET | +5.688 | +6.059 | Z/3147 | 4.6 | 728.9 | 309.63 | 0.394272 | 0.225683 | 0.000581973 | 0.000598234
BB TRUSS BRACKET | +5.637 | +6.023 | Z/3146 | 4.3 | 675.1 | 309.6 | 0.371675 | 0.209004 | 0.000548417 | 0.000548417
BB TRUSS BRACKET | +5.632 | +6.017 | Z/3146 | 4.3 | 675.1 | 309.6 | 0.371675 | 0.209004 | 0.000548417 | 0.000548417
BB TRUSS BRACKET | +5.628 | +6.013 | Z/3146 | 4.3 | 675.1 | 309.6 | 0.371675 | 0.209004 | 0.000548417 | 0.000548417

# IfcPlate: PLT3*310 (66)
In: Undefined
Description: PLT3*310; Material: STEEL/450
Tekla Common - Phase: 1; Class: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 310 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 310.001 mm; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
2 x BRIDGING U-PLATE | Z/3149 | +5.622 | +5.980 | 4.4 | 86.4 | 0.4 | 599.3 | 0.379597 | 0.185776 | 0.000559672
2 x BRIDGING U-PLATE | Z/3069 | +5.621 | +5.979 | 4.4 | 86.4 | 0.4 | 599.3 | 0.379597 | 0.185776 | 0.000559672
2 x BRIDGING U-PLATE | Z/3625 | +5.606 | +5.964 | 4.4 | 86.4 | 0.4 | 599.3 | 0.379597 | 0.185776 | 0.000559672
2 x BRIDGING U-PLATE | Z/3150 | +5.598 | +5.956 | 4.4 | 86.4 | 0.4 | 599.3 | 0.379597 | 0.185776 | 0.000559672
2 x BRIDGING U-PLATE | Z/3150 | +5.621 | +5.979 | 4.4 | 86.4 | 0.4 | 599.3 | 0.379597 | 0.185776 | 0.000559672
2 x BRIDGING U-PLATE | Z/3068 | +5.621 | +5.979 | 4.4 | 86.4 | 0.4 | 599.3 | 0.379597 | 0.185776 | 0.000559672
2 x BRIDGING U-PLATE | Z/3149 | +5.576 | +5.934 | 4.4 | 86.4 | 0.4 | 599.3 | 0.379597 | 0.185776 | 0.000559672
2 x BRIDGING U-PLATE | Z/3149 | +5.621 | +5.979 | 4.4 | 86.4 | 0.4 | 599.3 | 0.379597 | 0.185776 | 0.000559672
2 x BRIDGING U-PLATE | Z/3067 | +5.621 | +5.979 | 4.4 | 86.4 | 0.4 | 599.3 | 0.379597 | 0.185776 | 0.000559672
2 x BRIDGING U-PLATE | Z/3152 | +5.647 | +5.955 | 3.6 | 86.4 | 0.4 | 491.3 | 0.311989 | 0.152296 | 0.000459232
2 x BRIDGING U-PLATE | Z/3066 | +5.671 | +5.979 | 3.6 | 86.4 | 0.4 | 491.3 | 0.311989 | 0.152296 | 0.000459232
2 x BRIDGING U-PLATE | Z/2979 | +5.672 | +5.980 | 3.6 | 86.4 | 0.4 | 491.3 | 0.311989 | 0.152296 | 0.000459232
2 x BRIDGING U-PLATE | Z/3151 | +5.667 | +5.975 | 3.6 | 86.4 | 0.4 | 491.3 | 0.311989 | 0.152296 | 0.000459232
2 x BRIDGING U-PLATE | Z/3065 | +5.671 | +5.979 | 3.6 | 86.4 | 0.4 | 491.3 | 0.311989 | 0.152296 | 0.000459232
2 x BRIDGING U-PLATE | Z/2978 | +5.672 | +5.980 | 3.6 | 86.4 | 0.4 | 491.3 | 0.311989 | 0.152296 | 0.000459232
2 x BRIDGING U-PLATE | Z/3151 | +5.672 | +5.980 | 3.6 | 86.4 | 0.4 | 491.3 | 0.311989 | 0.152296 | 0.000459232
2 x BRIDGING U-PLATE | Z/3064 | +5.671 | +5.979 | 3.6 | 86.4 | 0.4 | 491.3 | 0.311989 | 0.152296 | 0.000459232
2 x BRIDGING U-PLATE | Z/2977 | +5.672 | +5.980 | 3.6 | 86.4 | 0.4 | 491.3 | 0.311989 | 0.152296 | 0.000459232
2 x BRIDGING U-PLATE | Z/3063 | +5.683 | +5.945 | 3 | 86.7 | 0.4 | 405.3 | 0.258153 | 0.125636 | 0.000379252
2 x BRIDGING U-PLATE | Z/2976 | +5.708 | +5.970 | 3 | 86.7 | 0.4 | 405.3 | 0.258153 | 0.125636 | 0.000379252
2 x BRIDGING U-PLATE | Z/2617 | +5.718 | +5.980 | 3 | 86.7 | 0.4 | 405.3 | 0.258153 | 0.125636 | 0.000379252
2 x BRIDGING U-PLATE | Z/3062 | +5.698 | +5.960 | 3 | 86.7 | 0.4 | 405.3 | 0.258153 | 0.125636 | 0.000379252
2 x BRIDGING U-PLATE | Z/2975 | +5.718 | +5.980 | 3 | 86.7 | 0.4 | 405.3 | 0.258153 | 0.125636 | 0.000379252
2 x BRIDGING U-PLATE | Z/2616 | +5.693 | +5.955 | 3 | 86.7 | 0.4 | 405.3 | 0.258153 | 0.125636 | 0.000379252
2 x BRIDGING U-PLATE | Z/3061 | +5.718 | +5.980 | 3 | 86.7 | 0.4 | 405.3 | 0.258153 | 0.125636 | 0.000379252
2 x BRIDGING U-PLATE | Z/2974 | +5.718 | +5.980 | 3 | 86.7 | 0.4 | 405.3 | 0.258153 | 0.125636 | 0.000379252
2 x BRIDGING U-PLATE | Z/2615 | +5.672 | +5.934 | 3 | 86.7 | 0.4 | 405.3 | 0.258153 | 0.125636 | 0.000379252
2 x BRIDGING U-PLATE | Z/2972 | +5.719 | +5.930 | 2.6 | 86.9 | 0.2 | 354.3 | 0.226227 | 0.109826 | 0.000331822
2 x BRIDGING U-PLATE | Z/2614 | +5.713 | +5.924 | 2.6 | 86.9 | 0.2 | 354.3 | 0.226227 | 0.109826 | 0.000331822
2 x BRIDGING U-PLATE | Z/2972 | +5.739 | +5.950 | 2.6 | 86.9 | 0.2 | 354.3 | 0.226227 | 0.109826 | 0.000331822
2 x BRIDGING U-PLATE | Z/2613 | +5.723 | +5.934 | 2.6 | 86.9 | 0.2 | 354.3 | 0.226227 | 0.109826 | 0.000331822
2 x BRIDGING U-PLATE | Z/2973 | +5.759 | +5.970 | 2.6 | 86.9 | 0.2 | 354.3 | 0.226227 | 0.109826 | 0.000331822
2 x BRIDGING U-PLATE | Z/2612 | +5.723 | +5.934 | 2.6 | 86.9 | 0.2 | 354.3 | 0.226227 | 0.109826 | 0.000331822

# IfcPlate: PLT3*333.3 (36)
In: Undefined
Description: PLT3*333.3; Material: STEEL/450
Tekla Common - Phase: 1; Class: 11
Tekla Quantity - Weight: 3.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.4 m2; Net surface area: 0.4 m2; Height: 333.3 mm; Width: 3 mm; Length: 496.9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - NetArea: 0.266193 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000392276 m3; GrossVolume: 0.000392276 m3
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Width (mm) | GrossArea (m2)
3 x PLATE | Z/548 | +5.656 | +5.970 | 333.309 | 0.165626
PLATE | Z/3023 | +5.656 | +5.970 | 333.309 | 0.165626
3 x PLATE | Z/548 | +5.675 | +5.989 | 333.309 | 0.165626
PLATE | Z/3021 | +5.675 | +5.989 | 333.309 | 0.165626
3 x PLATE | Z/548 | +5.692 | +6.006 | 333.309 | 0.165626
PLATE | Z/3019 | +5.692 | +6.006 | 333.309 | 0.165626
PLATE | Z/3017 | +5.656 | +5.970 | 333.309 | 0.165626
PLATE | Z/3015 | +5.675 | +5.989 | 333.309 | 0.165626
PLATE | Z/3013 | +5.692 | +6.006 | 333.309 | 0.165626
PLATE | Z/3011 | +5.656 | +5.970 | 333.309 | 0.165626
PLATE | Z/3011 | +5.675 | +5.989 | 333.309 | 0.165626
PLATE | Z/3009 | +5.692 | +6.006 | 333.309 | 0.165626
3 x PLATE | Z/227 | +5.656 | +5.970 | 333.291 | 0.165615
3 x PLATE | Z/227 | +5.675 | +5.989 | 333.291 | 0.165615
3 x PLATE | Z/227 | +5.692 | +6.006 | 333.291 | 0.165615
PLATE | Z/3022 | +5.656 | +5.970 | 333.291 | 0.165615
PLATE | Z/3020 | +5.675 | +5.989 | 333.291 | 0.165615
PLATE | Z/3018 | +5.692 | +6.006 | 333.291 | 0.165615
PLATE | Z/3016 | +5.656 | +5.970 | 333.291 | 0.165615
PLATE | Z/3014 | +5.675 | +5.989 | 333.291 | 0.165615
PLATE | Z/3012 | +5.692 | +6.006 | 333.291 | 0.165615
PLATE | Z/3010 | +5.656 | +5.970 | 333.291 | 0.165615
PLATE | Z/3010 | +5.675 | +5.989 | 333.291 | 0.165615
PLATE | Z/3008 | +5.692 | +6.006 | 333.291 | 0.165615

# IfcPlate: PLT3*350 (36)
In: Undefined
Description: PLT3*350; Material: STEEL/450
Tekla Common - Phase: 1; Class: 2
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.4 m2; Height: 350 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 350 mm; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
BRIDGING-COLUMN STIFF | Z/3622 | +5.625 | +5.975 | 4.4 | 86.4 | 549.3 | 0.392812 | 0.192248 | 0.000579389
BRIDGING-COLUMN STIFF | Z/3144 | +5.626 | +5.976 | 3.7 | 86.4 | 441.3 | 0.316564 | 0.154448 | 0.000465989
3 x BRIDGING-COLUMN STIFF | Z/3054 | +5.626 | +5.976 | 3 | 86.7 | 358.9 | 0.25839 | 0.125608 | 0.000379469
2 x BRIDGING-COLUMN STIFF | Z/3620 | +5.625 | +5.975 | 4.4 | 86.4 | 549.3 | 0.392812 | 0.192248 | 0.000579389
BRIDGING-COLUMN STIFF | Z/3144 | +5.602 | +5.952 | 3.7 | 86.4 | 441.3 | 0.316564 | 0.154448 | 0.000465989
BRIDGING-COLUMN STIFF | Z/3144 | +5.580 | +5.930 | 3.7 | 86.4 | 441.3 | 0.316564 | 0.154448 | 0.000465989
BRIDGING-COLUMN STIFF | Z/3142 | +5.626 | +5.976 | 3.7 | 86.4 | 441.3 | 0.316564 | 0.154448 | 0.000465989
3 x BRIDGING-COLUMN STIFF | Z/3052 | +5.626 | +5.976 | 3 | 86.7 | 358.9 | 0.25839 | 0.125608 | 0.000379469
BRIDGING-COLUMN STIFF | Z/3140 | +5.626 | +5.976 | 3.7 | 86.4 | 441.3 | 0.316564 | 0.154448 | 0.000465989
BRIDGING-COLUMN STIFF | Z/3138 | +5.626 | +5.976 | 3.7 | 86.4 | 441.3 | 0.316564 | 0.154448 | 0.000465989
BRIDGING-COLUMN STIFF | Z/3050 | +5.626 | +5.976 | 3 | 86.7 | 358.9 | 0.25839 | 0.125608 | 0.000379469
BRIDGING-COLUMN STIFF | Z/3048 | +5.626 | +5.976 | 3 | 86.7 | 358.9 | 0.25839 | 0.125608 | 0.000379469
BRIDGING-COLUMN STIFF | Z/3046 | +5.626 | +5.976 | 3 | 86.7 | 358.9 | 0.25839 | 0.125608 | 0.000379469
BRIDGING-COLUMN STIFF | Z/3621 | +5.625 | +5.975 | 4.4 | 86.4 | 549.3 | 0.392812 | 0.192248 | 0.000579389
2 x BRIDGING-COLUMN STIFF | Z/3619 | +5.625 | +5.975 | 4.4 | 86.4 | 549.3 | 0.392812 | 0.192248 | 0.000579389
BRIDGING-COLUMN STIFF | Z/3143 | +5.626 | +5.976 | 3.7 | 86.4 | 441.3 | 0.316564 | 0.154448 | 0.000465989
BRIDGING-COLUMN STIFF | Z/3143 | +5.602 | +5.952 | 3.7 | 86.4 | 441.3 | 0.316564 | 0.154448 | 0.000465989
BRIDGING-COLUMN STIFF | Z/3143 | +5.580 | +5.930 | 3.7 | 86.4 | 441.3 | 0.316564 | 0.154448 | 0.000465989
BRIDGING-COLUMN STIFF | Z/3141 | +5.626 | +5.976 | 3.7 | 86.4 | 441.3 | 0.316564 | 0.154448 | 0.000465989
BRIDGING-COLUMN STIFF | Z/3139 | +5.626 | +5.976 | 3.7 | 86.4 | 441.3 | 0.316564 | 0.154448 | 0.000465989
BRIDGING-COLUMN STIFF | Z/3137 | +5.626 | +5.976 | 3.7 | 86.4 | 441.3 | 0.316564 | 0.154448 | 0.000465989
3 x BRIDGING-COLUMN STIFF | Z/3053 | +5.626 | +5.976 | 3 | 86.7 | 358.9 | 0.25839 | 0.125608 | 0.000379469
3 x BRIDGING-COLUMN STIFF | Z/3051 | +5.626 | +5.976 | 3 | 86.7 | 358.9 | 0.25839 | 0.125608 | 0.000379469
BRIDGING-COLUMN STIFF | Z/3049 | +5.626 | +5.976 | 3 | 86.7 | 358.9 | 0.25839 | 0.125608 | 0.000379469
BRIDGING-COLUMN STIFF | Z/3047 | +5.626 | +5.976 | 3 | 86.7 | 358.9 | 0.25839 | 0.125608 | 0.000379469
BRIDGING-COLUMN STIFF | Z/3045 | +5.626 | +5.976 | 3 | 86.7 | 358.9 | 0.25839 | 0.125608 | 0.000379469

# IfcPlate: PLT3*359.6 (12)
In: Undefined
Description: PLT3*359.6; Material: STEEL/450
Tekla Common - Phase: 1; Class: 1
Tekla Quantity - Weight: 5.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.2 m2; Net surface area: 0.4 m2; Height: 359.6 mm; Width: 3 mm; Length: 731.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 359.592 mm; NetArea: 0.464623 m2; GrossArea: 0.263073 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000686935 m3; GrossVolume: 0.000702217 m3
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation
2 x BB TRUSS BRACKET | Z/3624 | +5.610 | +6.032
2 x BB TRUSS BRACKET | Z/3623 | +5.610 | +6.032
2 x BB TRUSS BRACKET | Z/3624 | +5.629 | +6.051
2 x BB TRUSS BRACKET | Z/3623 | +5.629 | +6.051
2 x BB TRUSS BRACKET | Z/3624 | +5.646 | +6.068
2 x BB TRUSS BRACKET | Z/3623 | +5.646 | +6.068

# IfcPlate: PLT3*385.3 (6)
In: Undefined
Description: PLT3*385.3; Material: STEEL/450
Tekla Common - Phase: 1; Class: 1
Tekla Quantity - Weight: 4.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.4 m2; Net surface area: 0.4 m2; Height: 385.3 mm; Width: 3 mm; Length: 666.5 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 385.311 mm; NetArea: 0.371675 m2; GrossArea: 0.256798 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000548417 m3; GrossVolume: 0.000548417 m3
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation
BB TRUSS BRACKET | Z/3146 | +5.637 | +6.023
BB TRUSS BRACKET | Z/3146 | +5.632 | +6.017
BB TRUSS BRACKET | Z/3146 | +5.628 | +6.013
BB TRUSS BRACKET | Z/3145 | +5.637 | +6.023
BB TRUSS BRACKET | Z/3145 | +5.632 | +6.017
BB TRUSS BRACKET | Z/3145 | +5.628 | +6.013

# IfcPlate: PLT3*426.1 (36)
In: Undefined
Description: PLT3*426.1; Material: STEEL/450
Tekla Common - Phase: 1; Class: 11
Tekla Quantity - Weight: 5.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.2 m2; Net surface area: 0.4 m2; Height: 426.1 mm; Width: 3 mm; Length: 656.1 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - NetArea: 0.449082 m2; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Width (mm) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
3 x PLATE | Z/1287 | +5.571 | +5.998 | 426.096 | 0.279571 | 0.000664571
PLATE | Z/3109 | +5.571 | +5.998 | 426.096 | 0.279571 | 0.000664571
3 x PLATE | Z/1287 | +5.590 | +6.017 | 426.096 | 0.279571 | 0.000664571
PLATE | Z/3107 | +5.590 | +6.017 | 426.096 | 0.279571 | 0.000664571
3 x PLATE | Z/1287 | +5.607 | +6.034 | 426.096 | 0.279571 | 0.000664571
PLATE | Z/3105 | +5.607 | +6.034 | 426.096 | 0.279571 | 0.000664571
PLATE | Z/3101 | +5.571 | +5.998 | 426.096 | 0.279571 | 0.000664571
PLATE | Z/3099 | +5.590 | +6.017 | 426.096 | 0.279571 | 0.000664571
PLATE | Z/3096 | +5.607 | +6.034 | 426.096 | 0.279571 | 0.000664571
PLATE | Z/3094 | +5.571 | +5.998 | 426.096 | 0.279571 | 0.000664571
PLATE | Z/3092 | +5.590 | +6.017 | 426.096 | 0.279571 | 0.000664571
PLATE | Z/3090 | +5.607 | +6.034 | 426.096 | 0.279571 | 0.000664571
3 x PLATE | Z/1289 | +5.607 | +6.034 | 426.082 | 0.27956 | 0.000664572
3 x PLATE | Z/1289 | +5.590 | +6.017 | 426.082 | 0.27956 | 0.000664572
3 x PLATE | Z/1289 | +5.571 | +5.998 | 426.082 | 0.27956 | 0.000664572
PLATE | Z/3108 | +5.571 | +5.998 | 426.082 | 0.27956 | 0.000664572
PLATE | Z/3106 | +5.590 | +6.017 | 426.082 | 0.27956 | 0.000664572
PLATE | Z/3104 | +5.607 | +6.034 | 426.082 | 0.27956 | 0.000664572
PLATE | Z/3100 | +5.571 | +5.998 | 426.082 | 0.27956 | 0.000664572
PLATE | Z/3097 | +5.590 | +6.017 | 426.082 | 0.27956 | 0.000664572
PLATE | Z/3095 | +5.607 | +6.034 | 426.082 | 0.27956 | 0.000664572
PLATE | Z/3093 | +5.571 | +5.998 | 426.082 | 0.27956 | 0.000664572
PLATE | Z/3091 | +5.590 | +6.017 | 426.082 | 0.27956 | 0.000664572
PLATE | Z/3089 | +5.607 | +6.034 | 426.082 | 0.27956 | 0.000664572

# IfcPlate: PLT3*565.6 (24)
In: Undefined
Description: PLT3*565.6; Material: STEEL/450
Tekla Common - Phase: 1; Class: 11
Tekla Quantity - Weight: 8.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.9 m2; Height: 565.6 mm; Width: 3 mm; Length: 853.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - NetArea: 0.754232 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00111964 m3; GrossVolume: 0.00111964 m3
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Width (mm) | GrossArea (m2)
2 x PLATE | Z/1542 | +5.457 | +6.032 | 565.637 | 0.482806
PLATE | Z/3166 | +5.457 | +6.032 | 565.637 | 0.482806
PLATE | Z/1542 | +5.451 | +6.027 | 565.637 | 0.482806
PLATE | Z/3164 | +5.451 | +6.027 | 565.637 | 0.482806
PLATE | Z/1542 | +5.447 | +6.023 | 565.637 | 0.482806
PLATE | Z/3162 | +5.447 | +6.023 | 565.637 | 0.482806
PLATE | Z/3160 | +5.457 | +6.032 | 565.637 | 0.482806
PLATE | Z/1542 | +5.476 | +6.052 | 565.637 | 0.482806
PLATE | Z/3160 | +5.476 | +6.052 | 565.637 | 0.482806
PLATE | Z/1542 | +5.493 | +6.069 | 565.637 | 0.482806
PLATE | Z/3158 | +5.493 | +6.069 | 565.637 | 0.482806
2 x PLATE | Z/1543 | +5.457 | +6.032 | 565.634 | 0.482802
PLATE | Z/1543 | +5.451 | +6.027 | 565.634 | 0.482802
PLATE | Z/1543 | +5.447 | +6.023 | 565.634 | 0.482802
PLATE | Z/3165 | +5.457 | +6.032 | 565.634 | 0.482802
PLATE | Z/3163 | +5.451 | +6.027 | 565.634 | 0.482802
PLATE | Z/3161 | +5.447 | +6.023 | 565.634 | 0.482802
PLATE | Z/3159 | +5.457 | +6.032 | 565.634 | 0.482802
PLATE | Z/1543 | +5.476 | +6.052 | 565.634 | 0.482802
PLATE | Z/3159 | +5.476 | +6.052 | 565.634 | 0.482802
PLATE | Z/1543 | +5.493 | +6.069 | 565.634 | 0.482802
PLATE | Z/3157 | +5.493 | +6.069 | 565.634 | 0.482802

# IfcPlate: PLT3*606.1 (12)
In: Undefined
Description: PLT3*606.1; Material: STEEL/450
Tekla Common - Phase: 1; Class: 11
Tekla Quantity - Weight: 10.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.9 m2; Height: 606.1 mm; Width: 3 mm; Length: 905.1 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - NetArea: 0.865061 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00128499 m3; GrossVolume: 0.00128499 m3
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Width (mm) | GrossArea (m2)
PLATE | Z/666 | +5.455 | +6.042 | 606.065 | 0.548538
PLATE | Z/3633 | +5.455 | +6.042 | 606.065 | 0.548538
PLATE | Z/666 | +5.475 | +6.061 | 606.065 | 0.548538
PLATE | Z/3631 | +5.475 | +6.061 | 606.065 | 0.548538
PLATE | Z/666 | +5.492 | +6.078 | 606.065 | 0.548538
PLATE | Z/3629 | +5.492 | +6.078 | 606.065 | 0.548538
PLATE | Z/1432 | +5.492 | +6.078 | 606.062 | 0.548534
PLATE | Z/1432 | +5.475 | +6.061 | 606.062 | 0.548534
PLATE | Z/1432 | +5.455 | +6.042 | 606.062 | 0.548534
PLATE | Z/3632 | +5.455 | +6.042 | 606.062 | 0.548534
PLATE | Z/3630 | +5.475 | +6.061 | 606.062 | 0.548534
PLATE | Z/3628 | +5.492 | +6.078 | 606.062 | 0.548534
