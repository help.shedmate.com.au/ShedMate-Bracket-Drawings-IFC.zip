Properties of the parts of a building model (IFC2X3), part 2 of 3

# IfcElementAssembly (1320)
Name | ASSEMBLY_POS = Assembly/Cast unit Mark | Assembly/Cast unit weight (kg) | Assembly/Cast unit bottom elevation | Assembly/Cast unit top elevation | Width (mm) | ASSEMBLY_POSITION_CODE = Assembly/Cast unit position code
2 x BB TRUSS BRACKET | Z/3148 | 4.6 | +5.671 | +6.042 | 147.699 | C300-C300/BB300(TH96)-BB300(TH120)
2 x BB TRUSS BRACKET | Z/3147 | 4.6 | +5.671 | +6.042 | 147.699 | C300-C300/BB300(TH96)-BB300(TH120)
BB TRUSS BRACKET | Z/3058 | 2.9 | +5.693 | +6.006 | 147.999 | C250-C250/BB300(TH96)-BB300(TH120)
BB TRUSS BRACKET | Z/3057 | 2.9 | +5.693 | +6.006 | 147.999 | C250-C250/BB300(TH96)-BB300(TH120)
BB TRUSS BRACKET | Z/2971 | 1.7 | +5.744 | +5.978 | 147.999 | C200-C200/BB300(TH96)-BB300(TH120)
BB TRUSS BRACKET | Z/2970 | 1.7 | +5.744 | +5.978 | 147.999 | C200-C200/BB300(TH96)-BB300(TH120)
TH | Z/422 | 2.9 | +5.321 | +5.471 | 150 | C300-C300/BB300(TH96)-BB300(TH120)
BEAM | Z/3154 | 23.6 | +5.671 | +5.971 | 96 | C300-C300/BB300(TH96)-BB300(TH120)
PLATE | Z/1542 | 8.9 | +5.476 | +6.052 | 99 | C300/BB300(TH96)-BB300(TH120)
2 x TH | Z/422 | 2.9 | +6.085 | +6.199 | 150 | C300-C300/BB300(TH96)-BB300(TH120)
FASCIA | Z/420 | 9.4 | +5.824 | +5.976 | 64 | C300-C300/BB300(TH96)-BB300(TH120)
TH | Z/405 | 2.9 | +5.428 | +5.578 | 150 | C250-C250/BB300(TH96)-BB300(TH120)
PLATE | Z/1287 | 5.2 | +5.590 | +6.017 | 79 | C250/BB300(TH96)-BB300(TH120)
2 x TH | Z/405 | 2.9 | +6.090 | +6.204 | 150 | C250-C250/BB300(TH96)-BB300(TH120)
FASCIA | Z/409 | 8.1 | +5.823 | +5.975 | 64 | C250-C250/BB300(TH96)-BB300(TH120)
BEAM | Z/3083 | 19 | +5.675 | +5.975 | 96 | C250-C250/BB300(TH96)-BB300(TH120)
GIRT | Z/3000 | 4.6 | +5.396 | +5.546 | 150 | C200-C200/BB300(TH96)-BB300(TH120)
PLATE | Z/548 | 3.1 | +5.675 | +5.989 | 79 | C200/BB300(TH96)-BB300(TH120)
2 x PURLIN | Z/3001 | 4.6 | +6.042 | +6.155 | 150 | C200-C200/BB300(TH96)-BB300(TH120)
FASCIA | Z/426 | 8.9 | +5.824 | +5.976 | 64 | C200-C200/BB300(TH96)-BB300(TH120)
BRIDGING BEAM | Z/3007 | 19 | +5.676 | +5.976 | 96 | C200-C200/BB300(TH96)-BB300(TH120)
BEAM | Z/3153 | 23.6 | +5.676 | +5.976 | 96 | C300-C300/BB300(TH75)-BB300(TH96)
BRIDGING U-PLATE | Z/3151 | 3.6 | +5.672 | +5.980 | 100 | C300-C300/BB300(TH75)-BB300(TH96)
COLUMN | Z/3116 | 14 | +4.860 | +5.976 | 96 | C300/BB300(TH75)-BB300(TH96)
COLUMN | Z/3039 | 8.9 | +4.860 | +5.975 | 76 | C250/BB300(TH75)-BB300(TH96)
COLUMN | Z/2642 | 7.9 | +4.860 | +5.976 | 76 | C200/BB300(TH75)-BB300(TH96)
BEAM | Z/3082 | 19 | +5.675 | +5.975 | 96 | C250-C250/BB300(TH75)-BB300(TH96)
BRIDGING BEAM | Z/3006 | 19 | +5.676 | +5.976 | 96 | C200-C200/BB300(TH75)-BB300(TH96)
2 x FASCIA BRACKET | Z/2553 | 0.3 | +5.819 | +5.980 | 161 | C200/BB300(TH75)-BB300(TH96)
FASCIA BRACKET | Z/2553 | 0.3 | +5.819 | +5.980 | 161 | C200-C200/BB300(TH75)-BB300(TH96)
BRIDGING U-PLATE | Z/3064 | 3.6 | +5.671 | +5.979 | 100 | C250-C250/BB300(TH75)-BB300(TH96)
BRIDGING U-PLATE | Z/2977 | 3.6 | +5.672 | +5.980 | 308 | C200-C200/BB300(TH75)-BB300(TH96)
2 x RAFTER | Z/2998 | 3.9 | +5.762 | +6.075 | 76 | C200-C200/BB300(TH75)-BB300(TH96)
FASCIA STIFFENER | Z/237 | 0.8 | +5.676 | +5.976 | 3 | C300-C300/BB300(TH75)-BB300(TH96)
4 x RAFTER | Z/430 | 8.9 | +5.688 | +6.130 | 96 | C300/BB300(TH75)-BB300(TH96)
2 x RAFTER | Z/2599 | 8.9 | +5.688 | +6.130 | 96 | C300-C300/BB300(TH75)-BB300(TH96)
2 x FASCIA BRACKET | Z/52 | 0.2 | +5.821 | +5.979 | 157.2 | C300/BB300(TH75)-BB300(TH96)
FASCIA BRACKET | Z/52 | 0.2 | +5.821 | +5.979 | 157.2 | C300-C300/BB300(TH75)-BB300(TH96)
COLUMN | Z/3167 | 14 | +4.860 | +5.976 | 96 | C300/BB300(TH75)-BB300(TH96)
4 x RAFTER | Z/289 | 5.9 | +5.722 | +6.123 | 76 | C250/BB300(TH75)-BB300(TH96)
2 x RAFTER | Z/2591 | 5.9 | +5.722 | +6.123 | 76 | C250-C250/BB300(TH75)-BB300(TH96)
2 x FASCIA BRACKET | Z/52 | 0.2 | +5.821 | +5.978 | 157.2 | C250/BB300(TH75)-BB300(TH96)
FASCIA BRACKET | Z/52 | 0.2 | +5.821 | +5.978 | 157.2 | C250-C250/BB300(TH75)-BB300(TH96)
COLUMN | Z/3110 | 8.9 | +4.860 | +5.975 | 76 | C250/BB300(TH75)-BB300(TH96)
FASCIA STIFFENER | Z/237 | 0.8 | +5.675 | +5.975 | 3 | C250-C250/BB300(TH75)-BB300(TH96)
4 x RAFTER | Z/247 | 3.9 | +5.762 | +6.075 | 76 | C200/BB300(TH75)-BB300(TH96)
COLUMN | Z/3036 | 7.9 | +4.860 | +5.976 | 76 | C200/BB300(TH75)-BB300(TH96)
FASCIA STIFFENER | Z/237 | 0.8 | +5.676 | +5.976 | 3 | C200-C200/BB300(TH75)-BB300(TH96)
PLATE | Z/3158 | 10.6 | +5.493 | +6.069 | 244 | C300/BB300(TH75)-BB300(TH96)
BRIDGING-COLUMN STIFF | Z/3138 | 5.4 | +5.626 | +5.976 | 228 | C300/BB300(TH75)-BB300(TH96)
PLATE | Z/3096 | 7.1 | +5.607 | +6.034 | 224 | C250/BB300(TH75)-BB300(TH96)
BRIDGING-COLUMN STIFF | Z/3052 | 4.8 | +5.626 | +5.976 | 209.2 | C250/BB300(TH75)-BB300(TH96)
PLATE | Z/3019 | 4.8 | +5.691 | +6.006 | 224 | C200/BB300(TH75)-BB300(TH96)
BRIDGING-COLUMN STIFF | Z/2966 | 4.4 | +5.626 | +5.976 | 209.2 | C200/BB300(TH75)-BB300(TH96)
BB TRUSS BRACKET | Z/2971 | 1.7 | +5.761 | +5.995 | 147.999 | C200-C200/BB300(TH75)-BB300(TH96)
BB TRUSS BRACKET | Z/2970 | 1.7 | +5.761 | +5.995 | 147.999 | C200-C200/BB300(TH75)-BB300(TH96)
TH | Z/421 | 2.9 | +5.333 | +5.458 | 125 | C300-C300/BB300(TH75)-BB300(TH96)
BEAM | Z/3154 | 23.6 | +5.676 | +5.976 | 96 | C300-C300/BB300(TH75)-BB300(TH96)
PLATE | Z/1542 | 8.9 | +5.493 | +6.069 | 99 | C300/BB300(TH75)-BB300(TH96)
2 x BB TRUSS BRACKET | Z/3148 | 4.6 | +5.688 | +6.059 | 147.699 | C300-C300/BB300(TH75)-BB300(TH96)
2 x BB TRUSS BRACKET | Z/3147 | 4.6 | +5.688 | +6.059 | 147.699 | C300-C300/BB300(TH75)-BB300(TH96)
2 x TH | Z/421 | 2.9 | +6.105 | +6.195 | 125 | C300-C300/BB300(TH75)-BB300(TH96)
FASCIA | Z/420 | 9.4 | +5.824 | +5.976 | 64 | C300-C300/BB300(TH75)-BB300(TH96)
TH | Z/404 | 2.9 | +5.441 | +5.566 | 125 | C250-C250/BB300(TH75)-BB300(TH96)
PLATE | Z/1287 | 5.2 | +5.607 | +6.034 | 79 | C250/BB300(TH75)-BB300(TH96)
BB TRUSS BRACKET | Z/3058 | 2.9 | +5.710 | +6.023 | 147.999 | C250-C250/BB300(TH75)-BB300(TH96)
BB TRUSS BRACKET | Z/3057 | 2.9 | +5.710 | +6.023 | 147.999 | C250-C250/BB300(TH75)-BB300(TH96)
2 x TH | Z/404 | 2.9 | +6.110 | +6.200 | 125 | C250-C250/BB300(TH75)-BB300(TH96)
FASCIA | Z/409 | 8.1 | +5.823 | +5.975 | 64 | C250-C250/BB300(TH75)-BB300(TH96)
BEAM | Z/3083 | 19 | +5.675 | +5.975 | 96 | C250-C250/BB300(TH75)-BB300(TH96)
GIRT | Z/2995 | 4.6 | +5.408 | +5.533 | 125 | C200-C200/BB300(TH75)-BB300(TH96)
PLATE | Z/548 | 3.1 | +5.692 | +6.006 | 79 | C200/BB300(TH75)-BB300(TH96)
2 x PURLIN | Z/2999 | 4.6 | +6.062 | +6.152 | 125 | C200-C200/BB300(TH75)-BB300(TH96)
FASCIA | Z/426 | 8.9 | +5.824 | +5.976 | 64 | C200-C200/BB300(TH75)-BB300(TH96)
BRIDGING BEAM | Z/3007 | 19 | +5.676 | +5.976 | 96 | C200-C200/BB300(TH75)-BB300(TH96)
COLUMN | Z/3041 | 8.9 | +4.860 | +5.976 | 76 | C250/BB250(TH120)-BB300(TH75)
COLUMN | Z/2648 | 7.9 | +4.860 | +5.976 | 76 | C200/BB250(TH120)-BB300(TH75)
COLUMN | Z/2513 | 6.2 | +4.860 | +5.976 | 64 | C150/BB250(TH120)-BB300(TH75)
2 x FASCIA BRACKET | Z/2556 | 0.6 | +5.819 | +5.980 | 161 | C200/BB250(TH120)-BB300(TH75)
FASCIA BRACKET | Z/2556 | 0.6 | +5.819 | +5.980 | 161 | C200-C200/BB250(TH120)-BB300(TH75)
BRIDGING U-PLATE | Z/3063 | 2.9 | +5.683 | +5.945 | 80 | C250-C250/BB250(TH120)-BB300(TH75)
BEAM | Z/3070 | 15.3 | +5.687 | +5.941 | 76 | C250-C250/BB250(TH120)-BB300(TH75)
2 x RAFTER | Z/2591 | 5.9 | +5.686 | +6.086 | 76 | C250-C250/BB250(TH120)-BB300(TH75)
BRIDGING U-PLATE | Z/2976 | 2.9 | +5.708 | +5.970 | 262 | C200-C200/BB250(TH120)-BB300(TH75)
BRIDGING BEAM | Z/3004 | 15.3 | +5.712 | +5.966 | 76 | C200-C200/BB250(TH120)-BB300(TH75)
2 x RAFTER | Z/2998 | 3.9 | +5.725 | +6.038 | 76 | C200-C200/BB250(TH120)-BB300(TH75)
BRIDGING U-PLATE | Z/2617 | 2.9 | +5.718 | +5.980 | 262 | C150-C150/BB250(TH120)-BB300(TH75)
2 x RAFTER | Z/2555 | 2.6 | +5.764 | +6.010 | 64 | C150-C150/BB250(TH120)-BB300(TH75)
2 x FASCIA BRACKET | Z/2531 | 0.3 | +5.821 | +5.978 | 157.2 | C250/BB250(TH120)-BB300(TH75)
FASCIA BRACKET | Z/2531 | 0.3 | +5.821 | +5.978 | 157.2 | C250-C250/BB250(TH120)-BB300(TH75)
COLUMN | Z/3112 | 8.9 | +4.860 | +5.976 | 76 | C250/BB250(TH120)-BB300(TH75)
4 x RAFTER | Z/289 | 5.9 | +5.686 | +6.086 | 76 | C250/BB250(TH120)-BB300(TH75)
FASCIA STIFFENER | Z/223 | 0.6 | +5.687 | +5.941 | 3 | C250-C250/BB250(TH120)-BB300(TH75)
4 x RAFTER | Z/247 | 3.9 | +5.725 | +6.038 | 76 | C200/BB250(TH120)-BB300(TH75)
COLUMN | Z/3038 | 7.9 | +4.860 | +5.976 | 76 | C200/BB250(TH120)-BB300(TH75)
FASCIA STIFFENER | Z/223 | 0.6 | +5.712 | +5.966 | 3 | C200-C200/BB250(TH120)-BB300(TH75)
BEAM | Z/2620 | 15.3 | +5.722 | +5.976 | 76 | C150-C150/BB250(TH120)-BB300(TH75)
4 x RAFTER | Z/222 | 2.6 | +5.764 | +6.010 | 64 | C150/BB250(TH120)-BB300(TH75)
BEAM | Z/2619 | 15.3 | +5.722 | +5.976 | 76 | C150-C150/BB250(TH120)-BB300(TH75)
FASCIA STIFFENER | Z/223 | 0.6 | +5.722 | +5.976 | 3 | C150-C150/BB250(TH120)-BB300(TH75)
2 x FASCIA BRACKET | Z/2531 | 0.3 | +5.821 | +5.978 | 157.2 | C150/BB250(TH120)-BB300(TH75)
FASCIA BRACKET | Z/2531 | 0.3 | +5.821 | +5.978 | 157.2 | C150-C150/BB250(TH120)-BB300(TH75)
COLUMN | Z/2637 | 6.2 | +4.860 | +5.976 | 64 | C150/BB250(TH120)-BB300(TH75)
PLATE | Z/3094 | 6.7 | +5.571 | +5.998 | 224 | C250/BB250(TH120)-BB300(TH75)
BRIDGING-COLUMN STIFF | Z/3050 | 4.4 | +5.626 | +5.976 | 209.2 | C250/BB250(TH120)-BB300(TH75)
PLATE | Z/3017 | 4.6 | +5.656 | +5.970 | 224 | C200/BB250(TH120)-BB300(TH75)
BRIDGING-COLUMN STIFF | Z/2964 | 4.1 | +5.626 | +5.976 | 209.2 | C200/BB250(TH120)-BB300(TH75)
PLATE | Z/2632 | 3.9 | +5.656 | +5.959 | 212 | C150/BB250(TH120)-BB300(TH75)
BRIDGING-COLUMN STIFF | Z/2607 | 3.4 | +5.626 | +5.976 | 197.2 | C150/BB250(TH120)-BB300(TH75)
BB TRUSS BRACKET | Z/3055 | 3.1 | +5.685 | +5.986 | 456.661 | C250-C250/BB250(TH120)-BB300(TH75)
BB TRUSS BRACKET | Z/3056 | 3.1 | +5.685 | +5.986 | 147.999 | C250-C250/BB250(TH120)-BB300(TH75)
BB TRUSS BRACKET | Z/2969 | 1.9 | +5.717 | +5.958 | 147.999 | C200-C200/BB250(TH120)-BB300(TH75)
BB TRUSS BRACKET | Z/2968 | 1.9 | +5.717 | +5.958 | 147.999 | C200-C200/BB250(TH120)-BB300(TH75)
BB TRUSS BRACKET | Z/2610 | 1.2 | +5.768 | +5.948 | 147.999 | C150-C150/BB250(TH120)-BB300(TH75)
BB TRUSS BRACKET | Z/2611 | 1.2 | +5.768 | +5.948 | 147.999 | C150-C150/BB250(TH120)-BB300(TH75)
TH | Z/406 | 2.9 | +5.421 | +5.586 | 165 | C250-C250/BB250(TH120)-BB300(TH75)
FASCIA | Z/400 | 7.9 | +5.824 | +5.976 | 64 | C250-C250/BB250(TH120)-BB300(TH75)
2 x TH | Z/406 | 2.9 | +6.035 | +6.175 | 165 | C250-C250/BB250(TH120)-BB300(TH75)
PLATE | Z/1287 | 5.2 | +5.571 | +5.998 | 79 | C250/BB250(TH120)-BB300(TH75)
BEAM | Z/3071 | 15.3 | +5.687 | +5.941 | 76 | C250-C250/BB250(TH120)-BB300(TH75)
GIRT | Z/3002 | 4.6 | +5.388 | +5.553 | 165 | C200-C200/BB250(TH120)-BB300(TH75)
PLATE | Z/548 | 3.1 | +5.656 | +5.970 | 79 | C200/BB250(TH120)-BB300(TH75)
2 x PURLIN | Z/3003 | 4.6 | +6.021 | +6.160 | 165 | C200-C200/BB250(TH120)-BB300(TH75)
FASCIA | Z/426 | 8.9 | +5.824 | +5.976 | 64 | C200-C200/BB250(TH120)-BB300(TH75)
BRIDGING BEAM | Z/3005 | 15.3 | +5.712 | +5.966 | 76 | C200-C200/BB250(TH120)-BB300(TH75)
TH | Z/389 | 2.9 | +5.429 | +5.594 | 165 | C150-C150/BB250(TH120)-BB300(TH75)
PLATE | Z/2508 | 2.5 | +5.656 | +5.959 | 67 | C150/BB250(TH120)-BB300(TH75)
2 x TH | Z/389 | 2.9 | +5.992 | +6.132 | 165 | C150-C150/BB250(TH120)-BB300(TH75)
FASCIA | Z/386 | 7.7 | +5.824 | +5.976 | 64 | C150-C150/BB250(TH120)-BB300(TH75)
COLUMN | Z/3040 | 8.9 | +4.860 | +5.976 | 76 | C250/BB250(TH96)-BB250(TH120)
COLUMN | Z/2643 | 7.9 | +4.860 | +5.976 | 76 | C200/BB250(TH96)-BB250(TH120)
COLUMN | Z/2512 | 6.2 | +4.860 | +5.951 | 64 | C150/BB250(TH96)-BB250(TH120)
2 x FASCIA BRACKET | Z/2554 | 0.5 | +5.819 | +5.980 | 161 | C200/BB250(TH96)-BB250(TH120)
FASCIA BRACKET | Z/2554 | 0.5 | +5.819 | +5.980 | 161 | C200-C200/BB250(TH96)-BB250(TH120)
BRIDGING U-PLATE | Z/3062 | 2.9 | +5.698 | +5.960 | 80 | C250-C250/BB250(TH96)-BB250(TH120)
BEAM | Z/3070 | 15.3 | +5.702 | +5.956 | 76 | C250-C250/BB250(TH96)-BB250(TH120)
2 x RAFTER | Z/2591 | 5.9 | +5.706 | +6.106 | 76 | C250-C250/BB250(TH96)-BB250(TH120)
BRIDGING U-PLATE | Z/2975 | 2.9 | +5.718 | +5.980 | 262 | C200-C200/BB250(TH96)-BB250(TH120)
BRIDGING BEAM | Z/3004 | 15.3 | +5.722 | +5.976 | 76 | C200-C200/BB250(TH96)-BB250(TH120)
2 x RAFTER | Z/2998 | 3.9 | +5.745 | +6.058 | 76 | C200-C200/BB250(TH96)-BB250(TH120)
BRIDGING U-PLATE | Z/2616 | 2.9 | +5.693 | +5.955 | 262 | C150-C150/BB250(TH96)-BB250(TH120)
2 x RAFTER | Z/2555 | 2.6 | +5.759 | +6.004 | 64 | C150-C150/BB250(TH96)-BB250(TH120)
2 x FASCIA BRACKET | Z/2520 | 0.3 | +5.821 | +5.978 | 157.2 | C250/BB250(TH96)-BB250(TH120)
FASCIA BRACKET | Z/2520 | 0.3 | +5.821 | +5.978 | 157.2 | C250-C250/BB250(TH96)-BB250(TH120)
COLUMN | Z/3111 | 8.9 | +4.860 | +5.976 | 76 | C250/BB250(TH96)-BB250(TH120)
4 x RAFTER | Z/289 | 5.9 | +5.706 | +6.106 | 76 | C250/BB250(TH96)-BB250(TH120)
FASCIA STIFFENER | Z/223 | 0.6 | +5.702 | +5.956 | 3 | C250-C250/BB250(TH96)-BB250(TH120)
4 x RAFTER | Z/247 | 3.9 | +5.745 | +6.058 | 76 | C200/BB250(TH96)-BB250(TH120)
COLUMN | Z/3037 | 7.9 | +4.860 | +5.976 | 76 | C200/BB250(TH96)-BB250(TH120)
FASCIA STIFFENER | Z/223 | 0.6 | +5.722 | +5.976 | 3 | C200-C200/BB250(TH96)-BB250(TH120)
BEAM | Z/2620 | 15.3 | +5.697 | +5.951 | 76 | C150-C150/BB250(TH96)-BB250(TH120)
4 x RAFTER | Z/222 | 2.6 | +5.759 | +6.004 | 64 | C150/BB250(TH96)-BB250(TH120)
BEAM | Z/2619 | 15.3 | +5.697 | +5.951 | 76 | C150-C150/BB250(TH96)-BB250(TH120)
FASCIA STIFFENER | Z/223 | 0.6 | +5.697 | +5.951 | 3 | C150-C150/BB250(TH96)-BB250(TH120)
2 x FASCIA BRACKET | Z/2520 | 0.3 | +5.797 | +5.954 | 157.2 | C150/BB250(TH96)-BB250(TH120)
FASCIA BRACKET | Z/2520 | 0.3 | +5.797 | +5.954 | 157.2 | C150-C150/BB250(TH96)-BB250(TH120)
COLUMN | Z/2636 | 6.2 | +4.860 | +5.951 | 64 | C150/BB250(TH96)-BB250(TH120)
PLATE | Z/3092 | 6.7 | +5.590 | +6.017 | 224 | C250/BB250(TH96)-BB250(TH120)
BRIDGING-COLUMN STIFF | Z/3048 | 4.4 | +5.626 | +5.976 | 209.2 | C250/BB250(TH96)-BB250(TH120)
PLATE | Z/3015 | 4.6 | +5.675 | +5.989 | 224 | C200/BB250(TH96)-BB250(TH120)
BRIDGING-COLUMN STIFF | Z/2962 | 4.1 | +5.626 | +5.976 | 209.2 | C200/BB250(TH96)-BB250(TH120)
PLATE | Z/2630 | 3.9 | +5.651 | +5.954 | 212 | C150/BB250(TH96)-BB250(TH120)
BRIDGING-COLUMN STIFF | Z/2607 | 3.4 | +5.601 | +5.951 | 197.2 | C150/BB250(TH96)-BB250(TH120)
BB TRUSS BRACKET | Z/3055 | 3.1 | +5.705 | +6.006 | 456.661 | C250-C250/BB250(TH96)-BB250(TH120)
BB TRUSS BRACKET | Z/3056 | 3.1 | +5.705 | +6.006 | 147.999 | C250-C250/BB250(TH96)-BB250(TH120)
BB TRUSS BRACKET | Z/2969 | 1.9 | +5.736 | +5.978 | 147.999 | C200-C200/BB250(TH96)-BB250(TH120)
BB TRUSS BRACKET | Z/2968 | 1.9 | +5.736 | +5.978 | 147.999 | C200-C200/BB250(TH96)-BB250(TH120)
BB TRUSS BRACKET | Z/2610 | 1.2 | +5.763 | +5.943 | 147.999 | C150-C150/BB250(TH96)-BB250(TH120)
BB TRUSS BRACKET | Z/2611 | 1.2 | +5.763 | +5.943 | 147.999 | C150-C150/BB250(TH96)-BB250(TH120)
TH | Z/405 | 2.9 | +5.428 | +5.578 | 150 | C250-C250/BB250(TH96)-BB250(TH120)
FASCIA | Z/400 | 7.9 | +5.824 | +5.976 | 64 | C250-C250/BB250(TH96)-BB250(TH120)
2 x TH | Z/405 | 2.9 | +6.056 | +6.170 | 150 | C250-C250/BB250(TH96)-BB250(TH120)
PLATE | Z/1287 | 5.2 | +5.590 | +6.017 | 79 | C250/BB250(TH96)-BB250(TH120)
BEAM | Z/3071 | 15.3 | +5.702 | +5.956 | 76 | C250-C250/BB250(TH96)-BB250(TH120)
GIRT | Z/3000 | 4.6 | +5.396 | +5.546 | 150 | C200-C200/BB250(TH96)-BB250(TH120)
PLATE | Z/548 | 3.1 | +5.675 | +5.989 | 79 | C200/BB250(TH96)-BB250(TH120)
2 x PURLIN | Z/3001 | 4.6 | +6.042 | +6.155 | 150 | C200-C200/BB250(TH96)-BB250(TH120)
FASCIA | Z/426 | 8.9 | +5.824 | +5.976 | 64 | C200-C200/BB250(TH96)-BB250(TH120)
BRIDGING BEAM | Z/3005 | 15.3 | +5.722 | +5.976 | 76 | C200-C200/BB250(TH96)-BB250(TH120)
TH | Z/388 | 2.9 | +5.437 | +5.587 | 150 | C150-C150/BB250(TH96)-BB250(TH120)
PLATE | Z/2507 | 2.5 | +5.651 | +5.954 | 67 | C150/BB250(TH96)-BB250(TH120)
2 x TH | Z/388 | 2.9 | +5.989 | +6.102 | 150 | C150-C150/BB250(TH96)-BB250(TH120)
FASCIA | Z/386 | 7.7 | +5.799 | +5.951 | 64 | C150-C150/BB250(TH96)-BB250(TH120)
COLUMN | Z/3039 | 8.9 | +4.860 | +5.976 | 76 | C250/BB250(TH75)-BB250(TH96)
COLUMN | Z/2642 | 7.9 | +4.860 | +5.976 | 76 | C200/BB250(TH75)-BB250(TH96)
COLUMN | Z/2509 | 5.9 | +4.860 | +5.930 | 64 | C150/BB250(TH75)-BB250(TH96)
2 x FASCIA BRACKET | Z/2553 | 0.3 | +5.819 | +5.980 | 161 | C200/BB250(TH75)-BB250(TH96)
FASCIA BRACKET | Z/2553 | 0.3 | +5.819 | +5.980 | 161 | C200-C200/BB250(TH75)-BB250(TH96)
BEAM | Z/3070 | 15.3 | +5.722 | +5.976 | 76 | C250-C250/BB250(TH75)-BB250(TH96)
BRIDGING U-PLATE | Z/3061 | 2.9 | +5.718 | +5.980 | 80 | C250-C250/BB250(TH75)-BB250(TH96)
2 x RAFTER | Z/2591 | 5.9 | +5.723 | +6.123 | 76 | C250-C250/BB250(TH75)-BB250(TH96)
BRIDGING U-PLATE | Z/2974 | 2.9 | +5.718 | +5.980 | 262 | C200-C200/BB250(TH75)-BB250(TH96)
BRIDGING BEAM | Z/3004 | 15.3 | +5.722 | +5.976 | 76 | C200-C200/BB250(TH75)-BB250(TH96)
2 x RAFTER | Z/2998 | 3.9 | +5.762 | +6.075 | 76 | C200-C200/BB250(TH75)-BB250(TH96)
BRIDGING U-PLATE | Z/2615 | 2.9 | +5.672 | +5.934 | 262 | C150-C150/BB250(TH75)-BB250(TH96)
2 x RAFTER | Z/2555 | 2.6 | +5.755 | +6.000 | 64 | C150-C150/BB250(TH75)-BB250(TH96)
2 x FASCIA BRACKET | Z/52 | 0.2 | +5.821 | +5.978 | 157.2 | C250/BB250(TH75)-BB250(TH96)
FASCIA BRACKET | Z/52 | 0.2 | +5.821 | +5.978 | 157.2 | C250-C250/BB250(TH75)-BB250(TH96)
COLUMN | Z/3110 | 8.9 | +4.860 | +5.976 | 76 | C250/BB250(TH75)-BB250(TH96)
4 x RAFTER | Z/289 | 5.9 | +5.723 | +6.123 | 76 | C250/BB250(TH75)-BB250(TH96)
FASCIA STIFFENER | Z/223 | 0.6 | +5.722 | +5.976 | 3 | C250-C250/BB250(TH75)-BB250(TH96)
4 x RAFTER | Z/247 | 3.9 | +5.762 | +6.075 | 76 | C200/BB250(TH75)-BB250(TH96)
COLUMN | Z/3036 | 7.9 | +4.860 | +5.976 | 76 | C200/BB250(TH75)-BB250(TH96)
FASCIA STIFFENER | Z/223 | 0.6 | +5.722 | +5.976 | 3 | C200-C200/BB250(TH75)-BB250(TH96)
BEAM | Z/2620 | 15.3 | +5.676 | +5.930 | 76 | C150-C150/BB250(TH75)-BB250(TH96)
4 x RAFTER | Z/222 | 2.6 | +5.755 | +6.000 | 64 | C150/BB250(TH75)-BB250(TH96)
BEAM | Z/2619 | 15.3 | +5.676 | +5.930 | 76 | C150-C150/BB250(TH75)-BB250(TH96)
FASCIA STIFFENER | Z/223 | 0.6 | +5.676 | +5.930 | 3 | C150-C150/BB250(TH75)-BB250(TH96)
2 x FASCIA BRACKET | Z/52 | 0.2 | +5.775 | +5.932 | 157.2 | C150/BB250(TH75)-BB250(TH96)
FASCIA BRACKET | Z/52 | 0.2 | +5.775 | +5.932 | 157.2 | C150-C150/BB250(TH75)-BB250(TH96)
COLUMN | Z/2633 | 5.9 | +4.860 | +5.930 | 64 | C150/BB250(TH75)-BB250(TH96)
PLATE | Z/3090 | 6.7 | +5.607 | +6.034 | 224 | C250/BB250(TH75)-BB250(TH96)
BRIDGING-COLUMN STIFF | Z/3046 | 4.4 | +5.626 | +5.976 | 209.2 | C250/BB250(TH75)-BB250(TH96)
PLATE | Z/3013 | 4.6 | +5.692 | +6.006 | 224 | C200/BB250(TH75)-BB250(TH96)
BRIDGING-COLUMN STIFF | Z/2962 | 4.1 | +5.626 | +5.976 | 209.2 | C200/BB250(TH75)-BB250(TH96)
PLATE | Z/2628 | 3.9 | +5.646 | +5.949 | 212 | C150/BB250(TH75)-BB250(TH96)
BRIDGING-COLUMN STIFF | Z/2607 | 3.4 | +5.580 | +5.930 | 197.2 | C150/BB250(TH75)-BB250(TH96)
BB TRUSS BRACKET | Z/3055 | 3.1 | +5.722 | +6.023 | 456.661 | C250-C250/BB250(TH75)-BB250(TH96)
BB TRUSS BRACKET | Z/2969 | 1.9 | +5.753 | +5.995 | 147.999 | C200-C200/BB250(TH75)-BB250(TH96)
BB TRUSS BRACKET | Z/2968 | 1.9 | +5.753 | +5.995 | 147.999 | C200-C200/BB250(TH75)-BB250(TH96)
BB TRUSS BRACKET | Z/2610 | 1.2 | +5.759 | +5.938 | 147.999 | C150-C150/BB250(TH75)-BB250(TH96)
BB TRUSS BRACKET | Z/2611 | 1.2 | +5.759 | +5.938 | 147.999 | C150-C150/BB250(TH75)-BB250(TH96)
TH | Z/404 | 2.9 | +5.441 | +5.566 | 125 | C250-C250/BB250(TH75)-BB250(TH96)
FASCIA | Z/400 | 7.9 | +5.824 | +5.976 | 64 | C250-C250/BB250(TH75)-BB250(TH96)
BB TRUSS BRACKET | Z/3056 | 3.1 | +5.722 | +6.023 | 147.999 | C250-C250/BB250(TH75)-BB250(TH96)
2 x TH | Z/404 | 2.9 | +6.076 | +6.166 | 125 | C250-C250/BB250(TH75)-BB250(TH96)
PLATE | Z/1287 | 5.2 | +5.607 | +6.034 | 79 | C250/BB250(TH75)-BB250(TH96)
BEAM | Z/3071 | 15.3 | +5.722 | +5.976 | 76 | C250-C250/BB250(TH75)-BB250(TH96)
GIRT | Z/2995 | 4.6 | +5.408 | +5.533 | 125 | C200-C200/BB250(TH75)-BB250(TH96)
PLATE | Z/548 | 3.1 | +5.692 | +6.006 | 79 | C200/BB250(TH75)-BB250(TH96)
2 x PURLIN | Z/2999 | 4.6 | +6.062 | +6.152 | 125 | C200-C200/BB250(TH75)-BB250(TH96)
FASCIA | Z/426 | 8.9 | +5.824 | +5.976 | 64 | C200-C200/BB250(TH75)-BB250(TH96)
BRIDGING BEAM | Z/3005 | 15.3 | +5.722 | +5.976 | 76 | C200-C200/BB250(TH75)-BB250(TH96)
TH | Z/387 | 2.9 | +5.449 | +5.574 | 125 | C150-C150/BB250(TH75)-BB250(TH96)
PLATE | Z/1000 | 2.5 | +5.646 | +5.949 | 67 | C150/BB250(TH75)-BB250(TH96)
2 x TH | Z/387 | 2.9 | +5.987 | +6.077 | 125 | C150-C150/BB250(TH75)-BB250(TH96)
FASCIA | Z/386 | 7.7 | +5.778 | +5.930 | 64 | C150-C150/BB250(TH75)-BB250(TH96)
COLUMN | Z/2648 | 7.9 | +4.860 | +5.976 | 76 | C200/BB200(TH120)-BB250(TH75)
COLUMN | Z/2511 | 5.9 | +4.860 | +5.930 | 64 | C150/BB200(TH120)-BB250(TH75)
2 x FASCIA BRACKET | Z/2556 | 0.6 | +5.819 | +5.980 | 161 | C200/BB200(TH120)-BB250(TH75)
FASCIA BRACKET | Z/2556 | 0.6 | +5.819 | +5.980 | 161 | C200-C200/BB200(TH120)-BB250(TH75)
BRIDGING U-PLATE | Z/2972 | 2.6 | +5.719 | +5.930 | 211 | C200-C200/BB200(TH120)-BB250(TH75)
BRIDGING BEAM | Z/2996 | 13.4 | +5.723 | +5.926 | 76 | C200-C200/BB200(TH120)-BB250(TH75)
2 x RAFTER | Z/2998 | 3.9 | +5.725 | +6.038 | 76 | C200-C200/BB200(TH120)-BB250(TH75)
BRIDGING U-PLATE | Z/2614 | 2.6 | +5.713 | +5.924 | 211 | C150-C150/BB200(TH120)-BB250(TH75)
2 x RAFTER | Z/2555 | 2.6 | +5.718 | +5.964 | 64 | C150-C150/BB200(TH120)-BB250(TH75)
FASCIA STIFFENER | Z/367 | 0.6 | +5.723 | +5.926 | 3 | C200-C200/BB200(TH120)-BB250(TH75)
4 x RAFTER | Z/247 | 3.9 | +5.725 | +6.038 | 76 | C200/BB200(TH120)-BB250(TH75)
COLUMN | Z/3038 | 7.9 | +4.860 | +5.976 | 76 | C200/BB200(TH120)-BB250(TH75)
BEAM | Z/385 | 13.7 | +5.717 | +5.920 | 76 | C150-C150/BB200(TH120)-BB250(TH75)
BEAM | Z/2618 | 13.7 | +5.717 | +5.920 | 76 | C150-C150/BB200(TH120)-BB250(TH75)
4 x RAFTER | Z/222 | 2.6 | +5.718 | +5.964 | 64 | C150/BB200(TH120)-BB250(TH75)
FASCIA STIFFENER | Z/367 | 0.6 | +5.717 | +5.920 | 3 | C150-C150/BB200(TH120)-BB250(TH75)
2 x FASCIA BRACKET | Z/2531 | 0.3 | +5.775 | +5.932 | 157.2 | C150/BB200(TH120)-BB250(TH75)
FASCIA BRACKET | Z/2531 | 0.3 | +5.775 | +5.932 | 157.2 | C150-C150/BB200(TH120)-BB250(TH75)
COLUMN | Z/2635 | 5.9 | +4.860 | +5.930 | 64 | C150/BB200(TH120)-BB250(TH75)
PLATE | Z/3011 | 4.1 | +5.656 | +5.970 | 224 | C200/BB200(TH120)-BB250(TH75)
BRIDGING-COLUMN STIFF | Z/2960 | 3.7 | +5.626 | +5.976 | 209.2 | C200/BB200(TH120)-BB250(TH75)
PLATE | Z/2626 | 3.7 | +5.610 | +5.913 | 212 | C150/BB200(TH120)-BB250(TH75)
BRIDGING-COLUMN STIFF | Z/2604 | 3.1 | +5.580 | +5.930 | 197.2 | C150/BB200(TH120)-BB250(TH75)
BB TRUSS BRACKET | Z/2967 | 1.7 | +5.726 | +5.958 | 147.999 | C200-C200/BB200(TH120)-BB250(TH75)
BB TRUSS BRACKET | Z/2608 | 1.7 | +5.726 | +5.958 | 147.999 | C200-C200/BB200(TH120)-BB250(TH75)
BB TRUSS BRACKET | Z/2610 | 1.2 | +5.722 | +5.902 | 147.999 | C150-C150/BB200(TH120)-BB250(TH75)
BB TRUSS BRACKET | Z/2611 | 1.2 | +5.722 | +5.902 | 147.999 | C150-C150/BB200(TH120)-BB250(TH75)
GIRT | Z/3002 | 4.6 | +5.388 | +5.553 | 165 | C200-C200/BB200(TH120)-BB250(TH75)
PLATE | Z/548 | 3.1 | +5.656 | +5.970 | 79 | C200/BB200(TH120)-BB250(TH75)
2 x PURLIN | Z/3003 | 4.6 | +6.021 | +6.160 | 165 | C200-C200/BB200(TH120)-BB250(TH75)
FASCIA | Z/426 | 8.9 | +5.824 | +5.976 | 64 | C200-C200/BB200(TH120)-BB250(TH75)
BRIDGING BEAM | Z/2997 | 13.4 | +5.723 | +5.926 | 76 | C200-C200/BB200(TH120)-BB250(TH75)
TH | Z/389 | 2.9 | +5.429 | +5.594 | 165 | C150-C150/BB200(TH120)-BB250(TH75)
PLATE | Z/2508 | 2.5 | +5.610 | +5.913 | 67 | C150/BB200(TH120)-BB250(TH75)
2 x TH | Z/389 | 2.9 | +5.946 | +6.086 | 165 | C150-C150/BB200(TH120)-BB250(TH75)
FASCIA | Z/386 | 7.7 | +5.778 | +5.930 | 64 | C150-C150/BB200(TH120)-BB250(TH75)
COLUMN | Z/2643 | 7.9 | +4.860 | +5.976 | 76 | C200/BB200(TH96)-BB200(TH120)
COLUMN | Z/2510 | 5.9 | +4.860 | +5.930 | 64 | C150/BB200(TH96)-BB200(TH120)
2 x FASCIA BRACKET | Z/2554 | 0.5 | +5.819 | +5.980 | 161 | C200/BB200(TH96)-BB200(TH120)
FASCIA BRACKET | Z/2554 | 0.5 | +5.819 | +5.980 | 161 | C200-C200/BB200(TH96)-BB200(TH120)
BRIDGING U-PLATE | Z/2972 | 2.6 | +5.739 | +5.950 | 211 | C200-C200/BB200(TH96)-BB200(TH120)
BRIDGING BEAM | Z/2996 | 13.4 | +5.743 | +5.946 | 76 | C200-C200/BB200(TH96)-BB200(TH120)
2 x RAFTER | Z/2998 | 3.9 | +5.745 | +6.058 | 76 | C200-C200/BB200(TH96)-BB200(TH120)
BRIDGING U-PLATE | Z/2613 | 2.6 | +5.723 | +5.934 | 211 | C150-C150/BB200(TH96)-BB200(TH120)
2 x RAFTER | Z/2555 | 2.6 | +5.738 | +5.983 | 64 | C150-C150/BB200(TH96)-BB200(TH120)
FASCIA STIFFENER | Z/367 | 0.6 | +5.743 | +5.946 | 3 | C200-C200/BB200(TH96)-BB200(TH120)
4 x RAFTER | Z/247 | 3.9 | +5.745 | +6.058 | 76 | C200/BB200(TH96)-BB200(TH120)
COLUMN | Z/3037 | 7.9 | +4.860 | +5.976 | 76 | C200/BB200(TH96)-BB200(TH120)
BEAM | Z/385 | 13.7 | +5.727 | +5.930 | 76 | C150-C150/BB200(TH96)-BB200(TH120)
BEAM | Z/2618 | 13.7 | +5.727 | +5.930 | 76 | C150-C150/BB200(TH96)-BB200(TH120)
4 x RAFTER | Z/222 | 2.6 | +5.738 | +5.983 | 64 | C150/BB200(TH96)-BB200(TH120)
FASCIA STIFFENER | Z/367 | 0.6 | +5.727 | +5.930 | 3 | C150-C150/BB200(TH96)-BB200(TH120)
2 x FASCIA BRACKET | Z/2520 | 0.3 | +5.775 | +5.932 | 157.2 | C150/BB200(TH96)-BB200(TH120)
FASCIA BRACKET | Z/2520 | 0.3 | +5.775 | +5.932 | 157.2 | C150-C150/BB200(TH96)-BB200(TH120)
COLUMN | Z/2634 | 5.9 | +4.860 | +5.930 | 64 | C150/BB200(TH96)-BB200(TH120)
PLATE | Z/3011 | 4.1 | +5.675 | +5.989 | 224 | C200/BB200(TH96)-BB200(TH120)
BRIDGING-COLUMN STIFF | Z/2958 | 3.7 | +5.626 | +5.976 | 209.2 | C200/BB200(TH96)-BB200(TH120)
PLATE | Z/2624 | 3.7 | +5.629 | +5.932 | 212 | C150/BB200(TH96)-BB200(TH120)
BRIDGING-COLUMN STIFF | Z/2598 | 3.1 | +5.580 | +5.930 | 197.2 | C150/BB200(TH96)-BB200(TH120)
BB TRUSS BRACKET | Z/2967 | 1.7 | +5.746 | +5.978 | 147.999 | C200-C200/BB200(TH96)-BB200(TH120)
BB TRUSS BRACKET | Z/2608 | 1.7 | +5.746 | +5.978 | 147.999 | C200-C200/BB200(TH96)-BB200(TH120)
BB TRUSS BRACKET | Z/2610 | 1.2 | +5.742 | +5.921 | 147.999 | C150-C150/BB200(TH96)-BB200(TH120)
BB TRUSS BRACKET | Z/2611 | 1.2 | +5.742 | +5.921 | 147.999 | C150-C150/BB200(TH96)-BB200(TH120)
GIRT | Z/3000 | 4.6 | +5.396 | +5.546 | 150 | C200-C200/BB200(TH96)-BB200(TH120)
PLATE | Z/548 | 3.1 | +5.675 | +5.989 | 79 | C200/BB200(TH96)-BB200(TH120)
2 x PURLIN | Z/3001 | 4.6 | +6.042 | +6.155 | 150 | C200-C200/BB200(TH96)-BB200(TH120)
FASCIA | Z/426 | 8.9 | +5.824 | +5.976 | 64 | C200-C200/BB200(TH96)-BB200(TH120)
BRIDGING BEAM | Z/2997 | 13.4 | +5.743 | +5.946 | 76 | C200-C200/BB200(TH96)-BB200(TH120)
TH | Z/388 | 2.9 | +5.437 | +5.587 | 150 | C150-C150/BB200(TH96)-BB200(TH120)
PLATE | Z/2507 | 2.5 | +5.629 | +5.932 | 67 | C150/BB200(TH96)-BB200(TH120)
2 x TH | Z/388 | 2.9 | +5.967 | +6.081 | 150 | C150-C150/BB200(TH96)-BB200(TH120)
FASCIA | Z/386 | 7.7 | +5.778 | +5.930 | 64 | C150-C150/BB200(TH96)-BB200(TH120)
COLUMN | Z/2642 | 7.9 | +4.860 | +5.976 | 76 | C200/BB200(TH75)-BB200(TH96)
COLUMN | Z/2509 | 5.9 | +4.860 | +5.930 | 64 | C150/BB200(TH75)-BB200(TH96)
2 x FASCIA BRACKET | Z/2553 | 0.3 | +5.819 | +5.980 | 161 | C200/BB200(TH75)-BB200(TH96)
FASCIA BRACKET | Z/2553 | 0.3 | +5.819 | +5.980 | 161 | C200-C200/BB200(TH75)-BB200(TH96)
BRIDGING U-PLATE | Z/2612 | 2.6 | +5.723 | +5.934 | 211 | C150-C150/BB200(TH75)-BB200(TH96)
2 x RAFTER | Z/2555 | 2.6 | +5.755 | +6.000 | 64 | C150-C150/BB200(TH75)-BB200(TH96)
BRIDGING BEAM | Z/2996 | 13.4 | +5.763 | +5.966 | 76 | C200-C200/BB200(TH75)-BB200(TH96)
2 x RAFTER | Z/2998 | 3.9 | +5.762 | +6.075 | 76 | C200-C200/BB200(TH75)-BB200(TH96)
BRIDGING U-PLATE | Z/2973 | 2.6 | +5.759 | +5.970 | 211 | C200-C200/BB200(TH75)-BB200(TH96)
FASCIA STIFFENER | Z/367 | 0.6 | +5.763 | +5.966 | 3 | C200-C200/BB200(TH75)-BB200(TH96)
4 x RAFTER | Z/247 | 3.9 | +5.762 | +6.075 | 76 | C200/BB200(TH75)-BB200(TH96)
COLUMN | Z/3036 | 7.9 | +4.860 | +5.976 | 76 | C200/BB200(TH75)-BB200(TH96)
BEAM | Z/385 | 13.7 | +5.727 | +5.930 | 76 | C150-C150/BB200(TH75)-BB200(TH96)
BEAM | Z/2618 | 13.7 | +5.727 | +5.930 | 76 | C150-C150/BB200(TH75)-BB200(TH96)
4 x RAFTER | Z/222 | 2.6 | +5.755 | +6.000 | 64 | C150/BB200(TH75)-BB200(TH96)
FASCIA STIFFENER | Z/367 | 0.6 | +5.727 | +5.930 | 3 | C150-C150/BB200(TH75)-BB200(TH96)
2 x FASCIA BRACKET | Z/52 | 0.2 | +5.775 | +5.932 | 157.2 | C150/BB200(TH75)-BB200(TH96)
FASCIA BRACKET | Z/52 | 0.2 | +5.775 | +5.932 | 157.2 | C150-C150/BB200(TH75)-BB200(TH96)
COLUMN | Z/2633 | 5.9 | +4.860 | +5.930 | 64 | C150/BB200(TH75)-BB200(TH96)
PLATE | Z/3009 | 4.1 | +5.692 | +6.006 | 224 | C200/BB200(TH75)-BB200(TH96)
BRIDGING-COLUMN STIFF | Z/2956 | 3.7 | +5.626 | +5.976 | 209.2 | C200/BB200(TH75)-BB200(TH96)
PLATE | Z/2622 | 3.7 | +5.646 | +5.949 | 212 | C150/BB200(TH75)-BB200(TH96)
BRIDGING-COLUMN STIFF | Z/2598 | 3.1 | +5.580 | +5.930 | 197.2 | C150/BB200(TH75)-BB200(TH96)
BB TRUSS BRACKET | Z/2610 | 1.2 | +5.759 | +5.938 | 147.999 | C150-C150/BB200(TH75)-BB200(TH96)
BB TRUSS BRACKET | Z/2611 | 1.2 | +5.759 | +5.938 | 147.999 | C150-C150/BB200(TH75)-BB200(TH96)
GIRT | Z/2995 | 4.6 | +5.408 | +5.533 | 125 | C200-C200/BB200(TH75)-BB200(TH96)
BB TRUSS BRACKET | Z/2967 | 1.7 | +5.763 | +5.995 | 147.999 | C200-C200/BB200(TH75)-BB200(TH96)
BB TRUSS BRACKET | Z/2608 | 1.7 | +5.763 | +5.995 | 147.999 | C200-C200/BB200(TH75)-BB200(TH96)
PLATE | Z/548 | 3.1 | +5.692 | +6.006 | 79 | C200/BB200(TH75)-BB200(TH96)
2 x PURLIN | Z/2999 | 4.6 | +6.062 | +6.152 | 125 | C200-C200/BB200(TH75)-BB200(TH96)
FASCIA | Z/426 | 8.9 | +5.824 | +5.976 | 64 | C200-C200/BB200(TH75)-BB200(TH96)
BRIDGING BEAM | Z/2997 | 13.4 | +5.763 | +5.966 | 76 | C200-C200/BB200(TH75)-BB200(TH96)
TH | Z/387 | 2.9 | +5.449 | +5.574 | 125 | C150-C150/BB200(TH75)-BB200(TH96)
PLATE | Z/1000 | 2.5 | +5.646 | +5.949 | 67 | C150/BB200(TH75)-BB200(TH96)
2 x TH | Z/387 | 2.9 | +5.987 | +6.077 | 125 | C150-C150/BB200(TH75)-BB200(TH96)
FASCIA | Z/386 | 7.7 | +5.778 | +5.930 | 64 | C150-C150/BB200(TH75)-BB200(TH96)
BRIDGING U-PLATE | Z/3151 | 3.6 | +5.667 | +5.975 | 100 | C300-C300/BB300(TH96)
BEAM | Z/3153 | 23.6 | +5.671 | +5.971 | 96 | C300-C300/BB300(TH96)
BRIDGING U-PLATE | Z/3150 | 4.4 | +5.598 | +5.956 | 129 | C300-C300/BB350(TH96)
BEAM | Z/3155 | 28.2 | +5.602 | +5.952 | 125 | C300-C300/BB350(TH96)
BRIDGING U-PLATE | Z/3152 | 3.6 | +5.647 | +5.955 | 100 | C300-C300/BB300(TH120)
BEAM | Z/3153 | 23.6 | +5.651 | +5.951 | 96 | C300-C300/BB300(TH120)
BRIDGING U-PLATE | Z/3149 | 4.4 | +5.622 | +5.980 | 129 | C300-C300/BB350(TH120)
BEAM | Z/3155 | 28.2 | +5.626 | +5.976 | 125 | C300-C300/BB350(TH120)
BRIDGING U-PLATE | Z/3149 | 4.4 | +5.576 | +5.934 | 129 | C300-C300/BB350(TH75)
BEAM | Z/3155 | 28.2 | +5.580 | +5.930 | 125 | C300-C300/BB350(TH75)
BEAM | Z/3153 | 23.6 | +5.676 | +5.976 | 96 | C300-C300/BB300(TH75)
BRIDGING U-PLATE | Z/3151 | 3.6 | +5.672 | +5.980 | 100 | C300-C300/BB300(TH75)
COLUMN | Z/3615 | 16.7 | +4.860 | +5.975 | 125 | C350/BB350(TH120)
COLUMN | Z/3614 | 16.7 | +4.860 | +5.975 | 125 | C350/BB350(TH96)
COLUMN | Z/3613 | 16.7 | +4.860 | +5.975 | 125 | C350/BB350(TH75)
COLUMN | Z/3118 | 14 | +4.860 | +5.976 | 96 | C300/BB350(TH120)
COLUMN | Z/3120 | 13.7 | +4.860 | +5.952 | 96 | C300/BB350(TH96)
COLUMN | Z/3119 | 13.4 | +4.860 | +5.930 | 96 | C300/BB350(TH75)
COLUMN | Z/3118 | 14 | +4.860 | +5.976 | 96 | C300/BB300(TH120)
COLUMN | Z/3117 | 14 | +4.860 | +5.976 | 96 | C300/BB300(TH96)
COLUMN | Z/3116 | 14 | +4.860 | +5.976 | 96 | C300/BB300(TH75)
COLUMN | Z/3041 | 8.9 | +4.860 | +5.975 | 76 | C250/BB350(TH120)
COLUMN | Z/3040 | 8.9 | +4.860 | +5.975 | 76 | C250/BB350(TH96)
COLUMN | Z/3039 | 8.9 | +4.860 | +5.975 | 76 | C250/BB350(TH75)
COLUMN | Z/3041 | 8.9 | +4.860 | +5.975 | 76 | C250/BB300(TH120)
COLUMN | Z/3040 | 8.9 | +4.860 | +5.975 | 76 | C250/BB300(TH96)
COLUMN | Z/3039 | 8.9 | +4.860 | +5.975 | 76 | C250/BB300(TH75)
COLUMN | Z/3041 | 8.9 | +4.860 | +5.976 | 76 | C250/BB250(TH120)
COLUMN | Z/3040 | 8.9 | +4.860 | +5.976 | 76 | C250/BB250(TH96)
COLUMN | Z/3039 | 8.9 | +4.860 | +5.976 | 76 | C250/BB250(TH75)
COLUMN | Z/2648 | 7.9 | +4.860 | +5.976 | 76 | C200/BB300(TH120)
COLUMN | Z/2643 | 7.9 | +4.860 | +5.976 | 76 | C200/BB300(TH96)
COLUMN | Z/2642 | 7.9 | +4.860 | +5.976 | 76 | C200/BB300(TH75)
COLUMN | Z/2648 | 7.9 | +4.860 | +5.976 | 76 | C200/BB250(TH120)
COLUMN | Z/2643 | 7.9 | +4.860 | +5.976 | 76 | C200/BB250(TH96)
COLUMN | Z/2642 | 7.9 | +4.860 | +5.976 | 76 | C200/BB250(TH75)
COLUMN | Z/2648 | 7.9 | +4.860 | +5.976 | 76 | C200/BB200(TH120)
COLUMN | Z/2643 | 7.9 | +4.860 | +5.976 | 76 | C200/BB200(TH96)
COLUMN | Z/2642 | 7.9 | +4.860 | +5.976 | 76 | C200/BB200(TH75)
COLUMN | Z/2513 | 6.2 | +4.860 | +5.976 | 64 | C150/BB250(TH120)
COLUMN | Z/2512 | 6.2 | +4.860 | +5.951 | 64 | C150/BB250(TH96)
COLUMN | Z/2509 | 5.9 | +4.860 | +5.930 | 64 | C150/BB250(TH75)
COLUMN | Z/2511 | 5.9 | +4.860 | +5.930 | 64 | C150/BB200(TH120)
COLUMN | Z/2510 | 5.9 | +4.860 | +5.930 | 64 | C150/BB200(TH96)
COLUMN | Z/2509 | 5.9 | +4.860 | +5.930 | 64 | C150/BB200(TH75)
BEAM | Z/3082 | 19 | +5.675 | +5.975 | 96 | C250-C250/BB300(TH75)
BEAM | Z/3082 | 19 | +5.675 | +5.975 | 96 | C250-C250/BB300(TH96)
BEAM | Z/3082 | 19 | +5.675 | +5.975 | 96 | C250-C250/BB300(TH120)
BRIDGING BEAM | Z/3006 | 19 | +5.676 | +5.976 | 96 | C200-C200/BB300(TH120)
BRIDGING BEAM | Z/3006 | 19 | +5.676 | +5.976 | 96 | C200-C200/BB300(TH96)
BRIDGING BEAM | Z/3006 | 19 | +5.676 | +5.976 | 96 | C200-C200/BB300(TH75)
BEAM | Z/3084 | 28.5 | +5.625 | +5.975 | 125 | C250-C250/BB350(TH75)
BEAM | Z/3084 | 28.5 | +5.625 | +5.975 | 125 | C250-C250/BB350(TH96)
BEAM | Z/3084 | 28.5 | +5.625 | +5.975 | 125 | C250-C250/BB350(TH120)
BEAM | Z/3626 | 27.7 | +5.625 | +5.975 | 125 | C350-C350/BB350(TH75)
BEAM | Z/3626 | 27.7 | +5.625 | +5.975 | 125 | C350-C350/BB350(TH96)
BEAM | Z/3626 | 27.7 | +5.610 | +5.960 | 125 | C350-C350/BB350(TH120)
2 x FASCIA BRACKET | Z/2556 | 0.6 | +5.819 | +5.980 | 161 | C200/BB300(TH120)
FASCIA BRACKET | Z/2556 | 0.6 | +5.819 | +5.980 | 161 | C200-C200/BB300(TH120)
2 x FASCIA BRACKET | Z/2556 | 0.6 | +5.819 | +5.980 | 161 | C200/BB250(TH120)
FASCIA BRACKET | Z/2556 | 0.6 | +5.819 | +5.980 | 161 | C200-C200/BB250(TH120)
2 x FASCIA BRACKET | Z/2556 | 0.6 | +5.819 | +5.980 | 161 | C200/BB200(TH120)
FASCIA BRACKET | Z/2556 | 0.6 | +5.819 | +5.980 | 161 | C200-C200/BB200(TH120)
2 x FASCIA BRACKET | Z/2554 | 0.5 | +5.819 | +5.980 | 161 | C200/BB300(TH96)
FASCIA BRACKET | Z/2554 | 0.5 | +5.819 | +5.980 | 161 | C200-C200/BB300(TH96)
2 x FASCIA BRACKET | Z/2554 | 0.5 | +5.819 | +5.980 | 161 | C200/BB250(TH96)
FASCIA BRACKET | Z/2554 | 0.5 | +5.819 | +5.980 | 161 | C200-C200/BB250(TH96)
2 x FASCIA BRACKET | Z/2554 | 0.5 | +5.819 | +5.980 | 161 | C200/BB200(TH96)
FASCIA BRACKET | Z/2554 | 0.5 | +5.819 | +5.980 | 161 | C200-C200/BB200(TH96)
2 x FASCIA BRACKET | Z/2553 | 0.3 | +5.819 | +5.980 | 161 | C200/BB300(TH75)
FASCIA BRACKET | Z/2553 | 0.3 | +5.819 | +5.980 | 161 | C200-C200/BB300(TH75)
2 x FASCIA BRACKET | Z/2553 | 0.3 | +5.819 | +5.980 | 161 | C200/BB250(TH75)
FASCIA BRACKET | Z/2553 | 0.3 | +5.819 | +5.980 | 161 | C200-C200/BB250(TH75)
2 x FASCIA BRACKET | Z/2553 | 0.3 | +5.819 | +5.980 | 161 | C200/BB200(TH75)
FASCIA BRACKET | Z/2553 | 0.3 | +5.819 | +5.980 | 161 | C200-C200/BB200(TH75)
BRIDGING U-PLATE | Z/3150 | 4.4 | +5.621 | +5.979 | 358 | C350-C350/BB350(TH96)
BRIDGING U-PLATE | Z/3149 | 4.4 | +5.621 | +5.979 | 358 | C350-C350/BB350(TH75)
BRIDGING U-PLATE | Z/3625 | 4.4 | +5.606 | +5.964 | 358 | C350-C350/BB350(TH120)
RAFTER | Z/2606 | 10.8 | +5.612 | +6.105 | 125 | C350-C350/BB350(TH120)>
RAFTER | Z/2599 | 8.9 | +5.652 | +6.094 | 96 | C300-C300/BB350(TH120)>
BRIDGING U-PLATE | Z/3069 | 4.4 | +5.621 | +5.979 | 129 | C250-C250/BB350(TH120)
BRIDGING U-PLATE | Z/3068 | 4.4 | +5.621 | +5.979 | 129 | C250-C250/BB350(TH96)
BRIDGING U-PLATE | Z/3067 | 4.4 | +5.621 | +5.979 | 129 | C250-C250/BB350(TH75)
BRIDGING U-PLATE | Z/3066 | 3.6 | +5.671 | +5.979 | 100 | C250-C250/BB300(TH120)
BRIDGING U-PLATE | Z/3065 | 3.6 | +5.671 | +5.979 | 100 | C250-C250/BB300(TH96)
BRIDGING U-PLATE | Z/3064 | 3.6 | +5.671 | +5.979 | 100 | C250-C250/BB300(TH75)
BRIDGING U-PLATE | Z/3063 | 2.9 | +5.683 | +5.945 | 80 | C250-C250/BB250(TH120)
BEAM | Z/3070 | 15.3 | +5.687 | +5.941 | 76 | C250-C250/BB250(TH120)
BRIDGING U-PLATE | Z/3062 | 2.9 | +5.698 | +5.960 | 80 | C250-C250/BB250(TH96)
BEAM | Z/3070 | 15.3 | +5.702 | +5.956 | 76 | C250-C250/BB250(TH96)
BEAM | Z/3070 | 15.3 | +5.722 | +5.976 | 76 | C250-C250/BB250(TH75)
BRIDGING U-PLATE | Z/3061 | 2.9 | +5.718 | +5.980 | 80 | C250-C250/BB250(TH75)
RAFTER | Z/2591 | 5.9 | +5.686 | +6.086 | 76 | C250-C250/BB350(TH120)>
BRIDGING U-PLATE | Z/2979 | 3.6 | +5.672 | +5.980 | 308 | C200-C200/BB300(TH120)
BRIDGING U-PLATE | Z/2978 | 3.6 | +5.672 | +5.980 | 308 | C200-C200/BB300(TH96)
BRIDGING U-PLATE | Z/2977 | 3.6 | +5.672 | +5.980 | 308 | C200-C200/BB300(TH75)
BRIDGING U-PLATE | Z/2976 | 2.9 | +5.708 | +5.970 | 262 | C200-C200/BB250(TH120)
BRIDGING BEAM | Z/3004 | 15.3 | +5.712 | +5.966 | 76 | C200-C200/BB250(TH120)
BRIDGING U-PLATE | Z/2975 | 2.9 | +5.718 | +5.980 | 262 | C200-C200/BB250(TH96)
BRIDGING BEAM | Z/3004 | 15.3 | +5.722 | +5.976 | 76 | C200-C200/BB250(TH96)
BRIDGING U-PLATE | Z/2974 | 2.9 | +5.718 | +5.980 | 262 | C200-C200/BB250(TH75)
BRIDGING BEAM | Z/3004 | 15.3 | +5.722 | +5.976 | 76 | C200-C200/BB250(TH75)
BRIDGING U-PLATE | Z/2972 | 2.6 | +5.719 | +5.930 | 211 | C200-C200/BB200(TH120)
BRIDGING BEAM | Z/2996 | 13.4 | +5.723 | +5.926 | 76 | C200-C200/BB200(TH120)
BRIDGING U-PLATE | Z/2972 | 2.6 | +5.739 | +5.950 | 211 | C200-C200/BB200(TH96)
BRIDGING BEAM | Z/2996 | 13.4 | +5.743 | +5.946 | 76 | C200-C200/BB200(TH96)
BRIDGING U-PLATE | Z/2617 | 2.9 | +5.718 | +5.980 | 262 | C150-C150/BB250(TH120)
BRIDGING U-PLATE | Z/2616 | 2.9 | +5.693 | +5.955 | 262 | C150-C150/BB250(TH96)
BRIDGING U-PLATE | Z/2615 | 2.9 | +5.672 | +5.934 | 262 | C150-C150/BB250(TH75)
BRIDGING U-PLATE | Z/2614 | 2.6 | +5.713 | +5.924 | 211 | C150-C150/BB200(TH120)
BRIDGING U-PLATE | Z/2613 | 2.6 | +5.723 | +5.934 | 211 | C150-C150/BB200(TH96)
BRIDGING U-PLATE | Z/2612 | 2.6 | +5.723 | +5.934 | 211 | C150-C150/BB200(TH75)
2 x RAFTER | Z/431 | 10.8 | +5.612 | +6.105 | 125 | C350/BB350(TH120)>
2 x FASCIA BRACKET | Z/2531 | 0.3 | +5.820 | +5.977 | 157.2 | C350/BB350(TH120)
FASCIA BRACKET | Z/2531 | 0.3 | +5.820 | +5.977 | 157.2 | C350-C350/BB350(TH120)
FASCIA STIFFENER | Z/243 | 1 | +5.623 | +5.973 | 3 | C350-C350/BB350(TH120)
COLUMN | Z/3636 | 16.7 | +4.860 | +5.975 | 125 | C350/BB350(TH120)
2 x FASCIA BRACKET | Z/2520 | 0.3 | +5.820 | +5.977 | 157.2 | C350/BB350(TH96)
FASCIA BRACKET | Z/2520 | 0.3 | +5.820 | +5.977 | 157.2 | C350-C350/BB350(TH96)
FASCIA STIFFENER | Z/243 | 1 | +5.623 | +5.973 | 3 | C350-C350/BB350(TH96)
COLUMN | Z/3635 | 16.7 | +4.860 | +5.975 | 125 | C350/BB350(TH96)
2 x FASCIA BRACKET | Z/52 | 0.2 | +5.820 | +5.977 | 157.2 | C350/BB350(TH75)
FASCIA BRACKET | Z/52 | 0.2 | +5.820 | +5.977 | 157.2 | C350-C350/BB350(TH75)
FASCIA STIFFENER | Z/243 | 1 | +5.623 | +5.973 | 3 | C350-C350/BB350(TH75)
COLUMN | Z/3634 | 16.7 | +4.860 | +5.975 | 125 | C350/BB350(TH75)
2 x RAFTER | Z/430 | 8.9 | +5.652 | +6.094 | 96 | C300/BB350(TH120)>
2 x FASCIA BRACKET | Z/2531 | 0.3 | +5.821 | +5.979 | 157.2 | C300/BB350(TH120)
FASCIA BRACKET | Z/2531 | 0.3 | +5.821 | +5.979 | 157.2 | C300-C300/BB350(TH120)
FASCIA STIFFENER | Z/243 | 1 | +5.626 | +5.976 | 3 | C300-C300/BB350(TH120)
COLUMN | Z/3169 | 14 | +4.860 | +5.976 | 96 | C300/BB350(TH120)
2 x FASCIA BRACKET | Z/2520 | 0.3 | +5.797 | +5.954 | 157.2 | C300/BB350(TH96)
FASCIA BRACKET | Z/2520 | 0.3 | +5.797 | +5.954 | 157.2 | C300-C300/BB350(TH96)
FASCIA STIFFENER | Z/243 | 1 | +5.602 | +5.952 | 3 | C300-C300/BB350(TH96)
COLUMN | Z/3171 | 13.7 | +4.860 | +5.952 | 96 | C300/BB350(TH96)
2 x FASCIA BRACKET | Z/52 | 0.2 | +5.775 | +5.933 | 157.2 | C300/BB350(TH75)
FASCIA BRACKET | Z/52 | 0.2 | +5.775 | +5.933 | 157.2 | C300-C300/BB350(TH75)
FASCIA STIFFENER | Z/243 | 1 | +5.580 | +5.930 | 3 | C300-C300/BB350(TH75)
COLUMN | Z/3170 | 13.4 | +4.860 | +5.930 | 96 | C300/BB350(TH75)
FASCIA STIFFENER | Z/237 | 0.8 | +5.651 | +5.951 | 3 | C300-C300/BB300(TH120)
FASCIA STIFFENER | Z/237 | 0.8 | +5.671 | +5.971 | 3 | C300-C300/BB300(TH96)
FASCIA STIFFENER | Z/237 | 0.8 | +5.676 | +5.976 | 3 | C300-C300/BB300(TH75)
2 x FASCIA BRACKET | Z/2531 | 0.3 | +5.821 | +5.979 | 157.2 | C300/BB300(TH120)
FASCIA BRACKET | Z/2531 | 0.3 | +5.821 | +5.979 | 157.2 | C300-C300/BB300(TH120)
COLUMN | Z/3169 | 14 | +4.860 | +5.976 | 96 | C300/BB300(TH120)
2 x FASCIA BRACKET | Z/2520 | 0.3 | +5.821 | +5.979 | 157.2 | C300/BB300(TH96)
FASCIA BRACKET | Z/2520 | 0.3 | +5.821 | +5.979 | 157.2 | C300-C300/BB300(TH96)
COLUMN | Z/3168 | 14 | +4.860 | +5.976 | 96 | C300/BB300(TH96)
2 x FASCIA BRACKET | Z/52 | 0.2 | +5.821 | +5.979 | 157.2 | C300/BB300(TH75)
FASCIA BRACKET | Z/52 | 0.2 | +5.821 | +5.979 | 157.2 | C300-C300/BB300(TH75)
COLUMN | Z/3167 | 14 | +4.860 | +5.976 | 96 | C300/BB300(TH75)
2 x RAFTER | Z/289 | 5.9 | +5.686 | +6.086 | 76 | C250/BB350(TH120)>
2 x FASCIA BRACKET | Z/2531 | 0.3 | +5.821 | +5.978 | 157.2 | C250/BB350(TH120)
FASCIA BRACKET | Z/2531 | 0.3 | +5.821 | +5.978 | 157.2 | C250-C250/BB350(TH120)
COLUMN | Z/3112 | 8.9 | +4.860 | +5.975 | 76 | C250/BB350(TH120)
FASCIA STIFFENER | Z/243 | 1 | +5.625 | +5.975 | 3 | C250-C250/BB350(TH120)
2 x FASCIA BRACKET | Z/2520 | 0.3 | +5.821 | +5.978 | 157.2 | C250/BB350(TH96)
FASCIA BRACKET | Z/2520 | 0.3 | +5.821 | +5.978 | 157.2 | C250-C250/BB350(TH96)
COLUMN | Z/3111 | 8.9 | +4.860 | +5.975 | 76 | C250/BB350(TH96)
FASCIA STIFFENER | Z/243 | 1 | +5.625 | +5.975 | 3 | C250-C250/BB350(TH96)
2 x FASCIA BRACKET | Z/52 | 0.2 | +5.821 | +5.978 | 157.2 | C250/BB350(TH75)
FASCIA BRACKET | Z/52 | 0.2 | +5.821 | +5.978 | 157.2 | C250-C250/BB350(TH75)
COLUMN | Z/3110 | 8.9 | +4.860 | +5.975 | 76 | C250/BB350(TH75)
FASCIA STIFFENER | Z/243 | 1 | +5.625 | +5.975 | 3 | C250-C250/BB350(TH75)
2 x FASCIA BRACKET | Z/2531 | 0.3 | +5.821 | +5.978 | 157.2 | C250/BB300(TH120)
FASCIA BRACKET | Z/2531 | 0.3 | +5.821 | +5.978 | 157.2 | C250-C250/BB300(TH120)
COLUMN | Z/3112 | 8.9 | +4.860 | +5.975 | 76 | C250/BB300(TH120)
FASCIA STIFFENER | Z/237 | 0.8 | +5.675 | +5.975 | 3 | C250-C250/BB300(TH120)
2 x FASCIA BRACKET | Z/2520 | 0.3 | +5.821 | +5.978 | 157.2 | C250/BB300(TH96)
FASCIA BRACKET | Z/2520 | 0.3 | +5.821 | +5.978 | 157.2 | C250-C250/BB300(TH96)
COLUMN | Z/3111 | 8.9 | +4.860 | +5.975 | 76 | C250/BB300(TH96)
FASCIA STIFFENER | Z/237 | 0.8 | +5.675 | +5.975 | 3 | C250-C250/BB300(TH96)
2 x FASCIA BRACKET | Z/52 | 0.2 | +5.821 | +5.978 | 157.2 | C250/BB300(TH75)
FASCIA BRACKET | Z/52 | 0.2 | +5.821 | +5.978 | 157.2 | C250-C250/BB300(TH75)
COLUMN | Z/3110 | 8.9 | +4.860 | +5.975 | 76 | C250/BB300(TH75)
FASCIA STIFFENER | Z/237 | 0.8 | +5.675 | +5.975 | 3 | C250-C250/BB300(TH75)
2 x FASCIA BRACKET | Z/2531 | 0.3 | +5.821 | +5.978 | 157.2 | C250/BB250(TH120)
FASCIA BRACKET | Z/2531 | 0.3 | +5.821 | +5.978 | 157.2 | C250-C250/BB250(TH120)
COLUMN | Z/3112 | 8.9 | +4.860 | +5.976 | 76 | C250/BB250(TH120)
FASCIA STIFFENER | Z/223 | 0.6 | +5.687 | +5.941 | 3 | C250-C250/BB250(TH120)
2 x FASCIA BRACKET | Z/2520 | 0.3 | +5.821 | +5.978 | 157.2 | C250/BB250(TH96)
FASCIA BRACKET | Z/2520 | 0.3 | +5.821 | +5.978 | 157.2 | C250-C250/BB250(TH96)
COLUMN | Z/3111 | 8.9 | +4.860 | +5.976 | 76 | C250/BB250(TH96)
FASCIA STIFFENER | Z/223 | 0.6 | +5.702 | +5.956 | 3 | C250-C250/BB250(TH96)
2 x FASCIA BRACKET | Z/52 | 0.2 | +5.821 | +5.978 | 157.2 | C250/BB250(TH75)
FASCIA BRACKET | Z/52 | 0.2 | +5.821 | +5.978 | 157.2 | C250-C250/BB250(TH75)
COLUMN | Z/3110 | 8.9 | +4.860 | +5.976 | 76 | C250/BB250(TH75)
FASCIA STIFFENER | Z/223 | 0.6 | +5.722 | +5.976 | 3 | C250-C250/BB250(TH75)
COLUMN | Z/3038 | 7.9 | +4.860 | +5.976 | 76 | C200/BB300(TH120)
FASCIA STIFFENER | Z/237 | 0.8 | +5.676 | +5.976 | 3 | C200-C200/BB300(TH120)
COLUMN | Z/3037 | 7.9 | +4.860 | +5.976 | 76 | C200/BB300(TH96)
FASCIA STIFFENER | Z/237 | 0.8 | +5.676 | +5.976 | 3 | C200-C200/BB300(TH96)
COLUMN | Z/3036 | 7.9 | +4.860 | +5.976 | 76 | C200/BB300(TH75)
FASCIA STIFFENER | Z/237 | 0.8 | +5.676 | +5.976 | 3 | C200-C200/BB300(TH75)
COLUMN | Z/3038 | 7.9 | +4.860 | +5.976 | 76 | C200/BB250(TH120)
FASCIA STIFFENER | Z/223 | 0.6 | +5.712 | +5.966 | 3 | C200-C200/BB250(TH120)
COLUMN | Z/3037 | 7.9 | +4.860 | +5.976 | 76 | C200/BB250(TH96)
FASCIA STIFFENER | Z/223 | 0.6 | +5.722 | +5.976 | 3 | C200-C200/BB250(TH96)
COLUMN | Z/3036 | 7.9 | +4.860 | +5.976 | 76 | C200/BB250(TH75)
FASCIA STIFFENER | Z/223 | 0.6 | +5.722 | +5.976 | 3 | C200-C200/BB250(TH75)
BRIDGING BEAM | Z/2996 | 13.4 | +5.763 | +5.966 | 76 | C200-C200/BB200(TH75)
BRIDGING U-PLATE | Z/2973 | 2.6 | +5.759 | +5.970 | 211 | C200-C200/BB200(TH75)
FASCIA STIFFENER | Z/367 | 0.6 | +5.723 | +5.926 | 3 | C200-C200/BB200(TH120)
COLUMN | Z/3038 | 7.9 | +4.860 | +5.976 | 76 | C200/BB200(TH120)
FASCIA STIFFENER | Z/367 | 0.6 | +5.743 | +5.946 | 3 | C200-C200/BB200(TH96)
COLUMN | Z/3037 | 7.9 | +4.860 | +5.976 | 76 | C200/BB200(TH96)
FASCIA STIFFENER | Z/367 | 0.6 | +5.763 | +5.966 | 3 | C200-C200/BB200(TH75)
COLUMN | Z/3036 | 7.9 | +4.860 | +5.976 | 76 | C200/BB200(TH75)
BEAM | Z/2620 | 15.3 | +5.722 | +5.976 | 76 | C150-C150/BB250(TH120)
BEAM | Z/2620 | 15.3 | +5.697 | +5.951 | 76 | C150-C150/BB250(TH96)
BEAM | Z/2620 | 15.3 | +5.676 | +5.930 | 76 | C150-C150/BB250(TH75)
BEAM | Z/2619 | 15.3 | +5.722 | +5.976 | 76 | C150-C150/BB250(TH120)
BEAM | Z/2619 | 15.3 | +5.697 | +5.951 | 76 | C150-C150/BB250(TH96)
BEAM | Z/2619 | 15.3 | +5.676 | +5.930 | 76 | C150-C150/BB250(TH75)
FASCIA STIFFENER | Z/223 | 0.6 | +5.722 | +5.976 | 3 | C150-C150/BB250(TH120)
2 x FASCIA BRACKET | Z/2531 | 0.3 | +5.821 | +5.978 | 157.2 | C150/BB250(TH120)
FASCIA BRACKET | Z/2531 | 0.3 | +5.821 | +5.978 | 157.2 | C150-C150/BB250(TH120)
COLUMN | Z/2637 | 6.2 | +4.860 | +5.976 | 64 | C150/BB250(TH120)
FASCIA STIFFENER | Z/223 | 0.6 | +5.697 | +5.951 | 3 | C150-C150/BB250(TH96)
2 x FASCIA BRACKET | Z/2520 | 0.3 | +5.797 | +5.954 | 157.2 | C150/BB250(TH96)
FASCIA BRACKET | Z/2520 | 0.3 | +5.797 | +5.954 | 157.2 | C150-C150/BB250(TH96)
COLUMN | Z/2636 | 6.2 | +4.860 | +5.951 | 64 | C150/BB250(TH96)
FASCIA STIFFENER | Z/223 | 0.6 | +5.676 | +5.930 | 3 | C150-C150/BB250(TH75)
2 x FASCIA BRACKET | Z/52 | 0.2 | +5.775 | +5.932 | 157.2 | C150/BB250(TH75)
FASCIA BRACKET | Z/52 | 0.2 | +5.775 | +5.932 | 157.2 | C150-C150/BB250(TH75)
COLUMN | Z/2633 | 5.9 | +4.860 | +5.930 | 64 | C150/BB250(TH75)
BEAM | Z/385 | 13.7 | +5.717 | +5.920 | 76 | C150-C150/BB200(TH120)
BEAM | Z/385 | 13.7 | +5.727 | +5.930 | 76 | C150-C150/BB200(TH96)
BEAM | Z/385 | 13.7 | +5.727 | +5.930 | 76 | C150-C150/BB200(TH75)
BEAM | Z/2618 | 13.7 | +5.717 | +5.920 | 76 | C150-C150/BB200(TH120)
FASCIA STIFFENER | Z/367 | 0.6 | +5.717 | +5.920 | 3 | C150-C150/BB200(TH120)
2 x FASCIA BRACKET | Z/2531 | 0.3 | +5.775 | +5.932 | 157.2 | C150/BB200(TH120)
FASCIA BRACKET | Z/2531 | 0.3 | +5.775 | +5.932 | 157.2 | C150-C150/BB200(TH120)
COLUMN | Z/2635 | 5.9 | +4.860 | +5.930 | 64 | C150/BB200(TH120)
BEAM | Z/2618 | 13.7 | +5.727 | +5.930 | 76 | C150-C150/BB200(TH96)
FASCIA STIFFENER | Z/367 | 0.6 | +5.727 | +5.930 | 3 | C150-C150/BB200(TH96)
2 x FASCIA BRACKET | Z/2520 | 0.3 | +5.775 | +5.932 | 157.2 | C150/BB200(TH96)
FASCIA BRACKET | Z/2520 | 0.3 | +5.775 | +5.932 | 157.2 | C150-C150/BB200(TH96)
COLUMN | Z/2634 | 5.9 | +4.860 | +5.930 | 64 | C150/BB200(TH96)
BEAM | Z/2618 | 13.7 | +5.727 | +5.930 | 76 | C150-C150/BB200(TH75)
FASCIA STIFFENER | Z/367 | 0.6 | +5.727 | +5.930 | 3 | C150-C150/BB200(TH75)
2 x FASCIA BRACKET | Z/52 | 0.2 | +5.775 | +5.932 | 157.2 | C150/BB200(TH75)
FASCIA BRACKET | Z/52 | 0.2 | +5.775 | +5.932 | 157.2 | C150-C150/BB200(TH75)
COLUMN | Z/2633 | 5.9 | +4.860 | +5.930 | 64 | C150/BB200(TH75)
BRIDGING-COLUMN STIFF | Z/3621 | 6.7 | +5.625 | +5.975 | 257 | C350/BB350(TH120)
BRIDGING-COLUMN STIFF | Z/3619 | 6.7 | +5.625 | +5.975 | 257 | C350/BB350(TH96)
BRIDGING-COLUMN STIFF | Z/3619 | 6.7 | +5.625 | +5.975 | 257 | C350/BB350(TH75)
BRIDGING-COLUMN STIFF | Z/3143 | 5.9 | +5.626 | +5.976 | 228 | C300/BB350(TH120)
BRIDGING-COLUMN STIFF | Z/3143 | 5.9 | +5.602 | +5.952 | 228 | C300/BB350(TH96)
BRIDGING-COLUMN STIFF | Z/3143 | 5.9 | +5.580 | +5.930 | 228 | C300/BB350(TH75)
BRIDGING-COLUMN STIFF | Z/3141 | 5.4 | +5.626 | +5.976 | 228 | C300/BB300(TH120)
BRIDGING-COLUMN STIFF | Z/3139 | 5.4 | +5.626 | +5.976 | 228 | C300/BB300(TH96)
BRIDGING-COLUMN STIFF | Z/3137 | 5.4 | +5.626 | +5.976 | 228 | C300/BB300(TH75)
BRIDGING-COLUMN STIFF | Z/3053 | 5.2 | +5.626 | +5.976 | 209.2 | C250/BB350(TH120)
BRIDGING-COLUMN STIFF | Z/3053 | 5.2 | +5.626 | +5.976 | 209.2 | C250/BB350(TH96)
BRIDGING-COLUMN STIFF | Z/3053 | 5.2 | +5.626 | +5.976 | 209.2 | C250/BB350(TH75)
BRIDGING-COLUMN STIFF | Z/3051 | 4.8 | +5.626 | +5.976 | 209.2 | C250/BB300(TH120)
BRIDGING-COLUMN STIFF | Z/3051 | 4.8 | +5.626 | +5.976 | 209.2 | C250/BB300(TH96)
BRIDGING-COLUMN STIFF | Z/3051 | 4.8 | +5.626 | +5.976 | 209.2 | C250/BB300(TH75)
BRIDGING-COLUMN STIFF | Z/3049 | 4.4 | +5.626 | +5.976 | 209.2 | C250/BB250(TH120)
BRIDGING-COLUMN STIFF | Z/3047 | 4.4 | +5.626 | +5.976 | 209.2 | C250/BB250(TH96)
BRIDGING-COLUMN STIFF | Z/3045 | 4.4 | +5.626 | +5.976 | 209.2 | C250/BB250(TH75)
BRIDGING-COLUMN STIFF | Z/2965 | 4.4 | +5.626 | +5.976 | 209.2 | C200/BB300(TH120)
BRIDGING-COLUMN STIFF | Z/2965 | 4.4 | +5.626 | +5.976 | 209.2 | C200/BB300(TH96)
BRIDGING-COLUMN STIFF | Z/2965 | 4.4 | +5.626 | +5.976 | 209.2 | C200/BB300(TH75)
BRIDGING-COLUMN STIFF | Z/2963 | 4.1 | +5.626 | +5.976 | 209.2 | C200/BB250(TH120)
BRIDGING-COLUMN STIFF | Z/2961 | 4.1 | +5.626 | +5.976 | 209.2 | C200/BB250(TH96)
BRIDGING-COLUMN STIFF | Z/2961 | 4.1 | +5.626 | +5.976 | 209.2 | C200/BB250(TH75)
BRIDGING-COLUMN STIFF | Z/2959 | 3.7 | +5.626 | +5.976 | 209.2 | C200/BB200(TH120)
BRIDGING-COLUMN STIFF | Z/2957 | 3.7 | +5.626 | +5.976 | 209.2 | C200/BB200(TH96)
BRIDGING-COLUMN STIFF | Z/2955 | 3.7 | +5.626 | +5.976 | 209.2 | C200/BB200(TH75)
BRIDGING-COLUMN STIFF | Z/2605 | 3.4 | +5.626 | +5.976 | 197.2 | C150/BB250(TH120)
BRIDGING-COLUMN STIFF | Z/2605 | 3.4 | +5.601 | +5.951 | 197.2 | C150/BB250(TH96)
BRIDGING-COLUMN STIFF | Z/2605 | 3.4 | +5.580 | +5.930 | 197.2 | C150/BB250(TH75)
BRIDGING-COLUMN STIFF | Z/2603 | 3.1 | +5.580 | +5.930 | 197.2 | C150/BB200(TH120)
BRIDGING-COLUMN STIFF | Z/2597 | 3.1 | +5.580 | +5.930 | 197.2 | C150/BB200(TH96)
BRIDGING-COLUMN STIFF | Z/2597 | 3.1 | +5.580 | +5.930 | 197.2 | C150/BB200(TH75)
PLATE | Z/3159 | 10.6 | +5.457 | +6.032 | 244 | C300/BB300(TH120)-BB350(TH75)
PLATE | Z/3159 | 10.6 | +5.476 | +6.052 | 244 | C300/BB300(TH96)-BB300(TH120)
PLATE | Z/3157 | 10.6 | +5.493 | +6.069 | 244 | C300/BB300(TH75)-BB300(TH96)
PLATE | Z/3095 | 7.1 | +5.607 | +6.034 | 224 | C250/BB300(TH75)
PLATE | Z/3097 | 7.1 | +5.590 | +6.017 | 224 | C250/BB300(TH96)
PLATE | Z/3100 | 7.1 | +5.571 | +5.998 | 224 | C250/BB300(TH120)
PLATE | Z/3022 | 4.8 | +5.656 | +5.970 | 224 | C200/BB300(TH120)
PLATE | Z/3020 | 4.8 | +5.675 | +5.989 | 224 | C200/BB300(TH96)
PLATE | Z/3018 | 4.8 | +5.691 | +6.006 | 224 | C200/BB300(TH75)
PLATE | Z/3104 | 7.4 | +5.607 | +6.034 | 224 | C250/BB350(TH75)
PLATE | Z/3106 | 7.4 | +5.590 | +6.017 | 224 | C250/BB350(TH96)
PLATE | Z/3108 | 7.4 | +5.571 | +5.998 | 224 | C250/BB350(TH120)
PLATE | Z/3165 | 11 | +5.457 | +6.032 | 244 | C300/BB350(TH120)>
PLATE | Z/3163 | 11 | +5.451 | +6.027 | 244 | C300/BB350(TH96)-BB350(TH120)
PLATE | Z/3161 | 11 | +5.447 | +6.023 | 244 | C300/BB350(TH75)-BB350(TH96)
PLATE | Z/3628 | 12.3 | +5.492 | +6.078 | 273 | C350/BB350(TH75)-BB350(TH96)
PLATE | Z/3630 | 12.3 | +5.475 | +6.061 | 273 | C350/BB350(TH96)-BB350(TH120)
PLATE | Z/3632 | 12.3 | +5.455 | +6.042 | 273 | C350/BB350(TH120)>
BB TRUSS BRACKET | Z/3623 | 5.4 | +5.610 | +6.032 | 147.699 | C350-C350/BB350(TH120)>
BB TRUSS BRACKET | Z/3624 | 5.4 | +5.610 | +6.032 | 147.699 | C350-C350/BB350(TH120)>
BB TRUSS BRACKET | Z/3145 | 4.3 | +5.637 | +6.023 | 527.132 | C300-C300/BB350(TH120)>
BB TRUSS BRACKET | Z/3146 | 4.3 | +5.637 | +6.023 | 147.699 | C300-C300/BB350(TH120)>
BB TRUSS BRACKET | Z/3145 | 4.3 | +5.632 | +6.017 | 527.132 | C300-C300/BB350(TH96)-BB350(TH120)
BB TRUSS BRACKET | Z/3146 | 4.3 | +5.632 | +6.017 | 147.699 | C300-C300/BB350(TH96)-BB350(TH120)
BB TRUSS BRACKET | Z/3145 | 4.3 | +5.628 | +6.013 | 527.132 | C300-C300/BB350(TH75)-BB350(TH96)
BB TRUSS BRACKET | Z/3057 | 2.9 | +5.673 | +5.986 | 147.999 | C250-C250/BB300(TH120)
BB TRUSS BRACKET | Z/3058 | 2.9 | +5.673 | +5.986 | 147.999 | C250-C250/BB300(TH120)
BB TRUSS BRACKET | Z/3057 | 2.9 | +5.693 | +6.006 | 147.999 | C250-C250/BB300(TH96)
BB TRUSS BRACKET | Z/3058 | 2.9 | +5.693 | +6.006 | 147.999 | C250-C250/BB300(TH96)
BB TRUSS BRACKET | Z/3060 | 2.6 | +5.686 | +5.986 | 358.65 | C250-C250/BB350(TH120)
BB TRUSS BRACKET | Z/3059 | 2.6 | +5.686 | +5.986 | 358.65 | C250-C250/BB350(TH120)
BB TRUSS BRACKET | Z/3060 | 2.6 | +5.705 | +6.006 | 358.65 | C250-C250/BB350(TH96)
BB TRUSS BRACKET | Z/3059 | 2.6 | +5.705 | +6.006 | 358.65 | C250-C250/BB350(TH96)
BB TRUSS BRACKET | Z/3056 | 3.1 | +5.685 | +5.986 | 456.661 | C250-C250/BB250(TH120)
BB TRUSS BRACKET | Z/3055 | 3.1 | +5.685 | +5.986 | 147.999 | C250-C250/BB250(TH120)
BB TRUSS BRACKET | Z/3056 | 3.1 | +5.705 | +6.006 | 456.661 | C250-C250/BB250(TH96)
BB TRUSS BRACKET | Z/3055 | 3.1 | +5.705 | +6.006 | 147.999 | C250-C250/BB250(TH96)
BB TRUSS BRACKET | Z/3060 | 2.6 | +5.722 | +6.023 | 358.65 | C250-C250/BB350(TH75)
BB TRUSS BRACKET | Z/3059 | 2.6 | +5.722 | +6.023 | 358.65 | C250-C250/BB350(TH75)
BB TRUSS BRACKET | Z/3056 | 3.1 | +5.722 | +6.023 | 456.661 | C250-C250/BB250(TH75)
BB TRUSS BRACKET | Z/2970 | 1.7 | +5.725 | +5.958 | 147.999 | C200-C200/BB300(TH120)
BB TRUSS BRACKET | Z/2971 | 1.7 | +5.725 | +5.958 | 147.999 | C200-C200/BB300(TH120)
BB TRUSS BRACKET | Z/2970 | 1.7 | +5.744 | +5.978 | 147.999 | C200-C200/BB300(TH96)
BB TRUSS BRACKET | Z/2971 | 1.7 | +5.744 | +5.978 | 147.999 | C200-C200/BB300(TH96)
BB TRUSS BRACKET | Z/2970 | 1.7 | +5.761 | +5.995 | 147.999 | C200-C200/BB300(TH75)
BB TRUSS BRACKET | Z/2971 | 1.7 | +5.761 | +5.995 | 147.999 | C200-C200/BB300(TH75)
BB TRUSS BRACKET | Z/2968 | 1.9 | +5.717 | +5.958 | 147.999 | C200-C200/BB250(TH120)
BB TRUSS BRACKET | Z/2969 | 1.9 | +5.717 | +5.958 | 147.999 | C200-C200/BB250(TH120)
BB TRUSS BRACKET | Z/2968 | 1.9 | +5.736 | +5.978 | 147.999 | C200-C200/BB250(TH96)
BB TRUSS BRACKET | Z/2969 | 1.9 | +5.736 | +5.978 | 147.999 | C200-C200/BB250(TH96)
BB TRUSS BRACKET | Z/2968 | 1.9 | +5.753 | +5.995 | 147.999 | C200-C200/BB250(TH75)
BB TRUSS BRACKET | Z/2969 | 1.9 | +5.753 | +5.995 | 147.999 | C200-C200/BB250(TH75)
BB TRUSS BRACKET | Z/2608 | 1.7 | +5.726 | +5.958 | 147.999 | C200-C200/BB200(TH120)
BB TRUSS BRACKET | Z/2967 | 1.7 | +5.726 | +5.958 | 147.999 | C200-C200/BB200(TH120)
BB TRUSS BRACKET | Z/2608 | 1.7 | +5.746 | +5.978 | 147.999 | C200-C200/BB200(TH96)
BB TRUSS BRACKET | Z/2967 | 1.7 | +5.746 | +5.978 | 147.999 | C200-C200/BB200(TH96)
BB TRUSS BRACKET | Z/2611 | 1.2 | +5.768 | +5.948 | 147.999 | C150-C150/BB250(TH120)
BB TRUSS BRACKET | Z/2610 | 1.2 | +5.768 | +5.948 | 147.999 | C150-C150/BB250(TH120)
BB TRUSS BRACKET | Z/2611 | 1.2 | +5.763 | +5.943 | 147.999 | C150-C150/BB250(TH96)
BB TRUSS BRACKET | Z/2610 | 1.2 | +5.763 | +5.943 | 147.999 | C150-C150/BB250(TH96)
BB TRUSS BRACKET | Z/2611 | 1.2 | +5.759 | +5.938 | 147.999 | C150-C150/BB250(TH75)
BB TRUSS BRACKET | Z/2610 | 1.2 | +5.759 | +5.938 | 147.999 | C150-C150/BB250(TH75)
BB TRUSS BRACKET | Z/2611 | 1.2 | +5.722 | +5.902 | 147.999 | C150-C150/BB200(TH120)
BB TRUSS BRACKET | Z/2610 | 1.2 | +5.722 | +5.902 | 147.999 | C150-C150/BB200(TH120)
BB TRUSS BRACKET | Z/2611 | 1.2 | +5.742 | +5.921 | 147.999 | C150-C150/BB200(TH96)
BB TRUSS BRACKET | Z/2610 | 1.2 | +5.742 | +5.921 | 147.999 | C150-C150/BB200(TH96)
BB TRUSS BRACKET | Z/2611 | 1.2 | +5.759 | +5.938 | 147.999 | C150-C150/BB200(TH75)
BB TRUSS BRACKET | Z/2610 | 1.2 | +5.759 | +5.938 | 147.999 | C150-C150/BB200(TH75)
TH | Z/403 | 2.9 | +5.278 | +5.443 | 165 | C350-C350/BB350(TH120)
TH | Z/402 | 2.9 | +5.286 | +5.436 | 150 | C350-C350/BB350(TH96)
TH | Z/401 | 2.9 | +5.298 | +5.423 | 125 | C350-C350/BB350(TH75)
PLATE | Z/1432 | 10.1 | +5.492 | +6.078 | 128 | C350/BB350(TH75)-BB350(TH96)
PLATE | Z/1432 | 10.1 | +5.475 | +6.061 | 128 | C350/BB350(TH96)-BB350(TH120)
PLATE | Z/1432 | 10.1 | +5.455 | +6.042 | 128 | C350/BB350(TH120)>
TH | Z/403 | 2.9 | +6.088 | +6.227 | 165 | C350-C350/BB350(TH120)>
FASCIA | Z/426 | 8.9 | +5.823 | +5.975 | 64 | C350-C350/BB350(TH120)
BEAM | Z/3627 | 27.7 | +5.610 | +5.960 | 125 | C350-C350/BB350(TH120)
FASCIA | Z/426 | 8.9 | +5.823 | +5.975 | 64 | C350-C350/BB350(TH96)
BEAM | Z/3627 | 27.7 | +5.625 | +5.975 | 125 | C350-C350/BB350(TH96)
FASCIA | Z/426 | 8.9 | +5.823 | +5.975 | 64 | C350-C350/BB350(TH75)
BEAM | Z/3627 | 27.7 | +5.625 | +5.975 | 125 | C350-C350/BB350(TH75)
TH | Z/423 | 2.9 | +5.313 | +5.478 | 165 | C300-C300/BB350(TH120)
TH | Z/422 | 2.9 | +5.321 | +5.471 | 150 | C300-C300/BB350(TH96)
TH | Z/421 | 2.9 | +5.333 | +5.458 | 125 | C300-C300/BB350(TH75)
TH | Z/423 | 2.9 | +5.313 | +5.478 | 165 | C300-C300/BB300(TH120)
TH | Z/422 | 2.9 | +5.321 | +5.471 | 150 | C300-C300/BB300(TH96)
TH | Z/421 | 2.9 | +5.333 | +5.458 | 125 | C300-C300/BB300(TH75)
PLATE | Z/1543 | 8.9 | +5.457 | +6.032 | 99 | C300/BB350(TH120)>
PLATE | Z/1543 | 8.9 | +5.451 | +6.027 | 99 | C300/BB350(TH96)-BB350(TH120)
PLATE | Z/1543 | 8.9 | +5.447 | +6.023 | 99 | C300/BB350(TH75)-BB350(TH96)
BB TRUSS BRACKET | Z/3146 | 4.3 | +5.628 | +6.013 | 147.699 | C300-C300/BB350(TH75)-BB350(TH96)
TH | Z/423 | 2.9 | +6.077 | +6.216 | 165 | C300-C300/BB350(TH120)>
FASCIA | Z/420 | 9.4 | +5.824 | +5.976 | 64 | C300-C300/BB350(TH120)
BEAM | Z/3156 | 28.2 | +5.626 | +5.976 | 125 | C300-C300/BB350(TH120)
FASCIA | Z/420 | 9.4 | +5.800 | +5.952 | 64 | C300-C300/BB350(TH96)
BEAM | Z/3156 | 28.2 | +5.602 | +5.952 | 125 | C300-C300/BB350(TH96)
FASCIA | Z/420 | 9.4 | +5.778 | +5.930 | 64 | C300-C300/BB350(TH75)
BEAM | Z/3156 | 28.2 | +5.580 | +5.930 | 125 | C300-C300/BB350(TH75)
BEAM | Z/3154 | 23.6 | +5.651 | +5.951 | 96 | C300-C300/BB300(TH120)
PLATE | Z/1543 | 8.9 | +5.457 | +6.032 | 99 | C300/BB300(TH120)-BB350(TH75)
FASCIA | Z/420 | 9.4 | +5.824 | +5.976 | 64 | C300-C300/BB300(TH120)
BEAM | Z/3154 | 23.6 | +5.671 | +5.971 | 96 | C300-C300/BB300(TH96)
PLATE | Z/1543 | 8.9 | +5.476 | +6.052 | 99 | C300/BB300(TH96)-BB300(TH120)
FASCIA | Z/420 | 9.4 | +5.824 | +5.976 | 64 | C300-C300/BB300(TH96)
BEAM | Z/3154 | 23.6 | +5.676 | +5.976 | 96 | C300-C300/BB300(TH75)
PLATE | Z/1543 | 8.9 | +5.493 | +6.069 | 99 | C300/BB300(TH75)-BB300(TH96)
FASCIA | Z/420 | 9.4 | +5.824 | +5.976 | 64 | C300-C300/BB300(TH75)
TH | Z/406 | 2.9 | +5.421 | +5.586 | 165 | C250-C250/BB350(TH120)
TH | Z/405 | 2.9 | +5.428 | +5.578 | 150 | C250-C250/BB350(TH96)
TH | Z/404 | 2.9 | +5.441 | +5.566 | 125 | C250-C250/BB350(TH75)
TH | Z/406 | 2.9 | +5.421 | +5.586 | 165 | C250-C250/BB300(TH120)
TH | Z/405 | 2.9 | +5.428 | +5.578 | 150 | C250-C250/BB300(TH96)
TH | Z/404 | 2.9 | +5.441 | +5.566 | 125 | C250-C250/BB300(TH75)
TH | Z/406 | 2.9 | +5.421 | +5.586 | 165 | C250-C250/BB250(TH120)
TH | Z/405 | 2.9 | +5.428 | +5.578 | 150 | C250-C250/BB250(TH96)
TH | Z/404 | 2.9 | +5.441 | +5.566 | 125 | C250-C250/BB250(TH75)
PLATE | Z/1289 | 5.2 | +5.607 | +6.034 | 79 | C250/BB350(TH75)
PLATE | Z/1289 | 5.2 | +5.590 | +6.017 | 79 | C250/BB350(TH96)
PLATE | Z/1289 | 5.2 | +5.571 | +5.998 | 79 | C250/BB350(TH120)
FASCIA | Z/409 | 8.1 | +5.823 | +5.975 | 64 | C250-C250/BB350(TH120)
TH | Z/406 | 2.9 | +6.069 | +6.208 | 165 | C250-C250/BB350(TH120)>
BEAM | Z/3085 | 28.5 | +5.625 | +5.975 | 125 | C250-C250/BB350(TH120)
FASCIA | Z/409 | 8.1 | +5.823 | +5.975 | 64 | C250-C250/BB350(TH96)
BEAM | Z/3085 | 28.5 | +5.625 | +5.975 | 125 | C250-C250/BB350(TH96)
FASCIA | Z/409 | 8.1 | +5.823 | +5.975 | 64 | C250-C250/BB350(TH75)
BEAM | Z/3085 | 28.5 | +5.625 | +5.975 | 125 | C250-C250/BB350(TH75)
PLATE | Z/1289 | 5.2 | +5.607 | +6.034 | 79 | C250/BB300(TH75)
PLATE | Z/1289 | 5.2 | +5.590 | +6.017 | 79 | C250/BB300(TH96)
PLATE | Z/1289 | 5.2 | +5.571 | +5.998 | 79 | C250/BB300(TH120)
BB TRUSS BRACKET | Z/3057 | 2.9 | +5.710 | +6.023 | 147.999 | C250-C250/BB300(TH75)
BB TRUSS BRACKET | Z/3058 | 2.9 | +5.710 | +6.023 | 147.999 | C250-C250/BB300(TH75)
