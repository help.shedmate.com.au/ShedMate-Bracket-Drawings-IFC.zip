Properties of the parts of a building model (IFC2X3), part 1 of 2

# File
Description: ViewDefinition[CoordinationView_V2.0, QuantityTakeOffAddOnView], Option [BaseQuantities:On], Option [GridExport:On], Option [Assemblies:On], Option [Bolts:On], Option [Rebars:On], Option [PourObjects:Off], Option [Welds:Off], Option [SurfaceTreatments:Off], Option [LocationBy:0], Option [ViewColors:Off], Option [SectionedSpine:Off], Option [PropertySets:On], Option [Export all:Off]
File name: Adjustable Fascia Bracket(Upper skillion roof).ifc
Time: 2026-07-14T15:23:54
Author: DESKTOP-BKNQL56\admin
Organization: Structural Designer
Written by: IFC Database version: Work
Made in: Tekla Structures 2019 Service Pack 13, IFC Export Version: 4.0.0.0 Oct 18 2021

# IfcBuildingStorey, Undefined
In: Undefined
Elevation: 0 mm

# IfcBeam: C:100-15 (6)
In: Undefined
Description: C:100-15; Material: STEEL/300PLUS
Tekla Common - Phase: 1; Class: 13
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0.5 m2; Area per tons: 178.7 m2; Height: 102 mm; Width: 51 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
FASCIA | Z/343 | +2.495 | +2.597 | 18.6 | 3.3 | 7350 | 3.33022 | 0.00248063 | 19.4729
FASCIA | Z/343 | +4.473 | +4.575 | 18.6 | 3.3 | 7350 | 3.33022 | 0.00248063 | 19.4729
FASCIA | Z/343 | +6.452 | +6.554 | 18.6 | 3.3 | 7350 | 3.33022 | 0.00248063 | 19.4729
FASCIA | F/17 | +5.949 | +6.051 | 19.1 | 3.4 | 7550 | 3.42082 | 0.00254813 | 20.0028
FASCIA | F/17 | +3.949 | +4.051 | 19.1 | 3.4 | 7550 | 3.42082 | 0.00254813 | 20.0028
FASCIA | F/17 | +1.949 | +2.051 | 19.1 | 3.4 | 7550 | 3.42082 | 0.00254813 | 20.0028

# IfcBeam: C:150-15 (6)
In: Undefined
Description: C:150-15; Material: STEEL/300PLUS
Tekla Common - Phase: 1; Class: 13
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0.5 m2; Area per tons: 176.3 m2; Height: 152 mm; Width: 64 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
FASCIA | Z/342 | +2.442 | +2.594 | 25.6 | 4.5 | 7350 | 4.50647 | 0.00336262 | 26.3966
FASCIA | Z/342 | +4.420 | +4.572 | 25.6 | 4.5 | 7350 | 4.50647 | 0.00336262 | 26.3966
FASCIA | Z/342 | +6.399 | +6.551 | 25.6 | 4.5 | 7350 | 4.50647 | 0.00336262 | 26.3966
FASCIA | F/13 | +5.899 | +6.051 | 26.2 | 4.7 | 7550 | 4.62906 | 0.00345413 | 27.1149
FASCIA | F/13 | +3.899 | +4.051 | 26.2 | 4.7 | 7550 | 4.62906 | 0.00345413 | 27.1149
FASCIA | F/13 | +1.899 | +2.051 | 26.2 | 4.7 | 7550 | 4.62906 | 0.00345413 | 27.1149

# IfcBeam: C:150-24 (42)
In: Undefined
Description: C:150-24; Material: STEEL/G450
Tekla Common - Phase: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 152 mm; Width: 64 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Finish | Bottom elevation | Top elevation | Class | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
6 x RAFTER | Z/325 | 12 deg | +2.084 | +2.316 | 1 | 2.2 | 111.8 | 0.2 | 400 | 400 | 0.249316 | 0.000295104 | 2.31657
6 x RAFTER | Z/325 | 12 deg | +4.125 | +4.357 | 1 | 2.2 | 111.8 | 0.2 | 400 | 400 | 0.249316 | 0.000295104 | 2.31657
6 x RAFTER | Z/325 | 12 deg | +6.166 | +6.398 | 1 | 2.2 | 111.8 | 0.2 | 400 | 400 | 0.249316 | 0.000295104 | 2.31657
6 x RAFTER | Z/322 | 12 deg | +1.772 | +2.233 | 1 | 8.4 | 111.3 | 0.9 | 1500 | 1500 | 0.930876 | 0.00110664 | 8.68712
6 x RAFTER | Z/322 | 12 deg | +3.813 | +4.274 | 1 | 8.4 | 111.3 | 0.9 | 1500 | 1500 | 0.930876 | 0.00110664 | 8.68712
6 x RAFTER | Z/322 | 12 deg | +5.854 | +6.314 | 1 | 8.4 | 111.3 | 0.9 | 1500 | 1500 | 0.930876 | 0.00110664 | 8.68712
3 x COLUMN | Z/321 |  | +0.000 | +6.051 | 12 | 33.7 | 111.2 | 3.8 | 6050.7 | 6050.73 | 3.75051 | 0.00446399 | 35.0423
2 x COLUMN | Z/326 | 12 deg | -0.000 | +6.518 | 10 | 36.3 | 111.2 | 4 | 6517.8 | 6517.76 | 4.03988 | 0.00480854 | 37.7471
COLUMN | Z/327 | 12 deg | +0.006 | +6.518 | 10 | 36.3 | 111.2 | 4 | 6511.6 | 6511.57 | 4.03604 | 0.00480398 | 37.7112

# IfcBeam: C:200-15 (6)
In: Undefined
Description: C:200-15; Material: STEEL/300PLUS
Tekla Common - Phase: 1; Class: 13
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0.6 m2; Area per tons: 175.2 m2; Height: 203 mm; Width: 76 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
FASCIA | Z/339 | +2.389 | +2.592 | 32 | 5.7 | 7350 | 5.60919 | 0.0041895 | 32.8876
FASCIA | Z/339 | +4.367 | +4.570 | 32 | 5.7 | 7350 | 5.60919 | 0.0041895 | 32.8876
FASCIA | Z/339 | +6.346 | +6.549 | 32 | 5.7 | 7350 | 5.60919 | 0.0041895 | 32.8876
FASCIA | F/18 | +5.848 | +6.051 | 32.9 | 5.8 | 7550 | 5.76179 | 0.0043035 | 33.7825
FASCIA | F/18 | +3.848 | +4.051 | 32.9 | 5.8 | 7550 | 5.76179 | 0.0043035 | 33.7825
FASCIA | F/18 | +1.848 | +2.051 | 32.9 | 5.8 | 7550 | 5.76179 | 0.0043035 | 33.7825

# IfcBeam: C:200-24 (42)
In: Undefined
Description: C:200-24; Material: STEEL/G450
Tekla Common - Phase: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 203 mm; Width: 76 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Finish | Bottom elevation | Top elevation | Class | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
6 x RAFTER | Z/334 | 12 deg | +2.021 | +2.303 | 1 | 2.8 | 110.6 | 0.3 | 400 | 400 | 0.3137 | 0.000371904 | 2.91945
6 x RAFTER | Z/334 | 12 deg | +4.062 | +4.344 | 1 | 2.8 | 110.6 | 0.3 | 400 | 400 | 0.3137 | 0.000371904 | 2.91945
6 x RAFTER | Z/334 | 12 deg | +6.103 | +6.384 | 1 | 2.8 | 110.6 | 0.3 | 400 | 400 | 0.3137 | 0.000371904 | 2.91945
6 x RAFTER | Z/333 | 12 deg | +1.733 | +2.233 | 1 | 10.3 | 110.2 | 1.1 | 1447.9 | 1447.89 | 1.13063 | 0.00134619 | 10.5676
6 x RAFTER | Z/333 | 12 deg | +3.774 | +4.274 | 1 | 10.3 | 110.2 | 1.1 | 1447.9 | 1447.89 | 1.13063 | 0.00134619 | 10.5676
6 x RAFTER | Z/333 | 12 deg | +5.815 | +6.314 | 1 | 10.3 | 110.2 | 1.1 | 1447.9 | 1447.89 | 1.13063 | 0.00134619 | 10.5676
3 x COLUMN | Z/332 |  | +0.000 | +6.051 | 12 | 42.9 | 110 | 4.7 | 6050.7 | 6050.73 | 4.71901 | 0.00562573 | 44.162
3 x COLUMN | Z/335 | 12 deg | +0.000 | +6.446 | 10 | 45.7 | 110 | 5 | 6445.6 | 6445.59 | 5.02684 | 0.00599285 | 47.0439

# IfcBeam: C:250-24 (42)
In: Undefined
Description: C:250-24; Material: STEEL/G450
Tekla Common - Phase: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 254 mm; Width: 76 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Finish | Bottom elevation | Top elevation | Class | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
6 x RAFTER | Z/346 | 12 deg | +1.958 | +2.290 | 1 | 3.2 | 110.3 | 0.3 | 400 | 400 | 0.35394 | 0.000419904 | 3.29625
6 x RAFTER | Z/346 | 12 deg | +3.999 | +4.331 | 1 | 3.2 | 110.3 | 0.3 | 400 | 400 | 0.35394 | 0.000419904 | 3.29625
6 x RAFTER | Z/346 | 12 deg | +6.040 | +6.371 | 1 | 3.2 | 110.3 | 0.3 | 400 | 400 | 0.35394 | 0.000419904 | 3.29625
6 x RAFTER | Z/345 | 12 deg | +1.694 | +2.233 | 1 | 11.2 | 109.8 | 1.2 | 1395.8 | 1395.78 | 1.22983 | 0.00146523 | 11.5021
6 x RAFTER | Z/345 | 12 deg | +3.735 | +4.274 | 1 | 11.2 | 109.8 | 1.2 | 1395.8 | 1395.78 | 1.22983 | 0.00146523 | 11.5021
6 x RAFTER | Z/345 | 12 deg | +5.776 | +6.314 | 1 | 11.2 | 109.8 | 1.2 | 1395.8 | 1395.78 | 1.22983 | 0.00146523 | 11.5021
3 x COLUMN | Z/344 |  | +0.000 | +6.051 | 12 | 48.5 | 109.7 | 5.3 | 6050.7 | 6050.73 | 5.32432 | 0.00635181 | 49.8617
3 x COLUMN | Z/1516 | 12 deg | +0.000 | +6.436 | 10 | 51.6 | 109.7 | 5.7 | 6435.7 | 6435.66 | 5.66291 | 0.0067559 | 53.0338

# IfcBeam: C:300-30 (42)
In: Undefined
Description: C:300-30; Material: STEEL/G450
Tekla Common - Phase: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 300 mm; Width: 96 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Finish | Bottom elevation | Top elevation | Class | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
6 x RAFTER | Z/1525 | 12 deg | +1.891 | +2.278 | 1 | 5.6 | 87.9 | 0.5 | 450 | 450 | 0.494658 | 0.00073305 | 5.75444
6 x RAFTER | Z/1525 | 12 deg | +3.932 | +4.319 | 1 | 5.6 | 87.9 | 0.5 | 450 | 450 | 0.494658 | 0.00073305 | 5.75444
6 x RAFTER | Z/1525 | 12 deg | +5.973 | +6.360 | 1 | 5.6 | 87.9 | 0.5 | 450 | 450 | 0.494658 | 0.00073305 | 5.75444
6 x RAFTER | Z/1524 | 12 deg | +1.659 | +2.233 | 1 | 16.9 | 87.4 | 1.5 | 1348.6 | 1348.58 | 1.47591 | 0.00219684 | 17.2452
6 x RAFTER | Z/1524 | 12 deg | +3.700 | +4.274 | 1 | 16.9 | 87.4 | 1.5 | 1348.6 | 1348.58 | 1.47591 | 0.00219684 | 17.2452
6 x RAFTER | Z/1524 | 12 deg | +5.741 | +6.314 | 1 | 16.9 | 87.4 | 1.5 | 1348.6 | 1348.58 | 1.47591 | 0.00219684 | 17.2452
3 x COLUMN | Z/1523 |  | +0.000 | +6.051 | 12 | 75.7 | 87.4 | 6.6 | 6050.7 | 6050.73 | 6.61066 | 0.00985664 | 77.3746
3 x COLUMN | Z/1526 | 12 deg | +0.000 | +6.445 | 10 | 80.6 | 87.4 | 7 | 6445.3 | 6445.31 | 7.04154 | 0.0104994 | 82.4204

# IfcBeam: C:350-30 (42)
In: Undefined
Description: C:350-30; Material: STEEL/G450
Tekla Common - Phase: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 350 mm; Width: 125 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Finish | Bottom elevation | Top elevation | Class | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
6 x RAFTER | Z/1647 | 12 deg | +1.829 | +2.265 | 1 | 6.7 | 87.6 | 0.6 | 450 | 450 | 0.589788 | 0.0008748 | 6.86718
6 x RAFTER | Z/1647 | 12 deg | +3.870 | +4.306 | 1 | 6.7 | 87.6 | 0.6 | 450 | 450 | 0.589788 | 0.0008748 | 6.86718
6 x RAFTER | Z/1647 | 12 deg | +5.911 | +6.347 | 1 | 6.7 | 87.6 | 0.6 | 450 | 450 | 0.589788 | 0.0008748 | 6.86718
6 x RAFTER | Z/1646 | 12 deg | +1.621 | +2.233 | 1 | 19.4 | 87.4 | 1.7 | 1297.5 | 1297.51 | 1.69325 | 0.00252236 | 19.8005
6 x RAFTER | Z/1646 | 12 deg | +3.662 | +4.274 | 1 | 19.4 | 87.4 | 1.7 | 1297.5 | 1297.51 | 1.69325 | 0.00252236 | 19.8005
6 x RAFTER | Z/1646 | 12 deg | +5.702 | +6.314 | 1 | 19.4 | 87.4 | 1.7 | 1297.5 | 1297.51 | 1.69325 | 0.00252236 | 19.8005
3 x COLUMN | Z/1645 |  | +0.000 | +6.051 | 12 | 90.5 | 87.1 | 7.9 | 6050.7 | 6050.73 | 7.88194 | 0.0117626 | 92.3366
3 x COLUMN | Z/1648 | 12 deg | +0.000 | +6.406 | 10 | 95.8 | 87.1 | 8.3 | 6406.2 | 6406.17 | 8.34472 | 0.0124536 | 97.7607

# IfcBeam: Z:100-15 (9)
In: Undefined
Description: Z:100-15
Tekla Common - Phase: 1; Class: 4
Tekla Quantity - Volume: 0 m3; Area per tons: 179 m2; Net surface area: 3.4 m2; Height: 102 mm; Width: 100.5 mm
Pset_BeamCommon - LoadBearing: no
Name | Material | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Gross footprint area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
3 x GIRT | STEEL/G450 | B/37 | +5.888 | +5.989 | 19.1 | 0.1 | 7550 | 3.42082 | 0.00254813 | 20.0028
2 x PURLIN | STEEL/300PLUS | B/33 | +6.190 | +6.311 | 19 | 0 | 7500 | 3.39817 | 0.00253125 | 19.8703
3 x GIRT | STEEL/G450 | B/37 | +5.647 | +5.747 | 19.1 | 0.1 | 7550 | 3.42082 | 0.00254813 | 20.0028
PURLIN | STEEL/300PLUS | B/33 | +6.190 | +6.311 | 19 | 0 | 7500 | 3.39818 | 0.00253125 | 19.8703

# IfcBeam: Z:150-15 (9)
In: Undefined
Description: Z:150-15
Tekla Common - Phase: 1; Class: 4
Tekla Quantity - Volume: 0 m3; Area per tons: 176.5 m2; Net surface area: 4.7 m2; Height: 152 mm; Width: 124.5 mm
Pset_BeamCommon - LoadBearing: no
Name | Material | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Gross footprint area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
3 x GIRT | STEEL/G450 | B/36 | +3.845 | +3.969 | 26.2 | 0.1 | 7550 | 4.62906 | 0.00345413 | 27.1149
2 x PURLIN | STEEL/300PLUS | B/32 | +4.147 | +4.322 | 26.1 | 0 | 7500 | 4.59841 | 0.00343125 | 26.9353
3 x GIRT | STEEL/G450 | B/36 | +3.635 | +3.759 | 26.2 | 0.1 | 7550 | 4.62906 | 0.00345413 | 27.1149
PURLIN | STEEL/300PLUS | B/32 | +4.147 | +4.322 | 26.1 | 0 | 7500 | 4.59842 | 0.00343125 | 26.9353

# IfcBeam: Z:200-15 (9)
In: Undefined
Description: Z:200-15
Tekla Common - Phase: 1; Class: 4
Tekla Quantity - Volume: 0 m3; Area per tons: 175.2 m2; Height: 203 mm; Width: 151.5 mm
Pset_BeamCommon - LoadBearing: no
Name | Material | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Gross footprint area (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
3 x GIRT | STEEL/G450 | B/34 | +1.800 | +1.951 | 32.9 | 0.1 | 5.8 | 7550 | 5.76179 | 0.0043035 | 33.7825
3 x PURLIN | STEEL/300PLUS | B/10 | +2.103 | +2.333 | 32.7 | 0 | 5.7 | 7500 | 5.72364 | 0.004275 | 33.5588
3 x GIRT | STEEL/G450 | B/34 | +1.563 | +1.714 | 32.9 | 0.1 | 5.8 | 7550 | 5.76179 | 0.0043035 | 33.7825

# IfcColumn: C:150-24 (6)
In: Undefined
Description: C:150-24; Material: STEEL/G450
Tekla Common - Phase: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 111.2 m2; Height: 152 mm; Width: 64 mm
Pset_ColumnCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Class | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x COLUMN | Z/326 | -0.000 | +6.518 | 10 | 36.3 | 4 | 6517.8 | 6517.76 | 4.03988 | 0.00480854 | 37.7471 | Tekla Common - Finish: 12 deg
COLUMN | Z/327 | +0.006 | +6.518 | 10 | 36.3 | 4 | 6511.6 | 6511.57 | 4.03604 | 0.00480398 | 37.7112 | Tekla Common - Finish: 12 deg
3 x COLUMN | Z/321 | +0.000 | +6.051 | 12 | 33.7 | 3.8 | 6050.7 | 6050.73 | 3.75051 | 0.00446399 | 35.0423

# IfcColumn: C:200-24 (6)
In: Undefined
Description: C:200-24; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Phase: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 110 m2; Height: 203 mm; Width: 76 mm
Pset_ColumnCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Top elevation | Class | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
3 x COLUMN | Z/335 | +6.446 | 10 | 45.7 | 5 | 6445.6 | 6445.59 | 5.02684 | 0.00599285 | 47.0439 | Tekla Common - Finish: 12 deg
3 x COLUMN | Z/332 | +6.051 | 12 | 42.9 | 4.7 | 6050.7 | 6050.73 | 4.71901 | 0.00562573 | 44.162

# IfcColumn: C:250-24 (6)
In: Undefined
Description: C:250-24; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Phase: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 109.7 m2; Height: 254 mm; Width: 76 mm
Pset_ColumnCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Top elevation | Class | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
3 x COLUMN | Z/1516 | +6.436 | 10 | 51.6 | 5.7 | 6435.7 | 6435.66 | 5.66291 | 0.0067559 | 53.0338 | Tekla Common - Finish: 12 deg
3 x COLUMN | Z/344 | +6.051 | 12 | 48.5 | 5.3 | 6050.7 | 6050.73 | 5.32432 | 0.00635181 | 49.8617

# IfcColumn: C:300-30 (6)
In: Undefined
Description: C:300-30; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Phase: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.4 m2; Height: 300 mm; Width: 96 mm
Pset_ColumnCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Top elevation | Class | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
3 x COLUMN | Z/1526 | +6.445 | 10 | 80.6 | 7 | 6445.3 | 6445.31 | 7.04154 | 0.0104994 | 82.4204 | Tekla Common - Finish: 12 deg
3 x COLUMN | Z/1523 | +6.051 | 12 | 75.7 | 6.6 | 6050.7 | 6050.73 | 6.61066 | 0.00985664 | 77.3746

# IfcColumn: C:350-30 (6)
In: Undefined
Description: C:350-30; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Phase: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.1 m2; Height: 350 mm; Width: 125 mm
Pset_ColumnCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Top elevation | Class | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
3 x COLUMN | Z/1648 | +6.406 | 10 | 95.8 | 8.3 | 6406.2 | 6406.17 | 8.34472 | 0.0124536 | 97.7607 | Tekla Common - Finish: 12 deg
3 x COLUMN | Z/1645 | +6.051 | 12 | 90.5 | 7.9 | 6050.7 | 6050.73 | 7.88194 | 0.0117626 | 92.3366

# IfcElementAssembly (555)
In: Undefined
PredefinedType: RIGID_FRAME
Name | ASSEMBLY_POSITION_CODE = Assembly/Cast unit position code | ASSEMBLY_POS = Assembly/Cast unit Mark | Assembly/Cast unit weight (kg) | Assembly/Cast unit bottom elevation | Assembly/Cast unit top elevation | Width (mm)
ADJUSTABLE FASCIA BRA | C350AF>/Skillion roof | PL/1695 | 2.9 | +2.165 | +2.520 | 133
ADJUSTABLE FASCIA BRA | C350AF>/Skillion roof | PL/1695 | 2.9 | +2.193 | +2.548 | 133
ADJUSTABLE FASCIA BRA | C350AF>/Skillion roof | PL/1694 | 2.4 | +4.208 | +4.498 | 133
ADJUSTABLE FASCIA BRA | C350AF>/Skillion roof | PL/1694 | 2.4 | +4.236 | +4.526 | 133
ADJUSTABLE FASCIA BRA | C350AF>/Skillion roof | PL/1693 | 1.9 | +6.247 | +6.477 | 133
ADJUSTABLE FASCIA BRA | C350AF>/Skillion roof | PL/1693 | 1.9 | +6.275 | +6.505 | 133
ADJUSTABLE FASCIA BRA | C350AF>/Skillion roof | PL/1695 | 2.9 | +2.221 | +2.576 | 133
ADJUSTABLE FASCIA BRA | C350AF>/Skillion roof | PL/1694 | 2.4 | +4.264 | +4.554 | 133
ADJUSTABLE FASCIA BRA | C350AF>/Skillion roof | PL/1693 | 1.9 | +6.303 | +6.533 | 133
RAFTER | C350AF>/<Skillion roof | Z/1647 | 6.7 | +1.829 | +2.265 | 125
RAFTER | C350AF>/<Skillion roof | Z/1647 | 6.7 | +3.870 | +4.306 | 125
RAFTER | C350AF>/<Skillion roof | Z/1647 | 6.7 | +5.911 | +6.347 | 125
3 x COLUMN | C350AF>/Skillion roof | Z/1648 | 95.8 | +0.000 | +6.406 | 125
2 x RAFTER | C350AF>/Skillion roof-Skillion roof | Z/1647 | 6.7 | +1.829 | +2.265 | 125
2 x RAFTER | C350AF>/Skillion roof-Skillion roof | Z/1647 | 6.7 | +3.870 | +4.306 | 125
2 x RAFTER | C350AF>/Skillion roof-Skillion roof | Z/1647 | 6.7 | +5.911 | +6.347 | 125
FASCIA | C150AF-C350AF>/Skillion roof | Z/339 | 32 | +2.389 | +2.592 | 76
FASCIA | C150AF-C350AF>/Skillion roof | Z/339 | 32 | +4.367 | +4.570 | 76
FASCIA | C150AF-C350AF>/Skillion roof | Z/339 | 32 | +6.346 | +6.549 | 76
FASCIA | C150AF-C350AF>/Skillion roof | Z/342 | 25.6 | +2.442 | +2.594 | 64
FASCIA | C150AF-C350AF>/Skillion roof | Z/342 | 25.6 | +4.420 | +4.572 | 64
FASCIA | C150AF-C350AF>/Skillion roof | Z/342 | 25.6 | +6.399 | +6.551 | 64
FASCIA | C150AF-C350AF>/Skillion roof | Z/343 | 18.6 | +2.495 | +2.597 | 51
FASCIA | C150AF-C350AF>/Skillion roof | Z/343 | 18.6 | +4.473 | +4.575 | 51
FASCIA | C150AF-C350AF>/Skillion roof | Z/343 | 18.6 | +6.452 | +6.554 | 51
2 x PLATE | C350AF>/Skillion roof-Skillion roof | Z/2381 | 10.1 | +1.464 | +2.050 | 128
2 x PLATE | C350AF>/Skillion roof-Skillion roof | Z/2381 | 10.1 | +3.505 | +4.091 | 128
2 x PLATE | C350AF>/Skillion roof-Skillion roof | Z/2382 | 10.1 | +5.545 | +6.132 | 128
PLATE |  | Z/2381 | 10.1 | +1.464 | +2.050 | 128
PLATE |  | Z/2381 | 10.1 | +3.505 | +4.091 | 128
PLATE |  | Z/2382 | 10.1 | +5.545 | +6.132 | 128
PLATE | C350AF>/<Skillion roof | Z/2383 | 11 | +1.705 | +2.283 | 128
PLATE | C350AF>/<Skillion roof | Z/2383 | 11 | +3.746 | +4.324 | 128
PLATE | C350AF>/<Skillion roof | Z/2383 | 11 | +5.787 | +6.364 | 128
2 x PLATE | C350AF>/Skillion roof-Skillion roof | Z/2383 | 11 | +1.705 | +2.283 | 128
2 x PLATE | C350AF>/Skillion roof-Skillion roof | Z/2383 | 11 | +3.746 | +4.324 | 128
2 x PLATE | C350AF>/Skillion roof-Skillion roof | Z/2383 | 11 | +5.787 | +6.364 | 128
2 x RAFTER | C350AF>/Skillion roof-Skillion roof | Z/1646 | 19.4 | +1.621 | +2.233 | 125
2 x RAFTER | C350AF>/Skillion roof-Skillion roof | Z/1646 | 19.4 | +3.662 | +4.274 | 125
2 x RAFTER | C350AF>/Skillion roof-Skillion roof | Z/1646 | 19.4 | +5.702 | +6.314 | 125
2 x COLUMN | C350AF>/Skillion roof-Skillion roof | Z/1645 | 90.5 | +0.000 | +6.051 | 125
RAFTER | C350AF>/<Skillion roof | Z/1646 | 19.4 | +1.621 | +2.233 | 125
RAFTER | C350AF>/<Skillion roof | Z/1646 | 19.4 | +3.662 | +4.274 | 125
RAFTER | C350AF>/<Skillion roof | Z/1646 | 19.4 | +5.702 | +6.314 | 125
2 x COLUMN |  | Z/1645 | 90.5 | +0.000 | +6.051 | 125
ADJUSTABLE FASCIA BRA | C300AF-C350AF/Skillion roof | PL/1692 | 2.4 | +2.175 | +2.520 | 125
ADJUSTABLE FASCIA BRA | C300AF-C350AF/Skillion roof | PL/1692 | 2.4 | +2.203 | +2.548 | 125
ADJUSTABLE FASCIA BRA | C300AF-C350AF/Skillion roof | PL/1691 | 2.1 | +4.213 | +4.498 | 125
ADJUSTABLE FASCIA BRA | C300AF-C350AF/Skillion roof | PL/1691 | 2.1 | +4.241 | +4.526 | 125
ADJUSTABLE FASCIA BRA | C300AF-C350AF/Skillion roof | PL/1690 | 1.6 | +6.252 | +6.477 | 125
ADJUSTABLE FASCIA BRA | C300AF-C350AF/Skillion roof | PL/1690 | 1.6 | +6.280 | +6.505 | 125
RAFTER | C300AF-C350AF/<Skillion roof | Z/1525 | 5.6 | +1.891 | +2.278 | 96
RAFTER | C300AF-C350AF/<Skillion roof | Z/1525 | 5.6 | +3.932 | +4.319 | 96
3 x COLUMN | C300AF-C350AF/Skillion roof | Z/1526 | 80.6 | +0.000 | +6.445 | 96
RAFTER | C300AF-C350AF/<Skillion roof | Z/1525 | 5.6 | +5.973 | +6.360 | 96
2 x RAFTER | C300AF-C350AF/Skillion roof-Skillion roof | Z/1525 | 5.6 | +1.891 | +2.278 | 96
2 x RAFTER | C300AF-C350AF/Skillion roof-Skillion roof | Z/1525 | 5.6 | +3.932 | +4.319 | 96
2 x RAFTER | C300AF-C350AF/Skillion roof-Skillion roof | Z/1525 | 5.6 | +5.973 | +6.360 | 96
ADJUSTABLE FASCIA BRA | C300AF-C350AF/Skillion roof | PL/1692 | 2.4 | +2.231 | +2.576 | 125
ADJUSTABLE FASCIA BRA | C300AF-C350AF/Skillion roof | PL/1691 | 2.1 | +4.269 | +4.554 | 125
ADJUSTABLE FASCIA BRA | C300AF-C350AF/Skillion roof | PL/1690 | 1.6 | +6.308 | +6.533 | 125
2 x RAFTER | C300AF-C350AF/Skillion roof-Skillion roof | Z/1524 | 16.9 | +1.659 | +2.233 | 96
2 x RAFTER | C300AF-C350AF/Skillion roof-Skillion roof | Z/1524 | 16.9 | +3.700 | +4.274 | 96
2 x RAFTER | C300AF-C350AF/Skillion roof-Skillion roof | Z/1524 | 16.9 | +5.741 | +6.314 | 96
2 x COLUMN | C300AF-C350AF/Skillion roof-Skillion roof | Z/1523 | 75.7 | +0.000 | +6.051 | 96
RAFTER | C300AF-C350AF/<Skillion roof | Z/1524 | 16.9 | +1.659 | +2.233 | 96
RAFTER | C300AF-C350AF/<Skillion roof | Z/1524 | 16.9 | +3.700 | +4.274 | 96
RAFTER | C300AF-C350AF/<Skillion roof | Z/1524 | 16.9 | +5.741 | +6.314 | 96
2 x COLUMN |  | Z/1523 | 75.7 | +0.000 | +6.051 | 96
PLATE | C300AF-C350AF/<Skillion roof | Z/2380 | 9.1 | +1.766 | +2.293 | 99
PLATE | C300AF-C350AF/<Skillion roof | Z/2380 | 9.1 | +3.807 | +4.334 | 99
PLATE | C300AF-C350AF/<Skillion roof | Z/2380 | 9.1 | +5.847 | +6.375 | 99
2 x PLATE | C300AF-C350AF/Skillion roof-Skillion roof | Z/2380 | 9.1 | +1.766 | +2.293 | 99
2 x PLATE | C300AF-C350AF/Skillion roof-Skillion roof | Z/2380 | 9.1 | +3.807 | +4.334 | 99
2 x PLATE | C300AF-C350AF/Skillion roof-Skillion roof | Z/2380 | 9.1 | +5.847 | +6.375 | 99
2 x PLATE | C300AF-C350AF/Skillion roof-Skillion roof | Z/623 | 8.8 | +1.464 | +2.040 | 99
2 x PLATE | C300AF-C350AF/Skillion roof-Skillion roof | Z/623 | 8.8 | +3.505 | +4.081 | 99
2 x PLATE | C300AF-C350AF/Skillion roof-Skillion roof | Z/623 | 8.8 | +5.546 | +6.121 | 99
PLATE |  | Z/623 | 8.8 | +1.464 | +2.040 | 99
PLATE |  | Z/623 | 8.8 | +3.505 | +4.081 | 99
PLATE |  | Z/623 | 8.8 | +5.546 | +6.121 | 99
ADJUSTABLE FASCIA BRA | C250AF-C300AF/Skillion roof | PL/1689 | 2.1 | +2.185 | +2.520 | 105
ADJUSTABLE FASCIA BRA | C250AF-C300AF/Skillion roof | PL/1689 | 2.1 | +2.213 | +2.548 | 105
ADJUSTABLE FASCIA BRA | C250AF-C300AF/Skillion roof | PL/1688 | 1.7 | +4.223 | +4.498 | 105
ADJUSTABLE FASCIA BRA | C250AF-C300AF/Skillion roof | PL/1688 | 1.7 | +4.251 | +4.526 | 105
ADJUSTABLE FASCIA BRA | C250AF-C300AF/Skillion roof | PL/1687 | 1.3 | +6.267 | +6.477 | 105
ADJUSTABLE FASCIA BRA | C250AF-C300AF/Skillion roof | PL/1687 | 1.3 | +6.295 | +6.505 | 105
RAFTER | C250AF-C300AF/<Skillion roof | Z/346 | 3.2 | +1.958 | +2.290 | 76
RAFTER | C250AF-C300AF/<Skillion roof | Z/346 | 3.2 | +3.999 | +4.331 | 76
3 x COLUMN | C250AF-C300AF/Skillion roof | Z/1516 | 51.6 | +0.000 | +6.436 | 76
RAFTER | C250AF-C300AF/<Skillion roof | Z/346 | 3.2 | +6.040 | +6.371 | 76
2 x RAFTER | C250AF-C300AF/Skillion roof-Skillion roof | Z/346 | 3.2 | +1.958 | +2.290 | 76
2 x RAFTER | C250AF-C300AF/Skillion roof-Skillion roof | Z/346 | 3.2 | +3.999 | +4.331 | 76
2 x RAFTER | C250AF-C300AF/Skillion roof-Skillion roof | Z/346 | 3.2 | +6.040 | +6.371 | 76
ADJUSTABLE FASCIA BRA | C250AF-C300AF/Skillion roof | PL/1689 | 2.1 | +2.241 | +2.576 | 105
ADJUSTABLE FASCIA BRA | C250AF-C300AF/Skillion roof | PL/1688 | 1.7 | +4.279 | +4.554 | 105
ADJUSTABLE FASCIA BRA | C250AF-C300AF/Skillion roof | PL/1687 | 1.3 | +6.323 | +6.533 | 105
2 x RAFTER | C250AF-C300AF/Skillion roof-Skillion roof | Z/345 | 11.2 | +1.694 | +2.233 | 76
2 x RAFTER | C250AF-C300AF/Skillion roof-Skillion roof | Z/345 | 11.2 | +3.735 | +4.274 | 76
2 x RAFTER | C250AF-C300AF/Skillion roof-Skillion roof | Z/345 | 11.2 | +5.776 | +6.314 | 76
2 x COLUMN | C250AF-C300AF/Skillion roof-Skillion roof | Z/344 | 48.5 | +0.000 | +6.051 | 76
RAFTER | C250AF-C300AF/<Skillion roof | Z/345 | 11.2 | +1.694 | +2.233 | 76
RAFTER | C250AF-C300AF/<Skillion roof | Z/345 | 11.2 | +3.735 | +4.274 | 76
RAFTER | C250AF-C300AF/<Skillion roof | Z/345 | 11.2 | +5.776 | +6.314 | 76
2 x COLUMN |  | Z/344 | 48.5 | +0.000 | +6.051 | 76
PLATE | C250AF-C300AF/<Skillion roof | Z/2379 | 5.8 | +1.875 | +2.303 | 79
PLATE | C250AF-C300AF/<Skillion roof | Z/2379 | 5.8 | +3.917 | +4.344 | 79
PLATE | C250AF-C300AF/<Skillion roof | Z/2379 | 5.8 | +5.957 | +6.385 | 79
2 x PLATE | C250AF-C300AF/Skillion roof-Skillion roof | Z/2379 | 5.8 | +1.875 | +2.303 | 79
2 x PLATE | C250AF-C300AF/Skillion roof-Skillion roof | Z/2379 | 5.8 | +3.917 | +4.344 | 79
2 x PLATE | C250AF-C300AF/Skillion roof-Skillion roof | Z/2379 | 5.8 | +5.957 | +6.385 | 79
2 x PLATE | C250AF-C300AF/Skillion roof-Skillion roof | Z/584 | 5.2 | +1.579 | +2.006 | 79
2 x PLATE | C250AF-C300AF/Skillion roof-Skillion roof | Z/584 | 5.2 | +3.620 | +4.047 | 79
2 x PLATE | C250AF-C300AF/Skillion roof-Skillion roof | Z/584 | 5.2 | +5.660 | +6.088 | 79
PLATE |  | Z/584 | 5.2 | +1.579 | +2.006 | 79
PLATE |  | Z/584 | 5.2 | +3.620 | +4.047 | 79
PLATE |  | Z/584 | 5.2 | +5.660 | +6.088 | 79
ADJUSTABLE FASCIA BRA | C200AF-C250AF/Skillion roof | PL/1677 | 1.6 | +2.205 | +2.520 | 105
ADJUSTABLE FASCIA BRA | C200AF-C250AF/Skillion roof | PL/1677 | 1.6 | +2.233 | +2.548 | 105
ADJUSTABLE FASCIA BRA | C200AF-C250AF/Skillion roof | PL/1676 | 1.3 | +4.243 | +4.498 | 105
ADJUSTABLE FASCIA BRA | C200AF-C250AF/Skillion roof | PL/1676 | 1.3 | +4.271 | +4.526 | 105
ADJUSTABLE FASCIA BRA | C200AF-C250AF/Skillion roof | PL/1675 | 1 | +6.287 | +6.477 | 105
ADJUSTABLE FASCIA BRA | C200AF-C250AF/Skillion roof | PL/1675 | 1 | +6.315 | +6.505 | 105
ADJUSTABLE FASCIA BRA | C200AF-C250AF/Skillion roof | PL/1677 | 1.6 | +2.261 | +2.576 | 105
ADJUSTABLE FASCIA BRA | C200AF-C250AF/Skillion roof | PL/1676 | 1.3 | +4.299 | +4.554 | 105
ADJUSTABLE FASCIA BRA | C200AF-C250AF/Skillion roof | PL/1675 | 1 | +6.343 | +6.533 | 105
RAFTER | C200AF-C250AF/<Skillion roof | Z/334 | 2.8 | +2.021 | +2.303 | 76
RAFTER | C200AF-C250AF/<Skillion roof | Z/334 | 2.8 | +4.062 | +4.344 | 76
3 x COLUMN | C200AF-C250AF/Skillion roof | Z/335 | 45.7 | +0.000 | +6.446 | 76
RAFTER | C200AF-C250AF/<Skillion roof | Z/334 | 2.8 | +6.103 | +6.384 | 76
2 x RAFTER | C200AF-C250AF/Skillion roof-Skillion roof | Z/334 | 2.8 | +2.021 | +2.303 | 76
2 x RAFTER | C200AF-C250AF/Skillion roof-Skillion roof | Z/334 | 2.8 | +4.062 | +4.344 | 76
2 x RAFTER | C200AF-C250AF/Skillion roof-Skillion roof | Z/334 | 2.8 | +6.103 | +6.384 | 76
2 x RAFTER | C200AF-C250AF/Skillion roof-Skillion roof | Z/333 | 10.3 | +1.733 | +2.233 | 76
2 x RAFTER | C200AF-C250AF/Skillion roof-Skillion roof | Z/333 | 10.3 | +3.774 | +4.274 | 76
2 x RAFTER | C200AF-C250AF/Skillion roof-Skillion roof | Z/333 | 10.3 | +5.815 | +6.314 | 76
2 x COLUMN | C200AF-C250AF/Skillion roof-Skillion roof | Z/332 | 42.9 | +0.000 | +6.051 | 76
RAFTER | C200AF-C250AF/<Skillion roof | Z/333 | 10.3 | +1.733 | +2.233 | 76
RAFTER | C200AF-C250AF/<Skillion roof | Z/333 | 10.3 | +3.774 | +4.274 | 76
RAFTER | C200AF-C250AF/<Skillion roof | Z/333 | 10.3 | +5.815 | +6.314 | 76
2 x COLUMN |  | Z/332 | 42.9 | +0.000 | +6.051 | 76
3 x PLATE | C200AF-C250AF/Skillion roof | Z/2378 | 3.5 | +1.986 | +2.314 | 79
3 x PLATE | C200AF-C250AF/Skillion roof | Z/2378 | 3.5 | +4.027 | +4.355 | 79
3 x PLATE | C200AF-C250AF/Skillion roof | Z/2378 | 3.5 | +6.068 | +6.396 | 79
2 x PLATE | C200AF-C250AF/Skillion roof-Skillion roof | Z/548 | 3.1 | +1.664 | +1.977 | 79
2 x PLATE | C200AF-C250AF/Skillion roof-Skillion roof | Z/548 | 3.1 | +3.705 | +4.019 | 79
2 x PLATE | C200AF-C250AF/Skillion roof-Skillion roof | Z/548 | 3.1 | +5.745 | +6.059 | 79
PLATE |  | Z/548 | 3.1 | +1.664 | +1.977 | 79
PLATE |  | Z/548 | 3.1 | +3.705 | +4.019 | 79
PLATE |  | Z/548 | 3.1 | +5.745 | +6.059 | 79
ADJUSTABLE FASCIA BRA | C150AF-C200AF/Skillion roof | PL/1674 | 1.3 | +2.215 | +2.520 | 105
ADJUSTABLE FASCIA BRA | C150AF-C200AF/Skillion roof | PL/1674 | 1.3 | +2.243 | +2.548 | 105
ADJUSTABLE FASCIA BRA | C150AF-C200AF/Skillion roof | PL/1674 | 1.3 | +2.271 | +2.576 | 105
ADJUSTABLE FASCIA BRA | C150AF-C200AF/Skillion roof | PL/1672 | 1.1 | +4.248 | +4.498 | 105
ADJUSTABLE FASCIA BRA | C150AF-C200AF/Skillion roof | PL/1672 | 1.1 | +4.276 | +4.526 | 105
ADJUSTABLE FASCIA BRA | C150AF-C200AF/Skillion roof | PL/1672 | 1.1 | +4.304 | +4.554 | 105
ADJUSTABLE FASCIA BRA | C150AF-C200AF/Skillion roof | PL/1671 | 0.8 | +6.297 | +6.477 | 105
ADJUSTABLE FASCIA BRA | C150AF-C200AF/Skillion roof | PL/1671 | 0.8 | +6.325 | +6.505 | 105
ADJUSTABLE FASCIA BRA | C150AF-C200AF/Skillion roof | PL/1671 | 0.8 | +6.353 | +6.533 | 105
2 x RAFTER | C150AF-C200AF/Skillion roof-Skillion roof | Z/325 | 2.2 | +2.084 | +2.316 | 64
2 x RAFTER | C150AF-C200AF/Skillion roof-Skillion roof | Z/325 | 2.2 | +4.125 | +4.357 | 64
2 x COLUMN | C150AF-C200AF/Skillion roof | Z/326 | 36.3 | -0.000 | +6.518 | 64
2 x RAFTER | C150AF-C200AF/Skillion roof-Skillion roof | Z/325 | 2.2 | +6.166 | +6.398 | 64
COLUMN | C150AF-C200AF/Skillion roof | Z/327 | 36.3 | +0.006 | +6.518 | 64
RAFTER | C150AF-C200AF/<Skillion roof | Z/325 | 2.2 | +2.084 | +2.316 | 64
RAFTER | C150AF-C200AF/<Skillion roof | Z/325 | 2.2 | +4.125 | +4.357 | 64
RAFTER | C150AF-C200AF/<Skillion roof | Z/325 | 2.2 | +6.166 | +6.398 | 64
2 x RAFTER | C150AF-C200AF/Skillion roof-Skillion roof | Z/322 | 8.4 | +1.772 | +2.233 | 64
2 x RAFTER | C150AF-C200AF/Skillion roof-Skillion roof | Z/322 | 8.4 | +3.813 | +4.274 | 64
2 x RAFTER | C150AF-C200AF/Skillion roof-Skillion roof | Z/322 | 8.4 | +5.854 | +6.314 | 64
2 x COLUMN | C150AF-C200AF/Skillion roof-Skillion roof | Z/321 | 33.7 | +0.000 | +6.051 | 64
RAFTER | C150AF-C200AF/<Skillion roof | Z/322 | 8.4 | +1.772 | +2.233 | 64
RAFTER | C150AF-C200AF/<Skillion roof | Z/322 | 8.4 | +3.813 | +4.274 | 64
RAFTER | C150AF-C200AF/<Skillion roof | Z/322 | 8.4 | +5.854 | +6.314 | 64
2 x COLUMN |  | Z/321 | 33.7 | +0.000 | +6.051 | 64
3 x PLATE | C150AF-C200AF/Skillion roof | Z/2377 | 2.6 | +2.037 | +2.325 | 67
3 x PLATE | C150AF-C200AF/Skillion roof | Z/2377 | 2.6 | +4.078 | +4.366 | 67
3 x PLATE | C150AF-C200AF/Skillion roof | Z/2377 | 2.6 | +6.119 | +6.406 | 67
2 x PLATE | C150AF-C200AF/Skillion roof-Skillion roof | Z/1657 | 2.4 | +1.664 | +1.967 | 67
2 x PLATE | C150AF-C200AF/Skillion roof-Skillion roof | Z/1657 | 2.4 | +3.705 | +4.008 | 67
2 x PLATE | C150AF-C200AF/Skillion roof-Skillion roof | Z/1657 | 2.4 | +5.746 | +6.048 | 67
PLATE |  | Z/1657 | 2.4 | +1.664 | +1.967 | 67
PLATE |  | Z/1657 | 2.4 | +3.705 | +4.008 | 67
PLATE |  | Z/1657 | 2.4 | +5.746 | +6.048 | 67
ADJUSTABLE FASCIA BRA | C350AF/Skillion roof | PL/742 | 2.9 | +2.165 | +2.520 | 133
ADJUSTABLE FASCIA BRA | C350AF/Skillion roof | PL/742 | 2.9 | +2.193 | +2.548 | 133
ADJUSTABLE FASCIA BRA | C350AF/Skillion roof | PL/741 | 2.4 | +4.208 | +4.498 | 133
ADJUSTABLE FASCIA BRA | C350AF/Skillion roof | PL/741 | 2.4 | +4.236 | +4.526 | 133
ADJUSTABLE FASCIA BRA | C350AF/Skillion roof | PL/740 | 1.9 | +6.247 | +6.477 | 133
ADJUSTABLE FASCIA BRA | C350AF/Skillion roof | PL/740 | 1.9 | +6.275 | +6.505 | 133
ADJUSTABLE FASCIA BRA | C350AF/Skillion roof | PL/742 | 2.9 | +2.221 | +2.576 | 133
ADJUSTABLE FASCIA BRA | C350AF/Skillion roof | PL/741 | 2.4 | +4.264 | +4.554 | 133
ADJUSTABLE FASCIA BRA | C350AF/Skillion roof | PL/740 | 1.9 | +6.303 | +6.533 | 133
RAFTER | C350AF/<Skillion roof | Z/1647 | 6.7 | +1.829 | +2.265 | 125
RAFTER | C350AF/<Skillion roof | Z/1647 | 6.7 | +3.870 | +4.306 | 125
RAFTER | C350AF/<Skillion roof | Z/1647 | 6.7 | +5.911 | +6.347 | 125
3 x COLUMN | C350AF/Skillion roof | Z/1648 | 95.8 | +0.000 | +6.406 | 125
2 x RAFTER | C350AF/Skillion roof-Skillion roof | Z/1647 | 6.7 | +1.829 | +2.265 | 125
2 x RAFTER | C350AF/Skillion roof-Skillion roof | Z/1647 | 6.7 | +3.870 | +4.306 | 125
2 x RAFTER | C350AF/Skillion roof-Skillion roof | Z/1647 | 6.7 | +5.911 | +6.347 | 125
ADJUSTABLE FASCIA BRA | C300AF/Skillion roof | PL/736 | 2.4 | +2.175 | +2.520 | 125
ADJUSTABLE FASCIA BRA | C300AF/Skillion roof | PL/736 | 2.4 | +2.203 | +2.548 | 125
ADJUSTABLE FASCIA BRA | C300AF/Skillion roof | PL/735 | 2.1 | +4.213 | +4.498 | 125
ADJUSTABLE FASCIA BRA | C300AF/Skillion roof | PL/735 | 2.1 | +4.241 | +4.526 | 125
ADJUSTABLE FASCIA BRA | C300AF/Skillion roof | PL/734 | 1.6 | +6.252 | +6.477 | 125
ADJUSTABLE FASCIA BRA | C300AF/Skillion roof | PL/734 | 1.6 | +6.280 | +6.505 | 125
RAFTER | C300AF/<Skillion roof | Z/1525 | 5.6 | +1.891 | +2.278 | 96
RAFTER | C300AF/<Skillion roof | Z/1525 | 5.6 | +3.932 | +4.319 | 96
3 x COLUMN | C300AF/Skillion roof | Z/1526 | 80.6 | +0.000 | +6.445 | 96
RAFTER | C300AF/<Skillion roof | Z/1525 | 5.6 | +5.973 | +6.360 | 96
2 x RAFTER | C300AF/Skillion roof-Skillion roof | Z/1525 | 5.6 | +1.891 | +2.278 | 96
2 x RAFTER | C300AF/Skillion roof-Skillion roof | Z/1525 | 5.6 | +3.932 | +4.319 | 96
2 x RAFTER | C300AF/Skillion roof-Skillion roof | Z/1525 | 5.6 | +5.973 | +6.360 | 96
ADJUSTABLE FASCIA BRA | C300AF/Skillion roof | PL/736 | 2.4 | +2.231 | +2.576 | 125
ADJUSTABLE FASCIA BRA | C300AF/Skillion roof | PL/735 | 2.1 | +4.269 | +4.554 | 125
ADJUSTABLE FASCIA BRA | C300AF/Skillion roof | PL/734 | 1.6 | +6.308 | +6.533 | 125
ADJUSTABLE FASCIA BRA | C250AF/Skillion roof | PL/733 | 2.1 | +2.185 | +2.520 | 105
ADJUSTABLE FASCIA BRA | C250AF/Skillion roof | PL/733 | 2.1 | +2.213 | +2.548 | 105
ADJUSTABLE FASCIA BRA | C250AF/Skillion roof | PL/723 | 1.7 | +4.223 | +4.498 | 105
ADJUSTABLE FASCIA BRA | C250AF/Skillion roof | PL/723 | 1.7 | +4.251 | +4.526 | 105
ADJUSTABLE FASCIA BRA | C250AF/Skillion roof | PL/722 | 1.3 | +6.267 | +6.477 | 105
ADJUSTABLE FASCIA BRA | C250AF/Skillion roof | PL/722 | 1.3 | +6.295 | +6.505 | 105
RAFTER | C250AF/<Skillion roof | Z/346 | 3.2 | +1.958 | +2.290 | 76
RAFTER | C250AF/<Skillion roof | Z/346 | 3.2 | +3.999 | +4.331 | 76
3 x COLUMN | C250AF/Skillion roof | Z/1516 | 51.6 | +0.000 | +6.436 | 76
RAFTER | C250AF/<Skillion roof | Z/346 | 3.2 | +6.040 | +6.371 | 76
2 x RAFTER | C250AF/Skillion roof-Skillion roof | Z/346 | 3.2 | +1.958 | +2.290 | 76
2 x RAFTER | C250AF/Skillion roof-Skillion roof | Z/346 | 3.2 | +3.999 | +4.331 | 76
2 x RAFTER | C250AF/Skillion roof-Skillion roof | Z/346 | 3.2 | +6.040 | +6.371 | 76
ADJUSTABLE FASCIA BRA | C250AF/Skillion roof | PL/733 | 2.1 | +2.241 | +2.576 | 105
ADJUSTABLE FASCIA BRA | C250AF/Skillion roof | PL/723 | 1.7 | +4.279 | +4.554 | 105
ADJUSTABLE FASCIA BRA | C250AF/Skillion roof | PL/722 | 1.3 | +6.323 | +6.533 | 105
ADJUSTABLE FASCIA BRA | C200AF/Skillion roof | PL/699 | 1.6 | +2.205 | +2.520 | 105
ADJUSTABLE FASCIA BRA | C200AF/Skillion roof | PL/699 | 1.6 | +2.233 | +2.548 | 105
ADJUSTABLE FASCIA BRA | C200AF/Skillion roof | PL/142 | 1.3 | +4.243 | +4.498 | 105
ADJUSTABLE FASCIA BRA | C200AF/Skillion roof | PL/142 | 1.3 | +4.271 | +4.526 | 105
ADJUSTABLE FASCIA BRA | C200AF/Skillion roof | PL/141 | 1 | +6.287 | +6.477 | 105
ADJUSTABLE FASCIA BRA | C200AF/Skillion roof | PL/141 | 1 | +6.315 | +6.505 | 105
ADJUSTABLE FASCIA BRA | C200AF/Skillion roof | PL/699 | 1.6 | +2.261 | +2.576 | 105
ADJUSTABLE FASCIA BRA | C200AF/Skillion roof | PL/142 | 1.3 | +4.299 | +4.554 | 105
ADJUSTABLE FASCIA BRA | C200AF/Skillion roof | PL/141 | 1 | +6.343 | +6.533 | 105
RAFTER | C200AF/<Skillion roof | Z/334 | 2.8 | +2.021 | +2.303 | 76
RAFTER | C200AF/<Skillion roof | Z/334 | 2.8 | +4.062 | +4.344 | 76
3 x COLUMN | C200AF/Skillion roof | Z/335 | 45.7 | +0.000 | +6.446 | 76
RAFTER | C200AF/<Skillion roof | Z/334 | 2.8 | +6.103 | +6.384 | 76
2 x RAFTER | C200AF/Skillion roof-Skillion roof | Z/334 | 2.8 | +2.021 | +2.303 | 76
2 x RAFTER | C200AF/Skillion roof-Skillion roof | Z/334 | 2.8 | +4.062 | +4.344 | 76
2 x RAFTER | C200AF/Skillion roof-Skillion roof | Z/334 | 2.8 | +6.103 | +6.384 | 76
ADJUSTABLE FASCIA BRA | C150AF/Skillion roof | PL/137 | 1.3 | +2.215 | +2.520 | 105
ADJUSTABLE FASCIA BRA | C150AF/Skillion roof | PL/137 | 1.3 | +2.243 | +2.548 | 105
ADJUSTABLE FASCIA BRA | C150AF/Skillion roof | PL/137 | 1.3 | +2.271 | +2.576 | 105
ADJUSTABLE FASCIA BRA | C150AF/Skillion roof | PL/136 | 1.1 | +4.248 | +4.498 | 105
ADJUSTABLE FASCIA BRA | C150AF/Skillion roof | PL/136 | 1.1 | +4.276 | +4.526 | 105
ADJUSTABLE FASCIA BRA | C150AF/Skillion roof | PL/136 | 1.1 | +4.304 | +4.554 | 105
ADJUSTABLE FASCIA BRA | C150AF/Skillion roof | PL/135 | 0.8 | +6.297 | +6.477 | 105
ADJUSTABLE FASCIA BRA | C150AF/Skillion roof | PL/135 | 0.8 | +6.325 | +6.505 | 105
ADJUSTABLE FASCIA BRA | C150AF/Skillion roof | PL/135 | 0.8 | +6.353 | +6.533 | 105
2 x RAFTER | C150AF/Skillion roof-Skillion roof | Z/325 | 2.2 | +2.084 | +2.316 | 64
2 x RAFTER | C150AF/Skillion roof-Skillion roof | Z/325 | 2.2 | +4.125 | +4.357 | 64
2 x COLUMN | C150AF/Skillion roof | Z/326 | 36.3 | -0.000 | +6.518 | 64
2 x RAFTER | C150AF/Skillion roof-Skillion roof | Z/325 | 2.2 | +6.166 | +6.398 | 64
COLUMN | C150AF/Skillion roof | Z/327 | 36.3 | +0.006 | +6.518 | 64
RAFTER | C150AF/<Skillion roof | Z/325 | 2.2 | +2.084 | +2.316 | 64
RAFTER | C150AF/<Skillion roof | Z/325 | 2.2 | +4.125 | +4.357 | 64
RAFTER | C150AF/<Skillion roof | Z/325 | 2.2 | +6.166 | +6.398 | 64
2 x RAFTER | C150AF/Skillion roof-Skillion roof | Z/322 | 8.4 | +1.772 | +2.233 | 64
2 x RAFTER | C200AF/Skillion roof-Skillion roof | Z/333 | 10.3 | +1.733 | +2.233 | 76
2 x RAFTER | C250AF/Skillion roof-Skillion roof | Z/345 | 11.2 | +1.694 | +2.233 | 76
2 x RAFTER | C300AF/Skillion roof-Skillion roof | Z/1524 | 16.9 | +1.659 | +2.233 | 96
2 x PLATE | C350AF/Skillion roof-Skillion roof | Z/1529 | 10.1 | +1.464 | +2.050 | 128
2 x RAFTER | C150AF/Skillion roof-Skillion roof | Z/322 | 8.4 | +3.813 | +4.274 | 64
2 x RAFTER | C200AF/Skillion roof-Skillion roof | Z/333 | 10.3 | +3.774 | +4.274 | 76
2 x RAFTER | C250AF/Skillion roof-Skillion roof | Z/345 | 11.2 | +3.735 | +4.274 | 76
2 x RAFTER | C300AF/Skillion roof-Skillion roof | Z/1524 | 16.9 | +3.700 | +4.274 | 96
2 x PLATE | C350AF/Skillion roof-Skillion roof | Z/1529 | 10.1 | +3.505 | +4.091 | 128
2 x RAFTER | C150AF/Skillion roof-Skillion roof | Z/322 | 8.4 | +5.854 | +6.314 | 64
2 x RAFTER | C200AF/Skillion roof-Skillion roof | Z/333 | 10.3 | +5.815 | +6.314 | 76
2 x RAFTER | C250AF/Skillion roof-Skillion roof | Z/345 | 11.2 | +5.776 | +6.314 | 76
2 x RAFTER | C300AF/Skillion roof-Skillion roof | Z/1524 | 16.9 | +5.741 | +6.314 | 96
2 x PLATE | C350AF/Skillion roof-Skillion roof | Z/246 | 10.1 | +5.545 | +6.132 | 128
2 x COLUMN | C150AF/Skillion roof-Skillion roof | Z/321 | 33.7 | +0.000 | +6.051 | 64
2 x COLUMN | C300AF/Skillion roof-Skillion roof | Z/1523 | 75.7 | +0.000 | +6.051 | 96
2 x COLUMN | C250AF/Skillion roof-Skillion roof | Z/344 | 48.5 | +0.000 | +6.051 | 76
2 x COLUMN | C200AF/Skillion roof-Skillion roof | Z/332 | 42.9 | +0.000 | +6.051 | 76
RAFTER | C150AF/<Skillion roof | Z/322 | 8.4 | +1.772 | +2.233 | 64
RAFTER | C200AF/<Skillion roof | Z/333 | 10.3 | +1.733 | +2.233 | 76
RAFTER | C250AF/<Skillion roof | Z/345 | 11.2 | +1.694 | +2.233 | 76
RAFTER | C300AF/<Skillion roof | Z/1524 | 16.9 | +1.659 | +2.233 | 96
PLATE |  | Z/1529 | 10.1 | +1.464 | +2.050 | 128
RAFTER | C150AF/<Skillion roof | Z/322 | 8.4 | +3.813 | +4.274 | 64
RAFTER | C200AF/<Skillion roof | Z/333 | 10.3 | +3.774 | +4.274 | 76
RAFTER | C250AF/<Skillion roof | Z/345 | 11.2 | +3.735 | +4.274 | 76
RAFTER | C300AF/<Skillion roof | Z/1524 | 16.9 | +3.700 | +4.274 | 96
PLATE |  | Z/1529 | 10.1 | +3.505 | +4.091 | 128
RAFTER | C150AF/<Skillion roof | Z/322 | 8.4 | +5.854 | +6.314 | 64
RAFTER | C200AF/<Skillion roof | Z/333 | 10.3 | +5.815 | +6.314 | 76
RAFTER | C250AF/<Skillion roof | Z/345 | 11.2 | +5.776 | +6.314 | 76
RAFTER | C300AF/<Skillion roof | Z/1524 | 16.9 | +5.741 | +6.314 | 96
PLATE |  | Z/246 | 10.1 | +5.545 | +6.132 | 128
PLATE | C350AF/<Skillion roof | Z/1527 | 11 | +1.705 | +2.283 | 128
PLATE | C350AF/<Skillion roof | Z/1527 | 11 | +3.746 | +4.324 | 128
PLATE | C350AF/<Skillion roof | Z/1527 | 11 | +5.787 | +6.364 | 128
2 x PLATE | C350AF/Skillion roof-Skillion roof | Z/1527 | 11 | +1.705 | +2.283 | 128
2 x PLATE | C350AF/Skillion roof-Skillion roof | Z/1527 | 11 | +3.746 | +4.324 | 128
2 x PLATE | C350AF/Skillion roof-Skillion roof | Z/1527 | 11 | +5.787 | +6.364 | 128
PLATE | C300AF/<Skillion roof | Z/1517 | 9.1 | +1.766 | +2.293 | 99
PLATE | C300AF/<Skillion roof | Z/1517 | 9.1 | +3.807 | +4.334 | 99
PLATE | C300AF/<Skillion roof | Z/1517 | 9.1 | +5.847 | +6.375 | 99
2 x PLATE | C300AF/Skillion roof-Skillion roof | Z/1517 | 9.1 | +1.766 | +2.293 | 99
2 x PLATE | C300AF/Skillion roof-Skillion roof | Z/1517 | 9.1 | +3.807 | +4.334 | 99
2 x PLATE | C300AF/Skillion roof-Skillion roof | Z/1517 | 9.1 | +5.847 | +6.375 | 99
PLATE | C250AF/<Skillion roof | Z/337 | 5.8 | +1.875 | +2.303 | 79
PLATE | C250AF/<Skillion roof | Z/337 | 5.8 | +3.917 | +4.344 | 79
PLATE | C250AF/<Skillion roof | Z/337 | 5.8 | +5.957 | +6.385 | 79
2 x PLATE | C250AF/Skillion roof-Skillion roof | Z/337 | 5.8 | +1.875 | +2.303 | 79
2 x PLATE | C250AF/Skillion roof-Skillion roof | Z/337 | 5.8 | +3.917 | +4.344 | 79
2 x PLATE | C250AF/Skillion roof-Skillion roof | Z/337 | 5.8 | +5.957 | +6.385 | 79
3 x PLATE | C200AF/Skillion roof | Z/328 | 3.5 | +1.986 | +2.314 | 79
3 x PLATE | C200AF/Skillion roof | Z/328 | 3.5 | +4.027 | +4.355 | 79
3 x PLATE | C200AF/Skillion roof | Z/328 | 3.5 | +6.068 | +6.396 | 79
3 x GIRT | C150AF-C350AF>/Skillion roof | B/34 | 32.9 | +1.800 | +1.951 | 151.5
3 x GIRT | C150AF-C350AF>/Skillion roof | B/36 | 26.2 | +3.845 | +3.969 | 124.5
3 x GIRT | C150AF-C350AF>/Skillion roof | B/37 | 19.1 | +5.888 | +5.989 | 100.5
3 x PLATE | C150AF/Skillion roof | Z/201 | 2.6 | +2.037 | +2.325 | 67
3 x PLATE | C150AF/Skillion roof | Z/201 | 2.6 | +4.078 | +4.366 | 67
3 x PLATE | C150AF/Skillion roof | Z/201 | 2.6 | +6.119 | +6.406 | 67
2 x PURLIN | <C150AF-C350AF>/Skillion roof-Skillion roof | B/10 | 32.7 | +2.103 | +2.333 | 151.5
2 x PLATE | C150AF/Skillion roof-Skillion roof | Z/318 | 2.4 | +1.664 | +1.967 | 67
2 x PLATE | C200AF/Skillion roof-Skillion roof | Z/227 | 3.1 | +1.664 | +1.977 | 79
2 x PLATE | C250AF/Skillion roof-Skillion roof | Z/234 | 5.2 | +1.579 | +2.006 | 79
2 x PLATE | C300AF/Skillion roof-Skillion roof | Z/240 | 8.8 | +1.464 | +2.040 | 99
2 x RAFTER | C350AF/Skillion roof-Skillion roof | Z/1646 | 19.4 | +1.621 | +2.233 | 125
2 x PURLIN | <C150AF-C350AF>/Skillion roof-Skillion roof | B/32 | 26.1 | +4.147 | +4.322 | 124.5
2 x PLATE | C150AF/Skillion roof-Skillion roof | Z/318 | 2.4 | +3.705 | +4.008 | 67
2 x PLATE | C200AF/Skillion roof-Skillion roof | Z/227 | 3.1 | +3.705 | +4.019 | 79
2 x PLATE | C250AF/Skillion roof-Skillion roof | Z/234 | 5.2 | +3.620 | +4.047 | 79
2 x PLATE | C300AF/Skillion roof-Skillion roof | Z/240 | 8.8 | +3.505 | +4.081 | 99
2 x RAFTER | C350AF/Skillion roof-Skillion roof | Z/1646 | 19.4 | +3.662 | +4.274 | 125
2 x PURLIN | <C150AF-C350AF>/Skillion roof-Skillion roof | B/33 | 19 | +6.190 | +6.311 | 100.5
2 x PLATE | C150AF/Skillion roof-Skillion roof | Z/318 | 2.4 | +5.746 | +6.048 | 67
2 x PLATE | C200AF/Skillion roof-Skillion roof | Z/227 | 3.1 | +5.745 | +6.059 | 79
2 x PLATE | C250AF/Skillion roof-Skillion roof | Z/234 | 5.2 | +5.660 | +6.088 | 79
2 x PLATE | C300AF/Skillion roof-Skillion roof | Z/240 | 8.8 | +5.546 | +6.121 | 99
2 x RAFTER | C350AF/Skillion roof-Skillion roof | Z/1646 | 19.4 | +5.702 | +6.314 | 125
FASCIA | C150AF-C350AF>/Skillion roof-Skillion roof | F/18 | 32.9 | +5.848 | +6.051 | 76
2 x GIRT | C150AF-C350AF>/Skillion roof-Skillion roof | B/37 | 19.1 | +5.647 | +5.747 | 100.5
FASCIA | C150AF-C350AF>/Skillion roof-Skillion roof | F/18 | 32.9 | +3.848 | +4.051 | 76
2 x GIRT | C150AF-C350AF>/Skillion roof-Skillion roof | B/36 | 26.2 | +3.635 | +3.759 | 124.5
FASCIA | C150AF-C350AF>/Skillion roof-Skillion roof | F/18 | 32.9 | +1.848 | +2.051 | 76
2 x GIRT | C150AF-C350AF>/Skillion roof-Skillion roof | B/34 | 32.9 | +1.563 | +1.714 | 151.5
2 x COLUMN | C350AF/Skillion roof-Skillion roof | Z/1645 | 90.5 | +0.000 | +6.051 | 125
FASCIA | C150AF-C350AF>/Skillion roof-Skillion roof | F/17 | 19.1 | +5.949 | +6.051 | 51
FASCIA | C150AF-C350AF>/Skillion roof-Skillion roof | F/17 | 19.1 | +3.949 | +4.051 | 51
FASCIA | C150AF-C350AF>/Skillion roof-Skillion roof | F/17 | 19.1 | +1.949 | +2.051 | 51
PURLIN | <C150AF-C350AF>/<Skillion roof | B/10 | 32.7 | +2.103 | +2.333 | 151.5
PLATE |  | Z/318 | 2.4 | +1.664 | +1.967 | 67
PLATE |  | Z/227 | 3.1 | +1.664 | +1.977 | 79
PLATE |  | Z/234 | 5.2 | +1.579 | +2.006 | 79
PLATE |  | Z/240 | 8.8 | +1.464 | +2.040 | 99
RAFTER | C350AF/<Skillion roof | Z/1646 | 19.4 | +1.621 | +2.233 | 125
PURLIN |  | B/32 | 26.1 | +4.147 | +4.322 | 124.5
PLATE |  | Z/318 | 2.4 | +3.705 | +4.008 | 67
PLATE |  | Z/227 | 3.1 | +3.705 | +4.019 | 79
PLATE |  | Z/234 | 5.2 | +3.620 | +4.047 | 79
PLATE |  | Z/240 | 8.8 | +3.505 | +4.081 | 99
RAFTER | C350AF/<Skillion roof | Z/1646 | 19.4 | +3.662 | +4.274 | 125
PURLIN |  | B/33 | 19 | +6.190 | +6.311 | 100.5
PLATE |  | Z/318 | 2.4 | +5.746 | +6.048 | 67
PLATE |  | Z/227 | 3.1 | +5.745 | +6.059 | 79
PLATE |  | Z/234 | 5.2 | +5.660 | +6.088 | 79
PLATE |  | Z/240 | 8.8 | +5.546 | +6.121 | 99
RAFTER | C350AF/<Skillion roof | Z/1646 | 19.4 | +5.702 | +6.314 | 125
FASCIA |  | F/13 | 26.2 | +5.899 | +6.051 | 64
GIRT |  | B/37 | 19.1 | +5.647 | +5.747 | 100.5
FASCIA |  | F/13 | 26.2 | +3.899 | +4.051 | 64
GIRT |  | B/36 | 26.2 | +3.635 | +3.759 | 124.5
FASCIA |  | F/13 | 26.2 | +1.899 | +2.051 | 64
GIRT |  | B/34 | 32.9 | +1.563 | +1.714 | 151.5

# IfcMechanicalFastener: Bolt assembly (810)
In: Undefined
Tekla Bolt - Location: Site
Name | NominalDiameter (mm) = Washer diameter (mm) | NominalLength (mm) = Bolt length (mm) | Material = Bolt standard | Washer count = Nut count | Washer type | Washer name | Nut type | Nut name | Slotted hole y (mm) | Slotted hole x (mm) | Bolt hole diameter (mm) | Bolt count | Bolt size (mm) | Bolt Name
12 x Bolt assembly | 12 | 8 | 8.8S | 0 | HARD | WASHERM12-HARD | 8.8-HEX | NUTM12-8.8-HEX | 0 | 147 | 18 | 1 | 18 | BOLTM12*16
18 x Bolt assembly | 12 | 8 | 8.8S | 0 | HARD | WASHERM12-HARD | 8.8-HEX | NUTM12-8.8-HEX | 0 | 97 | 18 | 1 | 18 | BOLTM12*16
48 x Bolt assembly | 12 | 8 | 8.8S | 0 | HARD | WASHERM12-HARD | 8.8-HEX | NUTM12-8.8-HEX | 0 | 137 | 18 | 1 | 18 | BOLTM12*16
24 x Bolt assembly | 12 | 8 | 8.8S | 0 | HARD | WASHERM12-HARD | 8.8-HEX | NUTM12-8.8-HEX | 0 | 127 | 18 | 1 | 18 | BOLTM12*16
36 x Bolt assembly | 16 | 40 | 8.8S | 6 | HARD | WASHERM16-HARD | 8.8-HEX | NUTM16-8.8-HEX | 4 | 0 | 18 | 6 | 16 | BOLTM16*40
36 x Bolt assembly | 16 | 11 | 8.8S | 0 | HARD | WASHERM16-HARD | 8.8-HEX | NUTM16-8.8-HEX | 0 | 0 | 16 | 6 | 16 | BOLTM16*25
180 x Bolt assembly | 12 | 30 | FB1230Z | 1 | FLAT | WASHERM12-FLAT | 4.6-HEX | NUTM12-4.6-HEX | 0 | 0 | 14 | 1 | 12 | BOLTFB1230
36 x Bolt assembly | 12 | 30 | 8.8S | 6 | HARD | WASHERM12-HARD | 8.8-HEX | NUTM12-8.8-HEX | 4 | 8 | 14 | 6 | 12 | BOLTM12*30
36 x Bolt assembly | 12 | 30 | 8.8S | 6 | HARD | WASHERM12-HARD | 8.8-HEX | NUTM12-8.8-HEX | 8 | 4 | 14 | 6 | 12 | BOLTM12*30
18 x Bolt assembly | 12 | 8 | 8.8S | 0 | HARD | WASHERM12-HARD | 8.8-HEX | NUTM12-8.8-HEX | 0 | 87 | 18 | 1 | 18 | BOLTM12*16
24 x Bolt assembly | 12 | 8 | 8.8S | 0 | HARD | WASHERM12-HARD | 8.8-HEX | NUTM12-8.8-HEX | 0 | 122 | 18 | 1 | 18 | BOLTM12*16
54 x Bolt assembly | 12 | 8 | 8.8S | 0 | HARD | WASHERM12-HARD | 8.8-HEX | NUTM12-8.8-HEX | 0 | 67 | 18 | 1 | 18 | BOLTM12*16
18 x Bolt assembly | 16 | 35 | 8.8S | 4 | HARD | WASHERM16-HARD | 8.8-HEX | NUTM16-8.8-HEX | 4 | 0 | 18 | 4 | 16 | BOLTM16*35
18 x Bolt assembly | 16 | 10.4 | 8.8S | 0 | HARD | WASHERM16-HARD | 8.8-HEX | NUTM16-8.8-HEX | 0 | 0 | 16 | 4 | 16 | BOLTM16*25
90 x Bolt assembly | 12 | 30 | 8.8S | 4 | HARD | WASHERM12-HARD | 8.8-HEX | NUTM12-8.8-HEX | 8 | 4 | 14 | 4 | 12 | BOLTM12*30
36 x Bolt assembly | 12 | 30 | 8.8S | 4 | HARD | WASHERM12-HARD | 8.8-HEX | NUTM12-8.8-HEX | 4 | 8 | 14 | 4 | 12 | BOLTM12*30
12 x Bolt assembly | 12 | 8 | 8.8S | 0 | HARD | WASHERM12-HARD | 8.8-HEX | NUTM12-8.8-HEX | 0 | 117 | 18 | 1 | 18 | BOLTM12*16
36 x Bolt assembly | 12 | 8 | 8.8S | 0 | HARD | WASHERM12-HARD | 8.8-HEX | NUTM12-8.8-HEX | 0 | 107 | 18 | 1 | 18 | BOLTM12*16
12 x Bolt assembly | 12 | 8 | 8.8S | 0 | HARD | WASHERM12-HARD | 8.8-HEX | NUTM12-8.8-HEX | 0 | 102 | 18 | 1 | 18 | BOLTM12*16
54 x Bolt assembly | 12 | 10.4 | 8.8S | 0 | HARD | WASHERM12-HARD | 8.8-HEX | NUTM12-8.8-HEX | 0 | 0 | 12 | 4 | 12 | BOLTM12*16
12 x Bolt assembly | 12 | 8 | 8.8S | 0 | HARD | WASHERM12-HARD | 8.8-HEX | NUTM12-8.8-HEX | 0 | 92 | 18 | 1 | 18 | BOLTM12*16

# IfcPlate: PLT3*180 (6)
In: Undefined
Description: PLT3*180; Material: STEEL/250
Tekla Common - Phase: 1; Class: 2
Tekla Quantity - Weight: 0.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 88.6 m2; Net surface area: 0.1 m2; Height: 180 mm; Width: 3 mm; Length: 333.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 180 mm; NetArea: 0.0712312 m2; GrossArea: 0.0600423 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000102432 m3; GrossVolume: 0.000116457 m3
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation
ADJUSTABLE FASCIA BRA | PL/1671 | +6.297 | +6.477
ADJUSTABLE FASCIA BRA | PL/1671 | +6.325 | +6.505
ADJUSTABLE FASCIA BRA | PL/1671 | +6.353 | +6.533
ADJUSTABLE FASCIA BRA | PL/135 | +6.297 | +6.477
ADJUSTABLE FASCIA BRA | PL/135 | +6.325 | +6.505
ADJUSTABLE FASCIA BRA | PL/135 | +6.353 | +6.533

# IfcPlate: PLT3*190 (6)
In: Undefined
Description: PLT3*190; Material: STEEL/250
Tekla Common - Phase: 1; Class: 2
Tekla Quantity - Weight: 1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 88.1 m2; Net surface area: 0.1 m2; Height: 190 mm; Width: 3 mm; Length: 384.1 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 190 mm; NetArea: 0.0913703 m2; GrossArea: 0.0729711 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000132105 m3; GrossVolume: 0.000149917 m3
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation
ADJUSTABLE FASCIA BRA | PL/1675 | +6.287 | +6.477
ADJUSTABLE FASCIA BRA | PL/1675 | +6.315 | +6.505
ADJUSTABLE FASCIA BRA | PL/1675 | +6.343 | +6.533
ADJUSTABLE FASCIA BRA | PL/141 | +6.287 | +6.477
ADJUSTABLE FASCIA BRA | PL/141 | +6.315 | +6.505
ADJUSTABLE FASCIA BRA | PL/141 | +6.343 | +6.533

# IfcPlate: PLT3*210 (6)
In: Undefined
Description: PLT3*210; Material: STEEL/250
Tekla Common - Phase: 1; Class: 2
Tekla Quantity - Weight: 1.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.6 m2; Net surface area: 0.1 m2; Height: 210 mm; Width: 3 mm; Length: 434.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 210 mm; NetArea: 0.117256 m2; GrossArea: 0.0912573 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000170272 m3; GrossVolume: 0.000191871 m3
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation
ADJUSTABLE FASCIA BRA | PL/1687 | +6.267 | +6.477
ADJUSTABLE FASCIA BRA | PL/1687 | +6.295 | +6.505
ADJUSTABLE FASCIA BRA | PL/1687 | +6.323 | +6.533
ADJUSTABLE FASCIA BRA | PL/722 | +6.267 | +6.477
ADJUSTABLE FASCIA BRA | PL/722 | +6.295 | +6.505
ADJUSTABLE FASCIA BRA | PL/722 | +6.323 | +6.533

# IfcPlate: PLT3*225 (6)
In: Undefined
Description: PLT3*225; Material: STEEL/250
Tekla Common - Phase: 1; Class: 2
Tekla Quantity - Weight: 1.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.4 m2; Net surface area: 0.1 m2; Height: 225 mm; Width: 3 mm; Length: 502.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 225 mm; NetArea: 0.140142 m2; GrossArea: 0.113076 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000203932 m3; GrossVolume: 0.000239211 m3
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation
ADJUSTABLE FASCIA BRA | PL/1690 | +6.252 | +6.477
ADJUSTABLE FASCIA BRA | PL/1690 | +6.280 | +6.505
ADJUSTABLE FASCIA BRA | PL/1690 | +6.308 | +6.533
ADJUSTABLE FASCIA BRA | PL/734 | +6.252 | +6.477
ADJUSTABLE FASCIA BRA | PL/734 | +6.280 | +6.505
ADJUSTABLE FASCIA BRA | PL/734 | +6.308 | +6.533

# IfcPlate: PLT3*230 (6)
In: Undefined
Description: PLT3*230; Material: STEEL/250
Tekla Common - Phase: 1; Class: 2
Tekla Quantity - Weight: 1.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.4 m2; Net surface area: 0.2 m2; Height: 230 mm; Width: 3 mm; Length: 560.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 230 mm; NetArea: 0.163977 m2; GrossArea: 0.128928 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000239121 m3; GrossVolume: 0.00027965 m3
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation
ADJUSTABLE FASCIA BRA | PL/1693 | +6.247 | +6.477
ADJUSTABLE FASCIA BRA | PL/1693 | +6.275 | +6.505
ADJUSTABLE FASCIA BRA | PL/1693 | +6.303 | +6.533
ADJUSTABLE FASCIA BRA | PL/740 | +6.247 | +6.477
ADJUSTABLE FASCIA BRA | PL/740 | +6.275 | +6.505
ADJUSTABLE FASCIA BRA | PL/740 | +6.303 | +6.533

# IfcPlate: PLT3*250 (6)
In: Undefined
Description: PLT3*250; Material: STEEL/250
Tekla Common - Phase: 1; Class: 2
Tekla Quantity - Weight: 1.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 88.1 m2; Net surface area: 0.1 m2; Height: 250 mm; Width: 3 mm; Length: 383.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 250 mm; NetArea: 0.0947256 m2; GrossArea: 0.0958946 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000136921 m3; GrossVolume: 0.000172472 m3
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation
ADJUSTABLE FASCIA BRA | PL/1672 | +4.248 | +4.498
ADJUSTABLE FASCIA BRA | PL/1672 | +4.276 | +4.526
ADJUSTABLE FASCIA BRA | PL/1672 | +4.304 | +4.554
ADJUSTABLE FASCIA BRA | PL/136 | +4.248 | +4.498
ADJUSTABLE FASCIA BRA | PL/136 | +4.276 | +4.526
ADJUSTABLE FASCIA BRA | PL/136 | +4.304 | +4.554

# IfcPlate: PLT3*255 (6)
In: Undefined
Description: PLT3*255; Material: STEEL/250
Tekla Common - Phase: 1; Class: 2
Tekla Quantity - Weight: 1.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.6 m2; Net surface area: 0.1 m2; Height: 255 mm; Width: 3 mm; Length: 434.1 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 255 mm; NetArea: 0.117558 m2; GrossArea: 0.110687 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000170687 m3; GrossVolume: 0.000213812 m3
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation
ADJUSTABLE FASCIA BRA | PL/1676 | +4.243 | +4.498
ADJUSTABLE FASCIA BRA | PL/1676 | +4.271 | +4.526
ADJUSTABLE FASCIA BRA | PL/1676 | +4.299 | +4.554
ADJUSTABLE FASCIA BRA | PL/142 | +4.243 | +4.498
ADJUSTABLE FASCIA BRA | PL/142 | +4.271 | +4.526
ADJUSTABLE FASCIA BRA | PL/142 | +4.299 | +4.554

# IfcPlate: PLT3*275 (6)
In: Undefined
Description: PLT3*275; Material: STEEL/250
Tekla Common - Phase: 1; Class: 2
Tekla Quantity - Weight: 1.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.4 m2; Net surface area: 0.1 m2; Height: 275 mm; Width: 3 mm; Length: 484.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 275 mm; NetArea: 0.149954 m2; GrossArea: 0.133256 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000218664 m3; GrossVolume: 0.000269364 m3
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation
ADJUSTABLE FASCIA BRA | PL/1688 | +4.223 | +4.498
ADJUSTABLE FASCIA BRA | PL/1688 | +4.251 | +4.526
ADJUSTABLE FASCIA BRA | PL/1688 | +4.279 | +4.554
ADJUSTABLE FASCIA BRA | PL/723 | +4.223 | +4.498
ADJUSTABLE FASCIA BRA | PL/723 | +4.251 | +4.526
ADJUSTABLE FASCIA BRA | PL/723 | +4.279 | +4.554

# IfcPlate: PLT3*285 (6)
In: Undefined
Description: PLT3*285; Material: STEEL/250
Tekla Common - Phase: 1; Class: 2
Tekla Quantity - Weight: 2.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.1 m2; Net surface area: 0.2 m2; Height: 285 mm; Width: 3 mm; Length: 552.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 285 mm; NetArea: 0.181014 m2; GrossArea: 0.157482 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000264564 m3; GrossVolume: 0.000322464 m3
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation
ADJUSTABLE FASCIA BRA | PL/1691 | +4.213 | +4.498
ADJUSTABLE FASCIA BRA | PL/1691 | +4.241 | +4.526
ADJUSTABLE FASCIA BRA | PL/1691 | +4.269 | +4.554
ADJUSTABLE FASCIA BRA | PL/735 | +4.213 | +4.498
ADJUSTABLE FASCIA BRA | PL/735 | +4.241 | +4.526
ADJUSTABLE FASCIA BRA | PL/735 | +4.269 | +4.554

# IfcPlate: PLT3*290 (6)
In: Undefined
Description: PLT3*290; Material: STEEL/250
Tekla Common - Phase: 1; Class: 2
Tekla Quantity - Weight: 2.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87 m2; Net surface area: 0.2 m2; Height: 290 mm; Width: 3 mm; Length: 610.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 290 mm; NetArea: 0.209647 m2; GrossArea: 0.177065 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000306954 m3; GrossVolume: 0.000372354 m3
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation
ADJUSTABLE FASCIA BRA | PL/1694 | +4.208 | +4.498
ADJUSTABLE FASCIA BRA | PL/1694 | +4.236 | +4.526
ADJUSTABLE FASCIA BRA | PL/1694 | +4.264 | +4.554
ADJUSTABLE FASCIA BRA | PL/741 | +4.208 | +4.498
ADJUSTABLE FASCIA BRA | PL/741 | +4.236 | +4.526
ADJUSTABLE FASCIA BRA | PL/741 | +4.264 | +4.554

# IfcPlate: PLT3*305 (6)
In: Undefined
Description: PLT3*305; Material: STEEL/250
Tekla Common - Phase: 1; Class: 2
Tekla Quantity - Weight: 1.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.9 m2; Net surface area: 0.1 m2; Height: 305 mm; Width: 3 mm; Length: 434.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 305 mm; NetArea: 0.114183 m2; GrossArea: 0.132543 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000165455 m3; GrossVolume: 0.000230255 m3
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation
ADJUSTABLE FASCIA BRA | PL/1674 | +2.215 | +2.520
ADJUSTABLE FASCIA BRA | PL/1674 | +2.243 | +2.548
ADJUSTABLE FASCIA BRA | PL/1674 | +2.271 | +2.576
ADJUSTABLE FASCIA BRA | PL/137 | +2.215 | +2.520
ADJUSTABLE FASCIA BRA | PL/137 | +2.243 | +2.548
ADJUSTABLE FASCIA BRA | PL/137 | +2.271 | +2.576

# IfcPlate: PLT3*308.7 (18)
In: Undefined
Description: PLT3*308.7; Material: STEEL/450
