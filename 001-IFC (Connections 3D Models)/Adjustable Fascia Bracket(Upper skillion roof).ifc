Properties of the parts of a building model (IFC2X3), part 2 of 2

# IfcPlate: PLT3*308.7 (18)
Tekla Common - Phase: 1; Class: 11
Tekla Quantity - Weight: 2.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.6 m2; Net surface area: 0.2 m2; Height: 308.7 mm; Width: 3 mm; Length: 451.2 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - NetArea: 0.216526 m2; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Width (mm) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
3 x PLATE | Z/1657 | +1.664 | +1.967 | 308.673 | 0.139264 | 0.000318537
3 x PLATE | Z/1657 | +3.705 | +4.008 | 308.673 | 0.139264 | 0.000318537
3 x PLATE | Z/1657 | +5.746 | +6.048 | 308.673 | 0.139264 | 0.000318537
3 x PLATE | Z/318 | +1.664 | +1.967 | 308.662 | 0.139258 | 0.000318536
3 x PLATE | Z/318 | +3.705 | +4.008 | 308.662 | 0.139258 | 0.000318536
3 x PLATE | Z/318 | +5.746 | +6.048 | 308.662 | 0.139258 | 0.000318536

# IfcPlate: PLT3*315 (6)
In: Undefined
Description: PLT3*315; Material: STEEL/250
Tekla Common - Phase: 1; Class: 2
Tekla Quantity - Weight: 1.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.4 m2; Net surface area: 0.1 m2; Height: 315 mm; Width: 3 mm; Length: 485.1 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 315 mm; NetArea: 0.142893 m2; GrossArea: 0.152793 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000208003 m3; GrossVolume: 0.000284163 m3
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation
ADJUSTABLE FASCIA BRA | PL/1677 | +2.205 | +2.520
ADJUSTABLE FASCIA BRA | PL/1677 | +2.233 | +2.548
ADJUSTABLE FASCIA BRA | PL/1677 | +2.261 | +2.576
ADJUSTABLE FASCIA BRA | PL/699 | +2.205 | +2.520
ADJUSTABLE FASCIA BRA | PL/699 | +2.233 | +2.548
ADJUSTABLE FASCIA BRA | PL/699 | +2.261 | +2.576

# IfcPlate: PLT3*333.3 (18)
In: Undefined
Description: PLT3*333.3; Material: STEEL/450
Tekla Common - Phase: 1; Class: 11
Tekla Quantity - Weight: 3.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.4 m2; Net surface area: 0.3 m2; Height: 333.3 mm; Width: 3 mm; Length: 496.9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - NetArea: 0.266193 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000392276 m3; GrossVolume: 0.000392276 m3
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Width (mm) | GrossArea (m2)
3 x PLATE | Z/548 | +1.664 | +1.977 | 333.309 | 0.165626
3 x PLATE | Z/548 | +3.705 | +4.019 | 333.309 | 0.165626
3 x PLATE | Z/548 | +5.745 | +6.059 | 333.309 | 0.165626
3 x PLATE | Z/227 | +1.664 | +1.977 | 333.291 | 0.165615
3 x PLATE | Z/227 | +3.705 | +4.019 | 333.291 | 0.165615
3 x PLATE | Z/227 | +5.745 | +6.059 | 333.291 | 0.165615

# IfcPlate: PLT3*335 (6)
In: Undefined
Description: PLT3*335; Material: STEEL/250
Tekla Common - Phase: 1; Class: 2
Tekla Quantity - Weight: 2.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.1 m2; Net surface area: 0.2 m2; Height: 335 mm; Width: 3 mm; Length: 535.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 335 mm; NetArea: 0.179837 m2; GrossArea: 0.179412 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000262812 m3; GrossVolume: 0.000350335 m3
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation
ADJUSTABLE FASCIA BRA | PL/1689 | +2.185 | +2.520
ADJUSTABLE FASCIA BRA | PL/1689 | +2.213 | +2.548
ADJUSTABLE FASCIA BRA | PL/1689 | +2.241 | +2.576
ADJUSTABLE FASCIA BRA | PL/733 | +2.185 | +2.520
ADJUSTABLE FASCIA BRA | PL/733 | +2.213 | +2.548
ADJUSTABLE FASCIA BRA | PL/733 | +2.241 | +2.576

# IfcPlate: PLT3*344.1 (18)
In: Undefined
Description: PLT3*344.1; Material: STEEL/450
Tekla Common - Phase: 1; Class: 11
Tekla Quantity - Weight: 2.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.6 m2; Net surface area: 0.2 m2; Height: 344.1 mm; Width: 3 mm; Length: 408.8 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 344.143 mm; NetArea: 0.225714 m2; GrossArea: 0.140681 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00033197 m3; GrossVolume: 0.00033197 m3
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation
3 x PLATE | Z/2377 | +2.037 | +2.325
3 x PLATE | Z/2377 | +4.078 | +4.366
3 x PLATE | Z/2377 | +6.119 | +6.406
3 x PLATE | Z/201 | +2.037 | +2.325
3 x PLATE | Z/201 | +4.078 | +4.366
3 x PLATE | Z/201 | +6.119 | +6.406

# IfcPlate: PLT3*345 (6)
In: Undefined
Description: PLT3*345; Material: STEEL/250
Tekla Common - Phase: 1; Class: 2
Tekla Quantity - Weight: 2.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87 m2; Net surface area: 0.2 m2; Height: 345 mm; Width: 3 mm; Length: 603.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 345 mm; NetArea: 0.214763 m2; GrossArea: 0.208228 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000314517 m3; GrossVolume: 0.000412839 m3
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation
ADJUSTABLE FASCIA BRA | PL/1692 | +2.175 | +2.520
ADJUSTABLE FASCIA BRA | PL/1692 | +2.203 | +2.548
ADJUSTABLE FASCIA BRA | PL/1692 | +2.231 | +2.576
ADJUSTABLE FASCIA BRA | PL/736 | +2.175 | +2.520
ADJUSTABLE FASCIA BRA | PL/736 | +2.203 | +2.548
ADJUSTABLE FASCIA BRA | PL/736 | +2.231 | +2.576

# IfcPlate: PLT3*355 (6)
In: Undefined
Description: PLT3*355; Material: STEEL/250
Tekla Common - Phase: 1; Class: 2
Tekla Quantity - Weight: 2.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.8 m2; Net surface area: 0.3 m2; Height: 355 mm; Width: 3 mm; Length: 661.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 355 mm; NetArea: 0.25123 m2; GrossArea: 0.234853 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000368621 m3; GrossVolume: 0.000478194 m3
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation
ADJUSTABLE FASCIA BRA | PL/1695 | +2.165 | +2.520
ADJUSTABLE FASCIA BRA | PL/1695 | +2.193 | +2.548
ADJUSTABLE FASCIA BRA | PL/1695 | +2.221 | +2.576
ADJUSTABLE FASCIA BRA | PL/742 | +2.165 | +2.520
ADJUSTABLE FASCIA BRA | PL/742 | +2.193 | +2.548
ADJUSTABLE FASCIA BRA | PL/742 | +2.221 | +2.576

# IfcPlate: PLT3*396.7 (18)
In: Undefined
Description: PLT3*396.7; Material: STEEL/450
Tekla Common - Phase: 1; Class: 11
Tekla Quantity - Weight: 3.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.4 m2; Net surface area: 0.3 m2; Height: 396.7 mm; Width: 3 mm; Length: 470.4 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 396.7 mm; NetArea: 0.300701 m2; GrossArea: 0.186604 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000443447 m3; GrossVolume: 0.000443447 m3
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation
3 x PLATE | Z/2378 | +1.986 | +2.314
3 x PLATE | Z/2378 | +4.027 | +4.355
3 x PLATE | Z/2378 | +6.068 | +6.396
3 x PLATE | Z/328 | +1.986 | +2.314
3 x PLATE | Z/328 | +4.027 | +4.355
3 x PLATE | Z/328 | +6.068 | +6.396

# IfcPlate: PLT3*426.1 (18)
In: Undefined
Description: PLT3*426.1; Material: STEEL/450
Tekla Common - Phase: 1; Class: 11
Tekla Quantity - Weight: 5.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.1 m2; Net surface area: 0.3 m2; Height: 426.1 mm; Width: 3 mm; Length: 656.1 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - NetArea: 0.449082 m2; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Width (mm) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
3 x PLATE | Z/584 | +1.579 | +2.006 | 426.096 | 0.279571 | 0.000664571
3 x PLATE | Z/584 | +3.620 | +4.047 | 426.096 | 0.279571 | 0.000664571
3 x PLATE | Z/584 | +5.660 | +6.088 | 426.096 | 0.279571 | 0.000664571
3 x PLATE | Z/234 | +1.579 | +2.006 | 426.082 | 0.27956 | 0.000664572
3 x PLATE | Z/234 | +3.620 | +4.047 | 426.082 | 0.27956 | 0.000664572
3 x PLATE | Z/234 | +5.660 | +6.088 | 426.082 | 0.27956 | 0.000664572

# IfcPlate: PLT3*496.2 (18)
In: Undefined
Description: PLT3*496.2; Material: STEEL/450
Tekla Common - Phase: 1; Class: 11
Tekla Quantity - Weight: 5.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.1 m2; Net surface area: 0.5 m2; Height: 496.2 mm; Width: 3 mm; Length: 615.1 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 496.203 mm; NetArea: 0.496119 m2; GrossArea: 0.305235 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000734453 m3; GrossVolume: 0.000734453 m3
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation
3 x PLATE | Z/2379 | +1.875 | +2.303
3 x PLATE | Z/2379 | +3.917 | +4.344
3 x PLATE | Z/2379 | +5.957 | +6.385
3 x PLATE | Z/337 | +1.875 | +2.303
3 x PLATE | Z/337 | +3.917 | +4.344
3 x PLATE | Z/337 | +5.957 | +6.385

# IfcPlate: PLT3*565.6 (18)
In: Undefined
Description: PLT3*565.6; Material: STEEL/450
Tekla Common - Phase: 1; Class: 11
Tekla Quantity - Weight: 8.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.9 m2; Height: 565.6 mm; Width: 3 mm; Length: 853.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - NetArea: 0.754232 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00111964 m3; GrossVolume: 0.00111964 m3
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Width (mm) | GrossArea (m2)
3 x PLATE | Z/623 | +1.464 | +2.040 | 565.637 | 0.482806
3 x PLATE | Z/623 | +3.505 | +4.081 | 565.637 | 0.482806
3 x PLATE | Z/623 | +5.546 | +6.121 | 565.637 | 0.482806
3 x PLATE | Z/240 | +1.464 | +2.040 | 565.634 | 0.482802
3 x PLATE | Z/240 | +3.505 | +4.081 | 565.634 | 0.482802
3 x PLATE | Z/240 | +5.546 | +6.121 | 565.634 | 0.482802

# IfcPlate: PLT3*606.1 (18)
In: Undefined
Description: PLT3*606.1; Material: STEEL/450
Tekla Common - Phase: 1; Class: 11
Tekla Quantity - Weight: 10.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.9 m2; Height: 606.1 mm; Width: 3 mm; Length: 905.1 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - NetArea: 0.865061 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00128499 m3; GrossVolume: 0.00128499 m3
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Width (mm) | GrossArea (m2)
3 x PLATE | Z/2381 | +1.464 | +2.050 | 606.065 | 0.548538
3 x PLATE | Z/2381 | +3.505 | +4.091 | 606.065 | 0.548538
3 x PLATE | Z/2382 | +5.545 | +6.132 | 606.065 | 0.548538
3 x PLATE | Z/1529 | +1.464 | +2.050 | 606.062 | 0.548534
3 x PLATE | Z/1529 | +3.505 | +4.091 | 606.062 | 0.548534
3 x PLATE | Z/246 | +5.545 | +6.132 | 606.062 | 0.548534

# IfcPlate: PLT3*615.6 (18)
In: Undefined
Description: PLT3*615.6; Material: STEEL/450
Tekla Common - Phase: 1; Class: 11
Tekla Quantity - Weight: 9.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.9 m2; Height: 615.6 mm; Width: 3 mm; Length: 783.2 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 615.642 mm; NetArea: 0.776955 m2; GrossArea: 0.48217 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00115317 m3; GrossVolume: 0.00115317 m3
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation
3 x PLATE | Z/2380 | +1.766 | +2.293
3 x PLATE | Z/2380 | +3.807 | +4.334
3 x PLATE | Z/2380 | +5.847 | +6.375
3 x PLATE | Z/1517 | +1.766 | +2.293
3 x PLATE | Z/1517 | +3.807 | +4.334
3 x PLATE | Z/1517 | +5.847 | +6.375

# IfcPlate: PLT3*693.6 (18)
In: Undefined
Description: PLT3*693.6; Material: STEEL/450
Tekla Common - Phase: 1; Class: 11
Tekla Quantity - Weight: 11 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.7 m2; Net surface area: 0.9 m2; Height: 693.6 mm; Width: 3 mm; Length: 843.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 693.603 mm; NetArea: 0.939159 m2; GrossArea: 0.585119 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00139527 m3; GrossVolume: 0.00139527 m3
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation
3 x PLATE | Z/2383 | +1.705 | +2.283
3 x PLATE | Z/2383 | +3.746 | +4.324
3 x PLATE | Z/2383 | +5.787 | +6.364
3 x PLATE | Z/1527 | +1.705 | +2.283
3 x PLATE | Z/1527 | +3.746 | +4.324
3 x PLATE | Z/1527 | +5.787 | +6.364
