Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView_V2.0, QuantityTakeOffAddOnView], Option [BaseQuantities:On], Option [GridExport:On], Option [Assemblies:On], Option [Bolts:On], Option [Rebars:On], Option [PourObjects:Off], Option [Welds:Off], Option [SurfaceTreatments:On], Option [LocationBy:0], Option [ViewColors:Off], Option [SectionedSpine:Off], Option [PropertySets:On], Option [Export all:Off]
File name: TURNBUCKLE CONNECTION.ifc
Time: 2026-08-22T18:19:35
Author: LAPTOP-2P0BGI6B\lablab
Organization: Structural Designer
Written by: IFC Database Version: Work
Made in: Tekla Structures 2019 Service Pack 13, IFC Export Version: 4.0.0.0 Oct 18 2021

# IfcBuildingStorey, Undefined
In: Undefined
Elevation: 0 mm

# IfcBeam: C:150-24 (2)
In: Undefined
Description: C:150-24; Material: STEEL/G450
Default - ASSEMBLY_POS: Z/2676
Pset_BeamCommon - LoadBearing: no; Reference: Z/2676
BaseQuantities - Length: 5063.14 mm; OuterSurfaceArea: 3.1386 m2; NetVolume: 0.00373538 m3; NetWeight: 29.3228 kg

# IfcBuildingElementProxy: M12 Turnbuckle
In: Undefined
Description: M12 Turnbuckle; Material: STEEL/.

# IfcBuildingElementProxy: M8 Turnbuckle
In: Undefined
Description: M8 Turnbuckle; Material: STEEL/.

# IfcCovering: 12 deg (2)
In: Undefined
Material: Undefined/Undefined

# IfcElementAssembly (6)
In: Undefined
PredefinedType: RIGID_FRAME
Name | ASSEMBLY_POSITION_CODE | ASSEMBLY_POS | Width (mm)
M12 Turnbuckle | M12 Turnbuckle/ | S/93 | 34
COLUMN | M12 Turnbuckle/ | Z/2676 | 64
BRACING STRAP | M12 Turnbuckle/ | BS/2 | 1.2
M8 Turnbuckle | M8 Turnbuckle/ | S/92 | 26.3746
COLUMN | M8 Turnbuckle/ | Z/2676 | 64
BRACING STRAP | M8 Turnbuckle/ | BS/1 | 1.2

# IfcMechanicalFastener: Bolt assembly (6)
In: Undefined
NominalDiameter: 12 mm; NominalLength: 30 mm
Name | Material
4 x Bolt assembly | PB1230
2 x Bolt assembly | 8.8S

# IfcMember: PLT1.2*30, BRACING STRAP
In: Undefined
Description: PLT1.2*30; Material: STEEL/250
Pset_MemberCommon - LoadBearing: no; Reference: BS/1
BaseQuantities - Length: 350.001 mm; OuterSurfaceArea: 0.0219121 m2; GrossSurfaceArea: 0.0219121 m2; CrossSectionArea: 0.000036 m2; NetVolume: 0.0000126 m3; GrossVolume: 0.0000126 m3; NetWeight: 0.0989103 kg; GrossWeight: 0.0989103 kg

# IfcMember: PLT1.2*50, BRACING STRAP
In: Undefined
Description: PLT1.2*50; Material: STEEL/250
Pset_MemberCommon - LoadBearing: no; Reference: BS/2
BaseQuantities - Length: 350.001 mm; OuterSurfaceArea: 0.0359601 m2; GrossSurfaceArea: 0.0359601 m2; CrossSectionArea: 0.00006 m2; NetVolume: 0.0000210001 m3; GrossVolume: 0.0000210001 m3; NetWeight: 0.164851 kg; GrossWeight: 0.164851 kg
