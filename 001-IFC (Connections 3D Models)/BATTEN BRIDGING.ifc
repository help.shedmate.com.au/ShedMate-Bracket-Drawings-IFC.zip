Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView_V2.0, QuantityTakeOffAddOnView], Option [BaseQuantities:On], Option [GridExport:On], Option [Assemblies:On], Option [Bolts:On], Option [Rebars:On], Option [PourObjects:Off], Option [Welds:Off], Option [SurfaceTreatments:On], Option [LocationBy:0], Option [ViewColors:Off], Option [SectionedSpine:Off], Option [PropertySets:On], Option [Export all:Off]
File name: BATTEN BRIDGING.ifc
Time: 2026-08-22T18:22:26
Author: LAPTOP-2P0BGI6B\lablab
Organization: Structural Designer
Written by: IFC Database Version: Work
Made in: Tekla Structures 2019 Service Pack 13, IFC Export Version: 4.0.0.0 Oct 18 2021

# IfcBuildingStorey, Undefined
In: Undefined
Elevation: 0 mm

# IfcBeam: BATTEN:22 (4)
In: Undefined
Description: BATTEN:22; Material: STEEL/G450
Default - ASSEMBLY_POS: BT/0(?)
Pset_BeamCommon - LoadBearing: no; Reference: BT/0(?)
Name | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
BATTEN | 1176.56 | 0.221748 | 0.0000587339 | 0.461061
BATTEN | 7881.08 | 1.48479 | 0.000393424 | 3.08838
BATTEN | 1190.39 | 0.224354 | 0.0000594245 | 0.466482
BATTEN | 7836.58 | 1.4764 | 0.000391202 | 3.07094

# IfcBeam: C:100-15, FASCIA
In: Undefined
Description: C:100-15; Material: STEEL/G450
Default - ASSEMBLY_POS: F/0(?)
Pset_BeamCommon - LoadBearing: no; Reference: F/0(?)
BaseQuantities - Length: 5448 mm; OuterSurfaceArea: 2.46862 m2; NetVolume: 0.0018387 m3; NetWeight: 14.4338 kg

# IfcBeam: C:150-19, FASCIA
In: Undefined
Description: C:150-19; Material: STEEL/G450
Default - ASSEMBLY_POS: F/0(?)
Pset_BeamCommon - LoadBearing: no; Reference: F/0(?)
BaseQuantities - Length: 5448 mm; OuterSurfaceArea: 3.3495 m2; NetVolume: 0.00316126 m3; NetWeight: 24.8159 kg

# IfcBeam: TH:96-95 (13)
In: Undefined
Description: TH:96-95; Material: STEEL/G450
Pset_BeamCommon - LoadBearing: no
BaseQuantities - Length: 5898 mm; OuterSurfaceArea: 0.00000268961 m2; NetVolume: 0.00169374 m3; NetWeight: 13.2959 kg
Name | ASSEMBLY_POS = Reference
5 x GIRT | G/0(?)
8 x PURLIN | PU/0(?)

# IfcBeam: Z:150-12 (13)
In: Undefined
Description: Z:150-12; Material: STEEL/G450
Pset_BeamCommon - LoadBearing: no
BaseQuantities - Length: 5898 mm; OuterSurfaceArea: 3.60323 m2; NetVolume: 0.00215301 m3; NetWeight: 16.9011 kg
Name | ASSEMBLY_POS = Reference
5 x GIRT | G/0(?)
8 x PURLIN | PU/0(?)

# IfcColumn: BATTEN:22 (2)
In: Undefined
Description: BATTEN:22; Material: STEEL/G450
Default - ASSEMBLY_POS: BT/0(?)
Pset_ColumnCommon - LoadBearing: no; Reference: BT/0(?)
Name | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
BATTEN | 5214.8 | 0.982496 | 0.000260323 | 2.04354
BATTEN | 5200.2 | 0.979746 | 0.000259594 | 2.03781

# IfcElementAssembly (34)
In: Undefined
PredefinedType: RIGID_FRAME
Name | ASSEMBLY_POS | Width (mm)
8 x PURLIN | PU/0(?) | 150
6 x BATTEN | BT/0(?) | 22
5 x GIRT | G/0(?) | 150
FASCIA | F/0(?) | 51
5 x GIRT | G/0(?) | 124.8
8 x PURLIN | PU/0(?) | 124.8
FASCIA | F/0(?) | 64

# IfcMechanicalFastener: Bolt assembly (72)
In: Undefined
NominalDiameter: 5 mm; NominalLength: 12.7 mm; Material: SCREW
