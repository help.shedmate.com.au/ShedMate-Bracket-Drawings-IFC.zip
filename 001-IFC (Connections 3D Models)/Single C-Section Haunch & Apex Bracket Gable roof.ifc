Properties of the parts of a building model (IFC2X3), part 2 of 2

# IfcPlate: PLT3*355.5, PLATE
Pset_PlateCommon - LoadBearing: no; Reference: PL/21
BaseQuantities - Width: 355.548 mm; NetArea: 0.211784 m2; GrossArea: 0.159386 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000311633 m3; GrossVolume: 0.000311633 m3

# IfcPlate: PLT3*363.8 (2)
In: Undefined
Description: PLT3*363.8; Material: STEEL/450
Tekla Common - Bottom elevation: +4.775; Top elevation: +5.192; Phase: 1; Class: 11
Tekla Quantity - Weight: 3.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.3 m2; Height: 363.8 mm; Width: 3 mm; Length: 564.9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 363.821 mm; NetArea: 0.315463 m2; GrossArea: 0.205516 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00046552 m3; GrossVolume: 0.00046552 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/42
PLATE | PL/41

# IfcPlate: PLT3*364.6 (4)
In: Undefined
Description: PLT3*364.6; Material: STEEL/250
Default - ASSEMBLY_POS: PL/149
Tekla Common - Phase: 1; Class: 2
Tekla Quantity - Weight: 3.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.5 m2; Net surface area: 0.3 m2; Height: 364.6 mm; Width: 3 mm; Length: 400 mm
Pset_PlateCommon - LoadBearing: no; Reference: PL/149
BaseQuantities - Width: 364.596 mm; NetArea: 0.299732 m2; GrossArea: 0.145838 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000441291 m3; GrossVolume: 0.000441291 m3
Name | Bottom elevation | Top elevation
2 x STIFFINER SLEEVE | +4.934 | +5.259
2 x STIFFINER SLEEVE | +3.983 | +4.383

# IfcPlate: PLT3*373.7, PLATE
In: Undefined
Description: PLT3*373.7; Material: STEEL/450
Default - ASSEMBLY_POS: PL/43
Tekla Common - Bottom elevation: +5.609; Top elevation: +5.872; Phase: 1; Class: 11
Tekla Quantity - Weight: 3.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.3 m2; Height: 373.7 mm; Width: 3 mm; Length: 529.1 mm
Pset_PlateCommon - LoadBearing: no; Reference: PL/43
BaseQuantities - Width: 373.729 mm; NetArea: 0.298692 m2; GrossArea: 0.197735 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000440768 m3; GrossVolume: 0.000440768 m3

# IfcPlate: PLT3*393.6, PLATE
In: Undefined
Description: PLT3*393.6; Material: STEEL/450
Default - ASSEMBLY_POS: PL/44
Tekla Common - Bottom elevation: +5.822; Top elevation: +6.099; Phase: 1; Class: 11
Tekla Quantity - Weight: 3.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.3 m2; Height: 393.6 mm; Width: 3 mm; Length: 541.3 mm
Pset_PlateCommon - LoadBearing: no; Reference: PL/44
BaseQuantities - Width: 393.583 mm; NetArea: 0.307078 m2; GrossArea: 0.213063 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000453276 m3; GrossVolume: 0.000453276 m3

# IfcPlate: PLT3*400 (8)
In: Undefined
Description: PLT3*400; Material: STEEL/250
Tekla Common - Phase: 1; Class: 2
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.5 m2; Height: 400 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 400 mm; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
2 x STIFFINER SLEEVE | PL/151 | +4.875 | +5.293 | 5.3 | 86.2 | 555 | 0.453195 | 0.221998 | 0.000669771
2 x STIFFINER SLEEVE | PL/151 | +3.808 | +4.208 | 5.3 | 86.2 | 555 | 0.453195 | 0.221998 | 0.000669771
2 x STIFFINER SLEEVE | PL/150 | +4.907 | +5.276 | 4.2 | 86.3 | 447 | 0.366147 | 0.178798 | 0.000540171
2 x STIFFINER SLEEVE | PL/150 | +3.888 | +4.288 | 4.2 | 86.3 | 447 | 0.366147 | 0.178798 | 0.000540171

# IfcPlate: PLT3*412, PLATE
In: Undefined
Description: PLT3*412; Material: STEEL/450
Default - ASSEMBLY_POS: PL/45
Tekla Common - Bottom elevation: +6.041; Top elevation: +6.332; Phase: 1; Class: 11
Tekla Quantity - Weight: 3.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.3 m2; Height: 412 mm; Width: 3 mm; Length: 550.3 mm
Pset_PlateCommon - LoadBearing: no; Reference: PL/45
BaseQuantities - Width: 411.971 mm; NetArea: 0.315115 m2; GrossArea: 0.226702 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000465263 m3; GrossVolume: 0.000465263 m3

# IfcPlate: PLT3*424.7, PLATE
In: Undefined
Description: PLT3*424.7; Material: STEEL/450
Default - ASSEMBLY_POS: PL/63
Tekla Common - Bottom elevation: +5.562; Top elevation: +5.877; Phase: 1; Class: 11
Tekla Quantity - Weight: 4.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.2 m2; Net surface area: 0.3 m2; Height: 424.7 mm; Width: 3 mm; Length: 549.8 mm
Pset_PlateCommon - LoadBearing: no; Reference: PL/63
BaseQuantities - Width: 424.728 mm; NetArea: 0.354893 m2; GrossArea: 0.23353 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000524514 m3; GrossVolume: 0.000524514 m3

# IfcPlate: PLT3*426.1 (2)
In: Undefined
Description: PLT3*426.1; Material: STEEL/450
Tekla Common - Bottom elevation: +4.692; Top elevation: +5.119; Phase: 1; Class: 11
Tekla Quantity - Weight: 5.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.2 m2; Net surface area: 0.3 m2; Height: 426.1 mm; Width: 3 mm; Length: 656.1 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - NetArea: 0.449082 m2; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Width (mm) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
PLATE | PL/64 | 426.096 | 0.279571 | 0.000664571
PLATE | PL/62 | 426.082 | 0.27956 | 0.000664572

# IfcPlate: PLT3*435.4, PLATE
In: Undefined
Description: PLT3*435.4; Material: STEEL/450
Tekla Common - Bottom elevation: +4.692; Top elevation: +5.149; Phase: 1; Class: 11
Tekla Quantity - Weight: 5.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.2 m2; Net surface area: 0.5 m2; Height: 435.5 mm; Width: 3 mm; Length: 675.7 mm
Default - ASSEMBLY_POS: PL/58
Pset_PlateCommon - LoadBearing: no; Reference: PL/58
BaseQuantities - Width: 435.438 mm; NetArea: 0.465321 m2; GrossArea: 0.294207 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000688788 m3; GrossVolume: 0.000688788 m3

# IfcPlate: PLT3*435.5, PLATE
In: Undefined
Description: PLT3*435.5; Material: STEEL/450
Default - ASSEMBLY_POS: PL/59
Tekla Common - Bottom elevation: +4.692; Top elevation: +5.149; Phase: 1; Class: 11
Tekla Quantity - Weight: 5.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.2 m2; Net surface area: 0.5 m2; Height: 435.5 mm; Width: 3 mm; Length: 675.7 mm
Pset_PlateCommon - LoadBearing: no; Reference: PL/59
BaseQuantities - Width: 435.459 mm; NetArea: 0.465321 m2; GrossArea: 0.294224 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000688799 m3; GrossVolume: 0.000688799 m3

# IfcPlate: PLT3*443.8, PLATE
In: Undefined
Description: PLT3*443.8; Material: STEEL/450
Tekla Common - Bottom elevation: +4.692; Top elevation: +5.180; Phase: 1; Class: 11
Default - ASSEMBLY_POS: PL/56
Tekla Quantity - Weight: 5.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.5 m2; Height: 443.8 mm; Width: 3 mm; Length: 695.5 mm
Pset_PlateCommon - LoadBearing: no; Reference: PL/56
BaseQuantities - Width: 443.844 mm; NetArea: 0.48188 m2; GrossArea: 0.308713 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000713477 m3; GrossVolume: 0.000713477 m3

# IfcPlate: PLT3*443.9, PLATE
In: Undefined
Description: PLT3*443.9; Material: STEEL/450
Default - ASSEMBLY_POS: PL/57
Tekla Common - Bottom elevation: +4.692; Top elevation: +5.180; Phase: 1; Class: 11
Tekla Quantity - Weight: 5.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.5 m2; Height: 443.9 mm; Width: 3 mm; Length: 695.6 mm
Pset_PlateCommon - LoadBearing: no; Reference: PL/57
BaseQuantities - Width: 443.894 mm; NetArea: 0.481881 m2; GrossArea: 0.308754 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000713497 m3; GrossVolume: 0.000713497 m3

# IfcPlate: PLT3*444.6, PLATE
In: Undefined
Description: PLT3*444.6; Material: STEEL/450
Default - ASSEMBLY_POS: PL/65
Tekla Common - Bottom elevation: +5.776; Top elevation: +6.105; Phase: 1; Class: 11
Tekla Quantity - Weight: 4.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.2 m2; Net surface area: 0.3 m2; Height: 444.6 mm; Width: 3 mm; Length: 566.8 mm
Pset_PlateCommon - LoadBearing: no; Reference: PL/65
BaseQuantities - Width: 444.577 mm; NetArea: 0.365885 m2; GrossArea: 0.252 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000540905 m3; GrossVolume: 0.000540905 m3

# IfcPlate: PLT3*448.1, PLATE
In: Undefined
Description: PLT3*448.1; Material: STEEL/450
Default - ASSEMBLY_POS: PL/46
Tekla Common - Bottom elevation: +6.585; Top elevation: +6.912; Phase: 1; Class: 11
Tekla Quantity - Weight: 3.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.2 m2; Net surface area: 0.3 m2; Height: 448.1 mm; Width: 3 mm; Length: 558.1 mm
Pset_PlateCommon - LoadBearing: no; Reference: PL/46
BaseQuantities - Width: 448.062 mm; NetArea: 0.332573 m2; GrossArea: 0.250076 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000491299 m3; GrossVolume: 0.000491299 m3

# IfcPlate: PLT3*459.7, PLATE
In: Undefined
Description: PLT3*459.7; Material: STEEL/450
Tekla Common - Bottom elevation: +4.692; Top elevation: +5.252; Phase: 1; Class: 11
Tekla Quantity - Weight: 6.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.5 m2; Height: 459.8 mm; Width: 3.1 mm; Length: 743.7 mm
Default - ASSEMBLY_POS: PL/54
Pset_PlateCommon - LoadBearing: no; Reference: PL/54
BaseQuantities - Width: 459.656 mm; NetArea: 0.521886 m2; GrossArea: 0.341847 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.0007731 m3; GrossVolume: 0.0007731 m3

# IfcPlate: PLT3*459.8, PLATE
In: Undefined
Description: PLT3*459.8; Material: STEEL/450
Default - ASSEMBLY_POS: PL/55
Tekla Common - Bottom elevation: +4.692; Top elevation: +5.252; Phase: 1; Class: 11
Tekla Quantity - Weight: 6.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.5 m2; Height: 459.8 mm; Width: 3.1 mm; Length: 743.7 mm
Pset_PlateCommon - LoadBearing: no; Reference: PL/55
BaseQuantities - Width: 459.8 mm; NetArea: 0.521888 m2; GrossArea: 0.341971 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000773137 m3; GrossVolume: 0.000773137 m3

# IfcPlate: PLT3*463, PLATE
In: Undefined
Description: PLT3*463; Material: STEEL/450
Default - ASSEMBLY_POS: PL/66
Tekla Common - Bottom elevation: +5.996; Top elevation: +6.341; Phase: 1; Class: 11
Tekla Quantity - Weight: 4.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.2 m2; Net surface area: 0.3 m2; Height: 463 mm; Width: 3 mm; Length: 580.3 mm
Pset_PlateCommon - LoadBearing: no; Reference: PL/66
BaseQuantities - Width: 462.973 mm; NetArea: 0.376626 m2; GrossArea: 0.268651 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000556923 m3; GrossVolume: 0.000556923 m3

# IfcPlate: PLT3*499.1, PLATE
In: Undefined
Description: PLT3*499.1; Material: STEEL/450
Default - ASSEMBLY_POS: PL/67
Tekla Common - Bottom elevation: +6.540; Top elevation: +6.924; Phase: 1; Class: 11
Tekla Quantity - Weight: 4.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.2 m2; Net surface area: 0.3 m2; Height: 499.1 mm; Width: 3 mm; Length: 597.2 mm
Pset_PlateCommon - LoadBearing: no; Reference: PL/67
BaseQuantities - Width: 499.069 mm; NetArea: 0.400777 m2; GrossArea: 0.298047 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000592931 m3; GrossVolume: 0.000592931 m3

# IfcPlate: PLT3*565.6 (2)
In: Undefined
Description: PLT3*565.6; Material: STEEL/450
Tekla Common - Bottom elevation: +4.577; Top elevation: +5.153; Phase: 1; Class: 11
Tekla Quantity - Weight: 8.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.8 m2; Height: 565.6 mm; Width: 3 mm; Length: 853.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - NetArea: 0.754232 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00111964 m3; GrossVolume: 0.00111964 m3
Name | ASSEMBLY_POS = Reference | Width (mm) | GrossArea (m2)
PLATE | PL/80 | 565.637 | 0.482806
PLATE | PL/79 | 565.634 | 0.482802

# IfcPlate: PLT3*571.6, PLATE
In: Undefined
Description: PLT3*571.6; Material: STEEL/450
Default - ASSEMBLY_POS: PL/85
Tekla Common - Bottom elevation: +5.479; Top elevation: +5.882; Phase: 1; Class: 11
Tekla Quantity - Weight: 9.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.8 m2; Height: 571.6 mm; Width: 3 mm; Length: 955.4 mm
Pset_PlateCommon - LoadBearing: no; Reference: PL/85
BaseQuantities - Width: 571.641 mm; NetArea: 0.801356 m2; GrossArea: 0.54616 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00118969 m3; GrossVolume: 0.00118969 m3

# IfcPlate: PLT3*576, PLATE
In: Undefined
Description: PLT3*576; Material: STEEL/450
Tekla Common - Bottom elevation: +4.577; Top elevation: +5.192; Phase: 1; Class: 11
Default - ASSEMBLY_POS: PL/75
Tekla Quantity - Weight: 9.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.8 m2; Height: 576 mm; Width: 3 mm; Length: 879 mm
Pset_PlateCommon - LoadBearing: no; Reference: PL/75
BaseQuantities - Width: 576.032 mm; NetArea: 0.778939 m2; GrossArea: 0.506333 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00115652 m3; GrossVolume: 0.00115652 m3

# IfcPlate: PLT3*576.1, PLATE
In: Undefined
Description: PLT3*576.1; Material: STEEL/450
Default - ASSEMBLY_POS: PL/76
Tekla Common - Bottom elevation: +4.577; Top elevation: +5.192; Phase: 1; Class: 11
Tekla Quantity - Weight: 9.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.8 m2; Height: 576.1 mm; Width: 3 mm; Length: 879 mm
Pset_PlateCommon - LoadBearing: no; Reference: PL/76
BaseQuantities - Width: 576.057 mm; NetArea: 0.77894 m2; GrossArea: 0.506359 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00115653 m3; GrossVolume: 0.00115653 m3

# IfcPlate: PLT3*585.2 (2)
In: Undefined
Description: PLT3*585.2; Material: STEEL/450
Tekla Common - Bottom elevation: +4.577; Top elevation: +5.231; Phase: 1; Class: 11
Tekla Quantity - Weight: 9.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.8 m2; Height: 585.2 mm; Length: 904.9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Tekla Quantity, Width (mm) | BaseQuantities, Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
PLATE | PL/74 | 3.1 | 585.228 | 0.803911 | 0.529577 | 0.00119381
PLATE | PL/73 | 3 | 585.177 | 0.803909 | 0.529521 | 0.00119378

# IfcPlate: PLT3*601.4, PLATE
In: Undefined
Description: PLT3*601.4; Material: STEEL/450
Tekla Common - Bottom elevation: +4.578; Top elevation: +5.322; Phase: 1; Class: 11
Default - ASSEMBLY_POS: PL/71
Tekla Quantity - Weight: 10.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.8 m2; Height: 601.4 mm; Width: 3.1 mm; Length: 967.3 mm
Pset_PlateCommon - LoadBearing: no; Reference: PL/71
BaseQuantities - Width: 601.441 mm; NetArea: 0.863374 m2; GrossArea: 0.581793 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.0012825 m3; GrossVolume: 0.0012825 m3

# IfcPlate: PLT3*601.6, PLATE
In: Undefined
Description: PLT3*601.6; Material: STEEL/450
Default - ASSEMBLY_POS: PL/72
Tekla Common - Bottom elevation: +4.578; Top elevation: +5.322; Phase: 1; Class: 11
Tekla Quantity - Weight: 10.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 1 m2; Height: 601.6 mm; Width: 3.1 mm; Length: 967.4 mm
Pset_PlateCommon - LoadBearing: no; Reference: PL/72
BaseQuantities - Width: 601.577 mm; NetArea: 0.863379 m2; GrossArea: 0.58195 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00128254 m3; GrossVolume: 0.00128254 m3

# IfcPlate: PLT3*606.1 (2)
In: Undefined
Description: PLT3*606.1; Material: STEEL/450
Tekla Common - Bottom elevation: +4.577; Top elevation: +5.164; Phase: 1; Class: 11
Tekla Quantity - Weight: 10.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.8 m2; Height: 606.1 mm; Width: 3 mm; Length: 905.1 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - NetArea: 0.865061 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00128499 m3; GrossVolume: 0.00128499 m3
Name | ASSEMBLY_POS = Reference | Width (mm) | GrossArea (m2)
PLATE | PL/103 | 606.065 | 0.548538
PLATE | PL/102 | 606.062 | 0.548534

# IfcPlate: PLT3*609.9, PLATE
In: Undefined
Description: PLT3*609.9; Material: STEEL/450
Default - ASSEMBLY_POS: PL/86
Tekla Common - Bottom elevation: +5.683; Top elevation: +6.112; Phase: 1; Class: 11
Tekla Quantity - Weight: 9.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.8 m2; Height: 609.9 mm; Width: 3 mm; Length: 968.2 mm
Pset_PlateCommon - LoadBearing: no; Reference: PL/86
BaseQuantities - Width: 609.9 mm; NetArea: 0.826034 m2; GrossArea: 0.590519 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00122661 m3; GrossVolume: 0.00122661 m3

# IfcPlate: PLT3*618.8 (2)
In: Undefined
Description: PLT3*618.8; Material: STEEL/450
Tekla Common - Bottom elevation: +4.577; Top elevation: +5.205; Phase: 1; Class: 11
Tekla Quantity - Weight: 10.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.7 m2; Net surface area: 0.8 m2; Height: 618.8 mm; Width: 3 mm; Length: 932.1 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
PLATE | PL/101 | 618.804 | 0.896834 | 0.576804 | 0.00133245
PLATE | PL/100 | 618.779 | 0.896833 | 0.576777 | 0.00133246

# IfcPlate: PLT3*630.2, PLATE
In: Undefined
Description: PLT3*630.2; Material: STEEL/450
Tekla Common - Bottom elevation: +4.577; Top elevation: +5.247; Phase: 1; Class: 11
Default - ASSEMBLY_POS: PL/98
Tekla Quantity - Weight: 10.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.7 m2; Net surface area: 0.8 m2; Height: 630.2 mm; Width: 3.1 mm; Length: 959.6 mm
Pset_PlateCommon - LoadBearing: no; Reference: PL/98
BaseQuantities - Width: 630.227 mm; NetArea: 0.929235 m2; GrossArea: 0.604746 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00138086 m3; GrossVolume: 0.00138086 m3

# IfcPlate: PLT3*630.3, PLATE
In: Undefined
Description: PLT3*630.3; Material: STEEL/450
Default - ASSEMBLY_POS: PL/99
Tekla Common - Bottom elevation: +4.577; Top elevation: +5.247; Phase: 1; Class: 11
Tekla Quantity - Weight: 10.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.7 m2; Net surface area: 1 m2; Height: 630.3 mm; Width: 3 mm; Length: 959.6 mm
Pset_PlateCommon - LoadBearing: no; Reference: PL/99
BaseQuantities - Width: 630.281 mm; NetArea: 0.929236 m2; GrossArea: 0.604807 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00138084 m3; GrossVolume: 0.00138084 m3

# IfcPlate: PLT3*645.5, PLATE
In: Undefined
Description: PLT3*645.5; Material: STEEL/450
Default - ASSEMBLY_POS: PL/87
Tekla Common - Bottom elevation: +5.893; Top elevation: +6.348; Phase: 1; Class: 11
Tekla Quantity - Weight: 9.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.8 m2; Height: 645.5 mm; Width: 3 mm; Length: 975.3 mm
Pset_PlateCommon - LoadBearing: no; Reference: PL/87
BaseQuantities - Width: 645.542 mm; NetArea: 0.849539 m2; GrossArea: 0.629592 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00126179 m3; GrossVolume: 0.00126179 m3

# IfcPlate: PLT3*650, PLATE
In: Undefined
Description: PLT3*650; Material: STEEL/450
Default - ASSEMBLY_POS: PL/106
Tekla Common - Bottom elevation: +5.433; Top elevation: +5.887; Phase: 1; Class: 11
Tekla Quantity - Weight: 11.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.7 m2; Net surface area: 0.8 m2; Height: 650 mm; Width: 3 mm; Length: 981.8 mm
Pset_PlateCommon - LoadBearing: no; Reference: PL/106
BaseQuantities - Width: 650 mm; NetArea: 0.948818 m2; GrossArea: 0.638154 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00141008 m3; GrossVolume: 0.00141008 m3

# IfcPlate: PLT3*651.8, PLATE
In: Undefined
Description: PLT3*651.8; Material: STEEL/450
Tekla Common - Bottom elevation: +4.577; Top elevation: +5.345; Phase: 1; Class: 11
Default - ASSEMBLY_POS: PL/96
Tekla Quantity - Weight: 11.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.7 m2; Net surface area: 1 m2; Height: 651.8 mm; Width: 3.1 mm; Length: 1025.8 mm
Pset_PlateCommon - LoadBearing: no; Reference: PL/96
BaseQuantities - Width: 651.804 mm; NetArea: 1.00762 m2; GrossArea: 0.668586 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00149792 m3; GrossVolume: 0.00149792 m3

# IfcPlate: PLT3*652, PLATE
In: Undefined
Description: PLT3*652; Material: STEEL/450
Default - ASSEMBLY_POS: PL/97
Tekla Common - Bottom elevation: +4.577; Top elevation: +5.345; Phase: 1; Class: 11
Tekla Quantity - Weight: 11.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.7 m2; Net surface area: 1 m2; Height: 652 mm; Width: 3.1 mm; Length: 1025.8 mm
Pset_PlateCommon - LoadBearing: no; Reference: PL/97
BaseQuantities - Width: 651.954 mm; NetArea: 1.00763 m2; GrossArea: 0.668766 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.0014979 m3; GrossVolume: 0.0014979 m3

# IfcPlate: PLT3*687.9, PLATE
In: Undefined
Description: PLT3*687.9; Material: STEEL/450
Default - ASSEMBLY_POS: PL/107
Tekla Common - Bottom elevation: +5.638; Top elevation: +6.119; Phase: 1; Class: 11
Tekla Quantity - Weight: 11.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.7 m2; Net surface area: 1 m2; Height: 687.9 mm; Width: 3 mm; Length: 1000.7 mm
Pset_PlateCommon - LoadBearing: no; Reference: PL/107
BaseQuantities - Width: 687.908 mm; NetArea: 0.97651 m2; GrossArea: 0.688403 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.0014515 m3; GrossVolume: 0.0014515 m3

# IfcPlate: PLT3*716.4, PLATE
In: Undefined
Description: PLT3*716.4; Material: STEEL/450
Default - ASSEMBLY_POS: PL/88
Tekla Common - Bottom elevation: +6.416; Top elevation: +6.935; Phase: 1; Class: 11
Tekla Quantity - Weight: 10.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.7 m2; Net surface area: 0.8 m2; Height: 716.4 mm; Width: 3 mm; Length: 969.5 mm
Pset_PlateCommon - LoadBearing: no; Reference: PL/88
BaseQuantities - Width: 716.41 mm; NetArea: 0.899521 m2; GrossArea: 0.694526 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00133658 m3; GrossVolume: 0.00133658 m3

# IfcPlate: PLT3*723.1, PLATE
In: Undefined
Description: PLT3*723.1; Material: STEEL/450
Default - ASSEMBLY_POS: PL/108
Tekla Common - Bottom elevation: +5.849; Top elevation: +6.357; Phase: 1; Class: 11
Tekla Quantity - Weight: 11.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.7 m2; Net surface area: 1 m2; Height: 723.1 mm; Width: 3 mm; Length: 1013.6 mm
Pset_PlateCommon - LoadBearing: no; Reference: PL/108
BaseQuantities - Width: 723.131 mm; NetArea: 1.00302 m2; GrossArea: 0.732998 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00149115 m3; GrossVolume: 0.00149115 m3

# IfcPlate: PLT3*792.7, PLATE
In: Undefined
Description: PLT3*792.7; Material: STEEL/450
Default - ASSEMBLY_POS: PL/109
Tekla Common - Bottom elevation: +6.373; Top elevation: +6.947; Phase: 1; Class: 11
Tekla Quantity - Weight: 12.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.7 m2; Net surface area: 1.1 m2; Height: 792.7 mm; Width: 3 mm; Length: 1020 mm
Pset_PlateCommon - LoadBearing: no; Reference: PL/109
BaseQuantities - Width: 792.682 mm; NetArea: 1.06002 m2; GrossArea: 0.808545 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.0015764 m3; GrossVolume: 0.0015764 m3
