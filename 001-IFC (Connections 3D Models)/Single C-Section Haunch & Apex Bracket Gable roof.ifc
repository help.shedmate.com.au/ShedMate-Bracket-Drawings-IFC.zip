Properties of the parts of a building model (IFC2X3), part 1 of 2

# File
Description: ViewDefinition[CoordinationView_V2.0, QuantityTakeOffAddOnView], Option [BaseQuantities:On], Option [GridExport:On], Option [Assemblies:On], Option [Bolts:On], Option [Rebars:On], Option [PourObjects:Off], Option [Welds:Off], Option [SurfaceTreatments:Off], Option [LocationBy:0], Option [ViewColors:Off], Option [SectionedSpine:Off], Option [PropertySets:On], Option [Export all:Off]
File name: Single C-Section Haunch & Apex Bracket Gable roof.ifc
Time: 2026-08-05T01:08:29
Author: LAPTOP-2P0BGI6B\lablab
Organization: Structural Designer
Written by: IFC Database Version: Work
Made in: Tekla Structures 2019 Service Pack 13, IFC Export Version: 4.0.0.0 Oct 18 2021

# IfcBuildingStorey, Undefined
In: Undefined
Elevation: 0 mm

# IfcBeam: C:150-15 (39)
In: Undefined
Description: C:150-15; Material: STEEL/300PLUS
Default - ASSEMBLY_POS: F/10
Tekla Common - Phase: 1; Class: 13
Tekla Quantity - Weight: 3.5 kg; Volume: 0 m3; Gross footprint area: 0.1 m2; Area per tons: 176.5 m2; Net surface area: 0.6 m2; Height: 152 mm; Width: 64 mm; Length: 1000 mm
Pset_BeamCommon - LoadBearing: no; Reference: F/10
BaseQuantities - Length: 1000 mm; OuterSurfaceArea: 0.613915 m2; NetVolume: 0.0004575 m3
Name | Bottom elevation | Top elevation | NetWeight (kg)
3 x FASCIA | +4.896 | +5.048 | 3.59138
6 x FASCIA | +4.895 | +5.047 | 3.59138
10 x FASCIA | +4.902 | +5.054 | 3.59138
4 x FASCIA | +4.906 | +5.058 | 3.59138
5 x FASCIA | +4.905 | +5.057 | 3.59138
FASCIA | +4.905 | +5.057 | 3.59137
6 x FASCIA | +4.909 | +5.061 | 3.59138
4 x FASCIA | +4.908 | +5.060 | 3.59138

# IfcBeam: C:150-19 (20)
In: Undefined
Description: C:150-19; Material: STEEL/G450
Tekla Common - Phase: 1; Class: 5
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0.2 m2; Area per tons: 139.6 m2; Height: 152 mm; Width: 64 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
BA-25-350 | S/83 | +5.856 | +6.008 | 16.3 | 2.3 | 3700 | 2.27518 | 0.00214696 | 16.8537
BA-25-300 | S/68 | +5.917 | +6.069 | 15.4 | 2.2 | 3500 | 2.15226 | 0.00203091 | 15.9426
BA-25-250 | S/53 | +5.924 | +6.076 | 15.4 | 2.2 | 3500 | 2.15226 | 0.00203091 | 15.9426
BA-25-200 | S/41 | +5.984 | +6.136 | 14.5 | 2 | 3300 | 2.02934 | 0.00191486 | 15.0316
BA-25-150 | S/29 | +6.051 | +6.203 | 13.7 | 2 | 3100 | 1.90642 | 0.00179881 | 14.1206
BA-18-350 | S/80 | +5.531 | +5.683 | 16.3 | 2.3 | 3700 | 2.27518 | 0.00214696 | 16.8537
BA-18-300 | S/65 | +5.577 | +5.729 | 15.4 | 2.2 | 3500 | 2.15226 | 0.00203091 | 15.9426
BA-18-250 | S/50 | +5.586 | +5.738 | 15.4 | 2.2 | 3500 | 2.15226 | 0.00203091 | 15.9426
BA-18-200 | S/38 | +5.642 | +5.794 | 14.5 | 2 | 3300 | 2.02934 | 0.00191486 | 15.0316
BA-18-150 | S/26 | +5.687 | +5.839 | 13.7 | 2 | 3100 | 1.90642 | 0.00179881 | 14.1206
BA-15-350 | S/77 | +5.391 | +5.543 | 16.3 | 2.3 | 3700 | 2.27518 | 0.00214696 | 16.8537
BA-15-300 | S/62 | +5.427 | +5.579 | 15.4 | 2.2 | 3500 | 2.15226 | 0.00203091 | 15.9426
BA-15-250 | S/17 | +5.451 | +5.603 | 15.4 | 2.2 | 3500 | 2.15226 | 0.00203091 | 15.9426
BA-15-200 | S/11 | +5.495 | +5.647 | 14.5 | 2 | 3300 | 2.02934 | 0.00191486 | 15.0316
BA-15-150 | S/5 | +5.539 | +5.691 | 13.7 | 2 | 3100 | 1.90642 | 0.00179881 | 14.1206
BA-12-350 | S/23 | +5.231 | +5.383 | 16.3 | 2.3 | 3700 | 2.27518 | 0.00214696 | 16.8537
BA-12-300 | S/20 | +5.277 | +5.429 | 15.4 | 2.2 | 3500 | 2.15226 | 0.00203091 | 15.9426
BA-12-250 | S/14 | +5.318 | +5.470 | 15.4 | 2.2 | 3500 | 2.15226 | 0.00203091 | 15.9426
BA-12-200 | S/8 | +5.365 | +5.517 | 14.5 | 2 | 3300 | 2.02934 | 0.00191486 | 15.0316
BA-12-150 | S/2 | +5.400 | +5.552 | 13.7 | 2 | 3100 | 1.90642 | 0.00179881 | 14.1206

# IfcBeam: C:150-24 (10)
In: Undefined
Description: C:150-24; Material: STEEL/G450
Tekla Common - Phase: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 111.2 m2; Height: 152 mm; Width: 64 mm
Pset_BeamCommon - LoadBearing: no
Name | Finish | Bottom elevation | Top elevation | Class | ASSEMBLY_POS = Reference | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
COLUMN | 25 deg | +0.000 | +5.050 | 10 | Z/92 | 28.1 | 3.1 | 5050.1 | 5050.09 | 3.13051 | 0.00372575 | 29.2472
COLUMN | 18 deg | +0.000 | +5.057 | 10 | Z/89 | 28.2 | 3.1 | 5056.8 | 5056.79 | 3.13466 | 0.0037307 | 29.286
COLUMN | 15 deg | +0.000 | +5.060 | 10 | Z/86 | 28.2 | 3.1 | 5059.9 | 5059.86 | 3.13656 | 0.00373296 | 29.3038
COLUMN | 12 deg | +0.000 | +5.063 | 10 | Z/84 | 28.2 | 3.1 | 5063.1 | 5063.14 | 3.1386 | 0.00373538 | 29.3228
RAFTER | 18 deg | +4.908 | +6.307 | 1 | Z/91 | 22.6 | 2.5 | 4060.8 | 4060.78 | 2.51754 | 0.00299588 | 23.5177
RAFTER | 18 deg | +4.908 | +6.307 | 1 | Z/90 | 22.6 | 2.5 | 4060.8 | 4060.78 | 2.51754 | 0.00299588 | 23.5177
RAFTER | 15 deg | +4.896 | +6.080 | 1 | Z/88 | 22.3 | 2.5 | 4006.2 | 4006.17 | 2.4837 | 0.00295559 | 23.2014
RAFTER | 15 deg | +4.896 | +6.080 | 1 | Z/87 | 22.3 | 2.5 | 4006.2 | 4006.17 | 2.4837 | 0.00295559 | 23.2014
RAFTER | 12 deg | +4.886 | +5.858 | 1 | Z/85 | 22.1 | 2.5 | 3964 | 3964.01 | 2.45758 | 0.00292449 | 22.9572
RAFTER | 12 deg | +4.886 | +5.858 | 1 | Z/353 | 22.1 | 2.5 | 3964 | 3964.01 | 2.45758 | 0.00292449 | 22.9572

# IfcBeam: C:200-24 (10)
In: Undefined
Description: C:200-24; Material: STEEL/G450
Tekla Common - Phase: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 110 m2; Height: 203 mm; Width: 76 mm
Pset_BeamCommon - LoadBearing: no
Name | Finish | Bottom elevation | Top elevation | Class | ASSEMBLY_POS = Reference | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
COLUMN | 25 deg | +0.000 | +5.050 | 10 | Z/111 | 35.8 | 3.9 | 5050.1 | 5050.09 | 3.93891 | 0.00469537 | 36.8587
COLUMN | 18 deg | +0.000 | +5.057 | 10 | Z/109 | 35.8 | 3.9 | 5056.8 | 5056.8 | 3.94414 | 0.00470161 | 36.9076
COLUMN | 15 deg | +0.000 | +5.060 | 10 | Z/106 | 35.8 | 3.9 | 5059.9 | 5059.86 | 3.94653 | 0.00470446 | 36.93
COLUMN | 12 deg | +0.000 | +5.063 | 10 | Z/105 | 35.8 | 3.9 | 5063.3 | 5063.16 | 3.9491 | 0.00470752 | 36.9541
RAFTER | 18 deg | +4.876 | +6.310 | 1 | Z/110 | 28.5 | 3.1 | 4017.4 | 4017.4 | 3.13382 | 0.00373522 | 29.3215
RAFTER | 18 deg | +4.876 | +6.310 | 1 | Z/4 | 28.5 | 3.1 | 4017.4 | 4017.4 | 3.13382 | 0.00373522 | 29.3215
RAFTER | 15 deg | +4.861 | +6.083 | 1 | Z/108 | 28.1 | 3.1 | 3966.1 | 3966.1 | 3.09383 | 0.00368752 | 28.947
RAFTER | 15 deg | +4.861 | +6.083 | 1 | Z/107 | 28.1 | 3.1 | 3966.1 | 3966.1 | 3.09383 | 0.00368752 | 28.947
RAFTER | 12 deg | +4.846 | +5.861 | 1 | Z/208 | 27.8 | 3.1 | 3927.1 | 3927.11 | 3.06344 | 0.00365127 | 28.6625
RAFTER | 12 deg | +4.846 | +5.861 | 1 | Z/354 | 27.8 | 3.1 | 3927.1 | 3927.11 | 3.06343 | 0.00365127 | 28.6625

# IfcBeam: C:250-24 (10)
In: Undefined
Description: C:250-24; Material: STEEL/G450
Tekla Common - Phase: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 109.7 m2; Height: 254 mm; Width: 76 mm
Pset_BeamCommon - LoadBearing: no
Name | Finish | Bottom elevation | Top elevation | Class | ASSEMBLY_POS = Reference | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
COLUMN | 25 deg | +0.000 | +5.050 | 10 | Z/1472 | 40.5 | 4.4 | 5050.1 | 5050.08 | 4.44415 | 0.00530137 | 41.6158
COLUMN | 18 deg | +0.000 | +5.057 | 10 | Z/1470 | 40.6 | 4.4 | 5056.8 | 5056.79 | 4.45005 | 0.00530842 | 41.6711
COLUMN | 15 deg | +0.000 | +5.060 | 10 | Z/1468 | 40.6 | 4.4 | 5059.9 | 5059.86 | 4.45275 | 0.00531164 | 41.6964
COLUMN | 12 deg | +0.000 | +5.063 | 10 | Z/123 | 40.6 | 4.4 | 5063.3 | 5063.25 | 4.45573 | 0.0053152 | 41.7243
RAFTER | 18 deg | +4.844 | +6.313 | 1 | Z/129 | 31.9 | 3.5 | 3974 | 3974.01 | 3.49764 | 0.00417175 | 32.7483
RAFTER | 18 deg | +4.844 | +6.313 | 1 | Z/1471 | 31.9 | 3.5 | 3974 | 3974.01 | 3.49764 | 0.00417175 | 32.7483
RAFTER | 15 deg | +4.825 | +6.086 | 1 | Z/126 | 31.5 | 3.5 | 3926 | 3926.04 | 3.45544 | 0.0041214 | 32.353
RAFTER | 15 deg | +4.825 | +6.086 | 1 | Z/1469 | 31.5 | 3.5 | 3926 | 3926.04 | 3.45544 | 0.0041214 | 32.353
RAFTER | 12 deg | +4.807 | +5.865 | 1 | Z/209 | 31.2 | 3.5 | 3890.2 | 3890.2 | 3.42392 | 0.00408378 | 32.0576
RAFTER | 12 deg | +4.807 | +5.865 | 1 | Z/355 | 31.2 | 3.5 | 3890.2 | 3890.2 | 3.42392 | 0.00408377 | 32.0576

# IfcBeam: C:300-30 (10)
In: Undefined
Description: C:300-30; Material: STEEL/G450
Tekla Common - Phase: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.4 m2; Height: 300 mm; Width: 96 mm
Pset_BeamCommon - LoadBearing: no
Name | Finish | Bottom elevation | Top elevation | Class | ASSEMBLY_POS = Reference | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
COLUMN | 25 deg | +0.000 | +5.050 | 10 | Z/1488 | 63.2 | 5.5 | 5050.1 | 5050.09 | 5.51796 | 0.0082266 | 64.5788
COLUMN | 18 deg | +0.000 | +5.057 | 10 | Z/1486 | 63.2 | 5.5 | 5056.8 | 5056.79 | 5.52527 | 0.00823751 | 64.6645
COLUMN | 15 deg | +0.000 | +5.060 | 10 | Z/1484 | 63.3 | 5.5 | 5059.9 | 5059.86 | 5.52863 | 0.00824251 | 64.7037
COLUMN | 12 deg | +0.000 | +5.063 | 10 | Z/142 | 63.3 | 5.5 | 5062.8 | 5062.81 | 5.53185 | 0.00824732 | 64.7414
RAFTER | 18 deg | +4.815 | +6.317 | 1 | Z/148 | 49.2 | 4.3 | 3934.9 | 3934.88 | 4.30015 | 0.00640992 | 50.3179
RAFTER | 18 deg | +4.815 | +6.317 | 1 | Z/1487 | 49.2 | 4.3 | 3934.9 | 3934.88 | 4.30015 | 0.00640992 | 50.3179
RAFTER | 15 deg | +4.793 | +6.090 | 1 | Z/145 | 48.6 | 4.3 | 3889.9 | 3889.9 | 4.25103 | 0.00633665 | 49.7427
RAFTER | 15 deg | +4.793 | +6.090 | 1 | Z/1485 | 48.6 | 4.3 | 3889.9 | 3889.9 | 4.25103 | 0.00633665 | 49.7427
RAFTER | 12 deg | +4.772 | +5.868 | 1 | Z/210 | 48.2 | 4.3 | 3856.9 | 3856.9 | 4.215 | 0.00628289 | 49.3207
RAFTER | 12 deg | +4.772 | +5.868 | 1 | Z/360 | 48.2 | 4.3 | 3856.9 | 3856.9 | 4.21499 | 0.00628289 | 49.3207

# IfcBeam: C:350-30 (10)
In: Undefined
Description: C:350-30; Material: STEEL/G450
Tekla Common - Phase: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.1 m2; Height: 350 mm; Width: 125 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Finish | Bottom elevation | Top elevation | Class | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
COLUMN | Z/1503 | 25 deg | +0.000 | +5.050 | 10 | 75.5 | 6.6 | 5050.1 | 5050.09 | 6.5791 | 0.00981737 | 77.0663
COLUMN | Z/1501 | 18 deg | +0.000 | +5.057 | 10 | 75.6 | 6.6 | 5056.8 | 5056.8 | 6.58784 | 0.00983041 | 77.1687
COLUMN | Z/1499 | 15 deg | +0.000 | +5.060 | 10 | 75.6 | 6.6 | 5059.9 | 5059.86 | 6.59182 | 0.00983636 | 77.2154
COLUMN | Z/161 | 12 deg | +0.000 | +5.063 | 10 | 75.6 | 6.6 | 5063 | 5063.04 | 6.59596 | 0.00984254 | 77.264
RAFTER | Z/168 | 18 deg | +4.784 | +6.320 | 1 | 58.2 | 5.1 | 3892.4 | 3892.35 | 5.07173 | 0.00756673 | 59.3988
RAFTER | Z/1502 | 18 deg | +4.784 | +6.320 | 1 | 58.2 | 5.1 | 3892.4 | 3892.35 | 5.07173 | 0.00756673 | 59.3988
RAFTER | Z/165 | 15 deg | +4.758 | +6.093 | 1 | 57.6 | 5 | 3850.6 | 3850.62 | 5.0174 | 0.00748561 | 58.762
RAFTER | Z/1500 | 15 deg | +4.758 | +6.093 | 1 | 57.6 | 5 | 3850.6 | 3850.62 | 5.0174 | 0.00748561 | 58.762
RAFTER | Z/1498 | 12 deg | +4.734 | +5.871 | 1 | 57.1 | 5 | 3820.7 | 3820.71 | 4.97845 | 0.00742746 | 58.3056
RAFTER | Z/364 | 12 deg | +4.734 | +5.871 | 1 | 57.1 | 5 | 3820.7 | 3820.71 | 4.97845 | 0.00742746 | 58.3056

# IfcBeam: PLT1.6*60 (40)
In: Undefined
Description: PLT1.6*60; Material: STEEL/250
Default - ASSEMBLY_POS: Z/52
Tekla Common - Phase: 1; Class: 12
Tekla Quantity - Weight: 0.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 164.6 m2; Net surface area: 0 m2; Height: 60 mm; Width: 1.6 mm; Length: 297.9 mm
Pset_BeamCommon - LoadBearing: no; Reference: Z/52
BaseQuantities - Length: 297.881 mm; OuterSurfaceArea: 0.0371807 m2; NetVolume: 0.0000287808 m3; NetWeight: 0.225929 kg
Name | Bottom elevation | Top elevation
10 x FASCIA BRACKET | +4.893 | +5.050
10 x FASCIA BRACKET | +4.900 | +5.057
10 x FASCIA BRACKET | +4.903 | +5.060
10 x FASCIA BRACKET | +4.906 | +5.063

# IfcBeam: TH:75-95 (77)
In: Undefined
Description: TH:75-95; Material: STEEL/300PLUS
Default - ASSEMBLY_POS: B/5
Tekla Common - Phase: 1; Class: 4
Tekla Quantity - Weight: 1.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 0 m2; Net surface area: 0.5 m2; Height: 75 mm; Width: 125 mm; Length: 1000 mm
Pset_BeamCommon - LoadBearing: no; Reference: B/5
BaseQuantities - Length: 1000 mm; OuterSurfaceArea: 4.5602e-07 m2; NetVolume: 0.000231901 m3; NetWeight: 1.82042 kg
Name | Bottom elevation | Top elevation
2 x TH | +4.550 | +4.675
7 x TH | +4.549 | +4.674
2 x TH | +5.722 | +5.824
2 x TH | +5.713 | +5.815
2 x TH | +5.704 | +5.806
2 x TH | +5.694 | +5.796
10 x TH | +4.556 | +4.681
2 x TH | +5.541 | +5.637
2 x TH | +5.537 | +5.633
2 x TH | +5.526 | +5.622
2 x TH | +5.519 | +5.615
2 x TH | +5.511 | +5.607
10 x TH | +4.559 | +4.684
2 x TH | +5.453 | +5.547
2 x TH | +5.447 | +5.540
2 x TH | +5.441 | +5.534
2 x TH | +5.435 | +5.528
2 x TH | +5.428 | +5.522
10 x TH | +4.562 | +4.687
2 x TH | +5.365 | +5.455
2 x TH | +5.360 | +5.450
2 x TH | +5.355 | +5.445
2 x TH | +5.349 | +5.440
2 x TH | +5.344 | +5.435

# IfcColumn: C:150-24 (4)
In: Undefined
Description: C:150-24; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Phase: 1; Class: 10
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 111.2 m2; Net surface area: 3.1 m2; Height: 152 mm; Width: 64 mm
Pset_ColumnCommon - LoadBearing: no
Name | Finish | Top elevation | ASSEMBLY_POS = Reference | Weight (kg) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
COLUMN | 25 deg | +5.050 | Z/92 | 28.1 | 5050.1 | 5050.09 | 3.13051 | 0.00372575 | 29.2472
COLUMN | 18 deg | +5.057 | Z/89 | 28.2 | 5056.8 | 5056.79 | 3.13466 | 0.0037307 | 29.286
COLUMN | 15 deg | +5.060 | Z/86 | 28.2 | 5059.9 | 5059.86 | 3.13656 | 0.00373296 | 29.3038
COLUMN | 12 deg | +5.063 | Z/84 | 28.2 | 5063.1 | 5063.14 | 3.1386 | 0.00373538 | 29.3228

# IfcColumn: C:200-24 (4)
In: Undefined
Description: C:200-24; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Phase: 1; Class: 10
Tekla Quantity - Weight: 35.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 110 m2; Net surface area: 3.9 m2; Height: 203 mm; Width: 76 mm
Pset_ColumnCommon - LoadBearing: no
Name | Finish | Top elevation | ASSEMBLY_POS = Reference | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
COLUMN | 25 deg | +5.050 | Z/111 | 5050.1 | 5050.09 | 3.93891 | 0.00469537 | 36.8587
COLUMN | 18 deg | +5.057 | Z/109 | 5056.8 | 5056.8 | 3.94414 | 0.00470161 | 36.9076
COLUMN | 15 deg | +5.060 | Z/106 | 5059.9 | 5059.86 | 3.94653 | 0.00470446 | 36.93
COLUMN | 12 deg | +5.063 | Z/105 | 5063.3 | 5063.16 | 3.9491 | 0.00470752 | 36.9541

# IfcColumn: C:250-24 (4)
In: Undefined
Description: C:250-24; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Phase: 1; Class: 10
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 109.7 m2; Net surface area: 4.4 m2; Height: 254 mm; Width: 76 mm
Pset_ColumnCommon - LoadBearing: no
Name | Finish | Top elevation | ASSEMBLY_POS = Reference | Weight (kg) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
COLUMN | 25 deg | +5.050 | Z/1472 | 40.5 | 5050.1 | 5050.08 | 4.44415 | 0.00530137 | 41.6158
COLUMN | 18 deg | +5.057 | Z/1470 | 40.6 | 5056.8 | 5056.79 | 4.45005 | 0.00530842 | 41.6711
COLUMN | 15 deg | +5.060 | Z/1468 | 40.6 | 5059.9 | 5059.86 | 4.45275 | 0.00531164 | 41.6964
COLUMN | 12 deg | +5.063 | Z/123 | 40.6 | 5063.3 | 5063.25 | 4.45573 | 0.0053152 | 41.7243

# IfcColumn: C:300-30 (4)
In: Undefined
Description: C:300-30; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Phase: 1; Class: 10
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.4 m2; Net surface area: 5.5 m2; Height: 300 mm; Width: 96 mm
Pset_ColumnCommon - LoadBearing: no
Name | Finish | Top elevation | ASSEMBLY_POS = Reference | Weight (kg) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
COLUMN | 25 deg | +5.050 | Z/1488 | 63.2 | 5050.1 | 5050.09 | 5.51796 | 0.0082266 | 64.5788
COLUMN | 18 deg | +5.057 | Z/1486 | 63.2 | 5056.8 | 5056.79 | 5.52527 | 0.00823751 | 64.6645
COLUMN | 15 deg | +5.060 | Z/1484 | 63.3 | 5059.9 | 5059.86 | 5.52863 | 0.00824251 | 64.7037
COLUMN | 12 deg | +5.063 | Z/142 | 63.3 | 5062.8 | 5062.81 | 5.53185 | 0.00824732 | 64.7414

# IfcColumn: C:350-30 (4)
In: Undefined
Description: C:350-30; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Phase: 1; Class: 10
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.1 m2; Net surface area: 6.6 m2; Height: 350 mm; Width: 125 mm
Pset_ColumnCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Finish | Top elevation | Weight (kg) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
COLUMN | Z/1503 | 25 deg | +5.050 | 75.5 | 5050.1 | 5050.09 | 6.5791 | 0.00981737 | 77.0663
COLUMN | Z/1501 | 18 deg | +5.057 | 75.6 | 5056.8 | 5056.8 | 6.58784 | 0.00983041 | 77.1687
COLUMN | Z/1499 | 15 deg | +5.060 | 75.6 | 5059.9 | 5059.86 | 6.59182 | 0.00983636 | 77.2154
COLUMN | Z/161 | 12 deg | +5.063 | 75.6 | 5063 | 5063.04 | 6.59596 | 0.00984254 | 77.264

# IfcElementAssembly (376)
In: Undefined
PredefinedType: RIGID_FRAME
Name | ASSEMBLY_POSITION_CODE = Assembly/Cast unit position code | ASSEMBLY_POS = Assembly/Cast unit Mark | Assembly/Cast unit weight (kg) | Assembly/Cast unit bottom elevation | Assembly/Cast unit top elevation | Width (mm)
RAFTER | C350SD/2-3 | Z/1498 | 57.1 | +4.734 | +5.871 | 125
STIFFINER SLEEVE | C350SD/2-3 | PL/151 | 5.3 | +4.875 | +5.293 | 114
COLUMN | C350SD/3 | Z/161 | 75.7 | +0.000 | +5.063 | 125
STIFFINER SLEEVE | C350SD/3 | PL/151 | 5.3 | +3.808 | +4.208 | 114
RAFTER | C350SD/1-2 | Z/364 | 57.1 | +4.734 | +5.871 | 125
STIFFINER SLEEVE | C350SD/1-2 | PL/151 | 5.3 | +4.875 | +5.293 | 114
COLUMN | C350SD/1 | Z/161 | 75.7 | +0.000 | +5.063 | 125
STIFFINER SLEEVE | C350SD/1 | PL/151 | 5.3 | +3.808 | +4.208 | 114
RAFTER | C300SD/2-3 | Z/210 | 48.2 | +4.772 | +5.868 | 96
STIFFINER SLEEVE | C300SD/2-3 | PL/150 | 4.2 | +4.907 | +5.276 | 85
COLUMN | C300SD/3 | Z/142 | 63.3 | +0.000 | +5.063 | 96
STIFFINER SLEEVE | C300SD/3 | PL/150 | 4.2 | +3.888 | +4.288 | 85
RAFTER | C300SD/1-2 | Z/360 | 48.2 | +4.772 | +5.868 | 96
STIFFINER SLEEVE | C300SD/1-2 | PL/150 | 4.2 | +4.907 | +5.276 | 85
COLUMN | C300SD/1 | Z/142 | 63.3 | +0.000 | +5.063 | 96
STIFFINER SLEEVE | C300SD/1 | PL/150 | 4.2 | +3.888 | +4.288 | 85
RAFTER | C250SD/2-3 | Z/209 | 31.2 | +4.807 | +5.865 | 76
STIFFINER SLEEVE | C250SD/2-3 | PL/149 | 3.5 | +4.934 | +5.259 | 66.2
COLUMN | C250SD/3 | Z/123 | 40.6 | +0.000 | +5.063 | 76
STIFFINER SLEEVE | C250SD/3 | PL/149 | 3.5 | +3.983 | +4.383 | 66.2
RAFTER | C250SD/1-2 | Z/355 | 31.2 | +4.807 | +5.865 | 76
STIFFINER SLEEVE | C250SD/1-2 | PL/149 | 3.5 | +4.934 | +5.259 | 66.2
COLUMN | C250SD/1 | Z/123 | 40.6 | +0.000 | +5.063 | 76
STIFFINER SLEEVE | C250SD/1 | PL/149 | 3.5 | +3.983 | +4.383 | 66.2
RAFTER | C200SD/2-3 | Z/208 | 27.8 | +4.846 | +5.861 | 76
STIFFINER SLEEVE | C200SD/2-3 | PL/148 | 3 | +4.968 | +5.243 | 66.2
COLUMN | C200SD/3 | Z/105 | 35.9 | +0.000 | +5.063 | 76
STIFFINER SLEEVE | C200SD/3 | PL/148 | 3 | +4.023 | +4.423 | 66.2
RAFTER | C200SD/1-2 | Z/354 | 27.8 | +4.846 | +5.861 | 76
STIFFINER SLEEVE | C200SD/1-2 | PL/148 | 3 | +4.968 | +5.243 | 66.2
COLUMN | C200SD/1 | Z/105 | 35.9 | +0.000 | +5.063 | 76
STIFFINER SLEEVE | C200SD/1 | PL/148 | 3 | +4.023 | +4.423 | 66.2
RAFTER | C150SD/2-3 | Z/85 | 22.1 | +4.886 | +5.858 | 64
STIFFINER SLEEVE | C150SD/2-3 | PL/147 | 2.3 | +5.005 | +5.231 | 54.2
COLUMN | C150SD/3 | Z/84 | 28.2 | +0.000 | +5.063 | 64
STIFFINER SLEEVE | C150SD/3 | PL/147 | 2.3 | +4.073 | +4.473 | 54.2
RAFTER | C150SD/1-2 | Z/353 | 22.1 | +4.886 | +5.858 | 64
STIFFINER SLEEVE | C150SD/1-2 | PL/147 | 2.3 | +5.005 | +5.231 | 54.2
COLUMN | C150SD/1 | Z/84 | 28.2 | +0.000 | +5.063 | 64
STIFFINER SLEEVE | C150SD/1 | PL/147 | 2.3 | +4.073 | +4.473 | 54.2
RAFTER | C200SD/2-3 | Z/112 | 29.7 | +4.915 | +6.870 | 76
COLUMN | C200SD/3 | Z/111 | 35.9 | +0.000 | +5.050 | 76
PLATE | C200SD/3 | PL/42 | 3.7 | +4.775 | +5.192 | 79
FASCIA BRACKET | C350SD/3 | Z/52 | 0.2 | +4.893 | +5.050 | 157.2
FASCIA BRACKET | C300SD/3 | Z/52 | 0.2 | +4.893 | +5.050 | 157.2
FASCIA BRACKET | C250SD/3 | Z/52 | 0.2 | +4.893 | +5.050 | 157.2
FASCIA BRACKET | C200SD/3 | Z/52 | 0.2 | +4.893 | +5.050 | 157.2
FASCIA BRACKET | C150SD/3 | Z/52 | 0.2 | +4.893 | +5.050 | 157.2
FASCIA | C300SD-C350SD/3 | F/10 | 3.5 | +4.896 | +5.048 | 64
TH | C300SD-C350SD/3 | B/5 | 1.8 | +4.550 | +4.675 | 125
FASCIA | C250SD-C300SD/3 | F/10 | 3.5 | +4.895 | +5.047 | 64
TH | C250SD-C300SD/3 | B/5 | 1.8 | +4.549 | +4.674 | 125
FASCIA | C200SD-C250SD/3 | F/10 | 3.5 | +4.895 | +5.047 | 64
TH | C200SD-C250SD/3 | B/5 | 1.8 | +4.549 | +4.674 | 125
TH | C300SD-C350SD/2-3 | B/5 | 1.8 | +5.722 | +5.824 | 125
TH | C250SD-C300SD/2-3 | B/5 | 1.8 | +5.713 | +5.815 | 125
TH | C200SD-C250SD/2-3 | B/5 | 1.8 | +5.704 | +5.806 | 125
FASCIA | C150SD-C200SD/3 | F/10 | 3.5 | +4.895 | +5.047 | 64
TH | C150SD-C200SD/3 | B/5 | 1.8 | +4.549 | +4.674 | 125
TH | C150SD-C200SD/2-3 | B/5 | 1.8 | +5.694 | +5.796 | 125
FASCIA BRACKET | C350SD/3 | Z/52 | 0.2 | +4.900 | +5.057 | 157.2
FASCIA BRACKET | C300SD/3 | Z/52 | 0.2 | +4.900 | +5.057 | 157.2
FASCIA BRACKET | C250SD/3 | Z/52 | 0.2 | +4.900 | +5.057 | 157.2
FASCIA BRACKET | C200SD/3 | Z/52 | 0.2 | +4.900 | +5.057 | 157.2
FASCIA BRACKET | C150SD/3 | Z/52 | 0.2 | +4.900 | +5.057 | 157.2
FASCIA | C350SD>/3 | F/10 | 3.5 | +4.902 | +5.054 | 64
TH | C350SD>/3 | B/5 | 1.8 | +4.556 | +4.681 | 125
FASCIA | C300SD-C350SD/3 | F/10 | 3.5 | +4.902 | +5.054 | 64
TH | C300SD-C350SD/3 | B/5 | 1.8 | +4.556 | +4.681 | 125
FASCIA | C250SD-C300SD/3 | F/10 | 3.5 | +4.902 | +5.054 | 64
TH | C250SD-C300SD/3 | B/5 | 1.8 | +4.556 | +4.681 | 125
FASCIA | C200SD-C250SD/3 | F/10 | 3.5 | +4.902 | +5.054 | 64
TH | C200SD-C250SD/3 | B/5 | 1.8 | +4.556 | +4.681 | 125
TH | C350SD>/2-3 | B/5 | 1.8 | +5.541 | +5.637 | 125
TH | C300SD-C350SD/2-3 | B/5 | 1.8 | +5.537 | +5.633 | 125
TH | C250SD-C300SD/2-3 | B/5 | 1.8 | +5.526 | +5.622 | 125
TH | C200SD-C250SD/2-3 | B/5 | 1.8 | +5.519 | +5.615 | 125
FASCIA | C150SD-C200SD/3 | F/10 | 3.5 | +4.902 | +5.054 | 64
TH | C150SD-C200SD/3 | B/5 | 1.8 | +4.556 | +4.681 | 125
TH | C150SD-C200SD/2-3 | B/5 | 1.8 | +5.511 | +5.607 | 125
FASCIA BRACKET | C350SD/3 | Z/52 | 0.2 | +4.903 | +5.060 | 157.2
FASCIA BRACKET | C300SD/3 | Z/52 | 0.2 | +4.903 | +5.060 | 157.2
FASCIA BRACKET | C250SD/3 | Z/52 | 0.2 | +4.903 | +5.060 | 157.2
FASCIA BRACKET | C200SD/3 | Z/52 | 0.2 | +4.903 | +5.060 | 157.2
FASCIA BRACKET | C150SD/3 | Z/52 | 0.2 | +4.903 | +5.060 | 157.2
FASCIA | C350SD>/3 | F/10 | 3.5 | +4.906 | +5.058 | 64
TH | C350SD>/3 | B/5 | 1.8 | +4.559 | +4.684 | 125
FASCIA | C300SD-C350SD/3 | F/10 | 3.5 | +4.906 | +5.058 | 64
TH | C300SD-C350SD/3 | B/5 | 1.8 | +4.559 | +4.684 | 125
FASCIA | C250SD-C300SD/3 | F/10 | 3.5 | +4.905 | +5.057 | 64
TH | C250SD-C300SD/3 | B/5 | 1.8 | +4.559 | +4.684 | 125
FASCIA | C200SD-C250SD/3 | F/10 | 3.5 | +4.905 | +5.057 | 64
TH | C200SD-C250SD/3 | B/5 | 1.8 | +4.559 | +4.684 | 125
TH | C350SD>/2-3 | B/5 | 1.8 | +5.453 | +5.547 | 125
TH | C300SD-C350SD/2-3 | B/5 | 1.8 | +5.447 | +5.540 | 125
TH | C250SD-C300SD/2-3 | B/5 | 1.8 | +5.441 | +5.534 | 125
TH | C200SD-C250SD/2-3 | B/5 | 1.8 | +5.435 | +5.528 | 125
FASCIA | C150SD-C200SD/3 | F/10 | 3.5 | +4.905 | +5.057 | 64
TH | C150SD-C200SD/3 | B/5 | 1.8 | +4.559 | +4.684 | 125
TH | C150SD-C200SD/2-3 | B/5 | 1.8 | +5.428 | +5.522 | 125
FASCIA BRACKET | C350SD/3 | Z/52 | 0.2 | +4.906 | +5.063 | 157.2
FASCIA BRACKET | C300SD/3 | Z/52 | 0.2 | +4.906 | +5.063 | 157.2
FASCIA BRACKET | C250SD/3 | Z/52 | 0.2 | +4.906 | +5.063 | 157.2
FASCIA BRACKET | C200SD/3 | Z/52 | 0.2 | +4.906 | +5.063 | 157.2
FASCIA BRACKET | C150SD/3 | Z/52 | 0.2 | +4.906 | +5.063 | 157.2
FASCIA | C350SD>/3 | F/10 | 3.5 | +4.909 | +5.061 | 64
TH | C350SD>/3 | B/5 | 1.8 | +4.562 | +4.687 | 125
FASCIA | C300SD-C350SD/3 | F/10 | 3.5 | +4.908 | +5.060 | 64
TH | C300SD-C350SD/3 | B/5 | 1.8 | +4.562 | +4.687 | 125
FASCIA | C250SD-C300SD/3 | F/10 | 3.5 | +4.908 | +5.060 | 64
TH | C250SD-C300SD/3 | B/5 | 1.8 | +4.562 | +4.687 | 125
FASCIA | C200SD-C250SD/3 | F/10 | 3.5 | +4.909 | +5.061 | 64
TH | C200SD-C250SD/3 | B/5 | 1.8 | +4.562 | +4.687 | 125
TH | C350SD>/2-3 | B/5 | 1.8 | +5.365 | +5.455 | 125
TH | C300SD-C350SD/2-3 | B/5 | 1.8 | +5.360 | +5.450 | 125
TH | C250SD-C300SD/2-3 | B/5 | 1.8 | +5.355 | +5.445 | 125
TH | C200SD-C250SD/2-3 | B/5 | 1.8 | +5.349 | +5.440 | 125
TH | C150SD-C200SD/2-3 | B/5 | 1.8 | +5.344 | +5.435 | 125
FASCIA | C150SD-C200SD/3 | F/10 | 3.5 | +4.909 | +5.061 | 64
TH | C150SD-C200SD/3 | B/5 | 1.8 | +4.562 | +4.687 | 125
FASCIA BRACKET | C350SD/1 | Z/52 | 0.2 | +4.893 | +5.050 | 157.2
FASCIA BRACKET | C350SD/1 | Z/52 | 0.2 | +4.900 | +5.057 | 157.2
FASCIA BRACKET | C350SD/1 | Z/52 | 0.2 | +4.906 | +5.063 | 157.2
FASCIA BRACKET | C300SD/1 | Z/52 | 0.2 | +4.893 | +5.050 | 157.2
FASCIA BRACKET | C300SD/1 | Z/52 | 0.2 | +4.900 | +5.057 | 157.2
FASCIA BRACKET | C300SD/1 | Z/52 | 0.2 | +4.906 | +5.063 | 157.2
FASCIA BRACKET | C250SD/1 | Z/52 | 0.2 | +4.893 | +5.050 | 157.2
FASCIA BRACKET | C250SD/1 | Z/52 | 0.2 | +4.900 | +5.057 | 157.2
FASCIA BRACKET | C250SD/1 | Z/52 | 0.2 | +4.906 | +5.063 | 157.2
FASCIA BRACKET | C200SD/1 | Z/52 | 0.2 | +4.893 | +5.050 | 157.2
FASCIA BRACKET | C200SD/1 | Z/52 | 0.2 | +4.900 | +5.057 | 157.2
FASCIA BRACKET | C200SD/1 | Z/52 | 0.2 | +4.906 | +5.063 | 157.2
FASCIA BRACKET | C150SD/1 | Z/52 | 0.2 | +4.893 | +5.050 | 157.2
FASCIA BRACKET | C150SD/1 | Z/52 | 0.2 | +4.900 | +5.057 | 157.2
FASCIA BRACKET | C150SD/1 | Z/52 | 0.2 | +4.906 | +5.063 | 157.2
FASCIA BRACKET | C350SD/1 | Z/52 | 0.2 | +4.903 | +5.060 | 157.2
FASCIA BRACKET | C300SD/1 | Z/52 | 0.2 | +4.903 | +5.060 | 157.2
FASCIA BRACKET | C250SD/1 | Z/52 | 0.2 | +4.903 | +5.060 | 157.2
FASCIA BRACKET | C200SD/1 | Z/52 | 0.2 | +4.903 | +5.060 | 157.2
FASCIA BRACKET | C150SD/1 | Z/52 | 0.2 | +4.903 | +5.060 | 157.2
FASCIA | C350SD>/1 | F/10 | 3.5 | +4.896 | +5.048 | 64
TH | C350SD>/1 | B/5 | 1.8 | +4.549 | +4.674 | 125
FASCIA | C350SD>/1 | F/10 | 3.5 | +4.902 | +5.054 | 64
TH | C350SD>/1 | B/5 | 1.8 | +4.556 | +4.681 | 125
FASCIA | C350SD>/1 | F/10 | 3.5 | +4.906 | +5.058 | 64
TH | C350SD>/1 | B/5 | 1.8 | +4.559 | +4.684 | 125
FASCIA | C350SD>/1 | F/10 | 3.5 | +4.909 | +5.061 | 64
TH | C350SD>/1 | B/5 | 1.8 | +4.562 | +4.687 | 125
FASCIA | C300SD-C350SD/1 | F/10 | 3.5 | +4.896 | +5.048 | 64
TH | C300SD-C350SD/1 | B/5 | 1.8 | +4.550 | +4.675 | 125
FASCIA | C300SD-C350SD/1 | F/10 | 3.5 | +4.902 | +5.054 | 64
TH | C300SD-C350SD/1 | B/5 | 1.8 | +4.556 | +4.681 | 125
FASCIA | C300SD-C350SD/1 | F/10 | 3.5 | +4.906 | +5.058 | 64
TH | C300SD-C350SD/1 | B/5 | 1.8 | +4.559 | +4.684 | 125
FASCIA | C300SD-C350SD/1 | F/10 | 3.5 | +4.908 | +5.060 | 64
TH | C300SD-C350SD/1 | B/5 | 1.8 | +4.562 | +4.687 | 125
FASCIA | C250SD-C300SD/1 | F/10 | 3.5 | +4.895 | +5.047 | 64
TH | C250SD-C300SD/1 | B/5 | 1.8 | +4.549 | +4.674 | 125
FASCIA | C250SD-C300SD/1 | F/10 | 3.5 | +4.902 | +5.054 | 64
TH | C250SD-C300SD/1 | B/5 | 1.8 | +4.556 | +4.681 | 125
FASCIA | C250SD-C300SD/1 | F/10 | 3.5 | +4.905 | +5.057 | 64
TH | C250SD-C300SD/1 | B/5 | 1.8 | +4.559 | +4.684 | 125
FASCIA | C250SD-C300SD/1 | F/10 | 3.5 | +4.908 | +5.060 | 64
TH | C250SD-C300SD/1 | B/5 | 1.8 | +4.562 | +4.687 | 125
FASCIA | C200SD-C250SD/1 | F/10 | 3.5 | +4.895 | +5.047 | 64
TH | C200SD-C250SD/1 | B/5 | 1.8 | +4.549 | +4.674 | 125
FASCIA | C200SD-C250SD/1 | F/10 | 3.5 | +4.902 | +5.054 | 64
TH | C200SD-C250SD/1 | B/5 | 1.8 | +4.556 | +4.681 | 125
FASCIA | C200SD-C250SD/1 | F/10 | 3.5 | +4.905 | +5.057 | 64
TH | C200SD-C250SD/1 | B/5 | 1.8 | +4.559 | +4.684 | 125
FASCIA | C200SD-C250SD/1 | F/10 | 3.5 | +4.909 | +5.061 | 64
TH | C200SD-C250SD/1 | B/5 | 1.8 | +4.562 | +4.687 | 125
TH | C350SD>/1-2 | B/5 | 1.8 | +5.541 | +5.637 | 125
TH | C350SD>/1-2 | B/5 | 1.8 | +5.453 | +5.547 | 125
TH | C350SD>/1-2 | B/5 | 1.8 | +5.365 | +5.455 | 125
TH | C300SD-C350SD/1-2 | B/5 | 1.8 | +5.722 | +5.824 | 125
TH | C300SD-C350SD/1-2 | B/5 | 1.8 | +5.537 | +5.633 | 125
TH | C300SD-C350SD/1-2 | B/5 | 1.8 | +5.447 | +5.540 | 125
TH | C300SD-C350SD/1-2 | B/5 | 1.8 | +5.360 | +5.450 | 125
TH | C250SD-C300SD/1-2 | B/5 | 1.8 | +5.713 | +5.815 | 125
TH | C250SD-C300SD/1-2 | B/5 | 1.8 | +5.526 | +5.622 | 125
TH | C250SD-C300SD/1-2 | B/5 | 1.8 | +5.441 | +5.534 | 125
TH | C250SD-C300SD/1-2 | B/5 | 1.8 | +5.355 | +5.445 | 125
TH | C200SD-C250SD/1-2 | B/5 | 1.8 | +5.704 | +5.806 | 125
TH | C200SD-C250SD/1-2 | B/5 | 1.8 | +5.519 | +5.615 | 125
TH | C200SD-C250SD/1-2 | B/5 | 1.8 | +5.435 | +5.528 | 125
TH | C200SD-C250SD/1-2 | B/5 | 1.8 | +5.349 | +5.440 | 125
FASCIA | C150SD-C200SD/1 | F/10 | 3.5 | +4.895 | +5.047 | 64
TH | C150SD-C200SD/1 | B/5 | 1.8 | +4.549 | +4.674 | 125
FASCIA | C150SD-C200SD/1 | F/10 | 3.5 | +4.902 | +5.054 | 64
TH | C150SD-C200SD/1 | B/5 | 1.8 | +4.556 | +4.681 | 125
FASCIA | C150SD-C200SD/1 | F/10 | 3.5 | +4.905 | +5.057 | 64
TH | C150SD-C200SD/1 | B/5 | 1.8 | +4.559 | +4.684 | 125
TH | C150SD-C200SD/1-2 | B/5 | 1.8 | +5.694 | +5.796 | 125
TH | C150SD-C200SD/1-2 | B/5 | 1.8 | +5.511 | +5.607 | 125
TH | C150SD-C200SD/1-2 | B/5 | 1.8 | +5.428 | +5.522 | 125
TH | C150SD-C200SD/1-2 | B/5 | 1.8 | +5.344 | +5.435 | 125
FASCIA | C150SD-C200SD/1 | F/10 | 3.5 | +4.909 | +5.061 | 64
TH | C150SD-C200SD/1 | B/5 | 1.8 | +4.562 | +4.687 | 125
BHR-25-350 | C350SD/2-3 | S/84 | 10.6 | +3.886 | +5.691 | 64
BHL-25-350 | C350SD/1-2 | S/82 | 10.6 | +3.886 | +5.691 | 64
BA-25-350 | C350SD/1-3 | S/83 | 16.3 | +5.856 | +6.008 | 64
BHR-25-250 | C250SD/2-3 | S/54 | 8.4 | +4.151 | +5.602 | 64
BHR-25-300 | C300SD/2-3 | S/69 | 9.7 | +3.999 | +5.662 | 64
BHL-25-300 | C300SD/1-2 | S/67 | 9.7 | +3.999 | +5.662 | 64
BA-25-300 | C300SD/1-3 | S/68 | 15.4 | +5.917 | +6.069 | 64
BHL-25-250 | C250SD/1-2 | S/52 | 8.4 | +4.151 | +5.602 | 64
BA-25-250 | C250SD/1-3 | S/53 | 15.4 | +5.924 | +6.076 | 64
BHR-25-200 | C200SD/2-3 | S/42 | 7.5 | +4.247 | +5.556 | 64
BHL-25-200 | C200SD/1-2 | S/40 | 7.5 | +4.247 | +5.556 | 64
BA-25-200 | C200SD/1-3 | S/41 | 14.5 | +5.984 | +6.136 | 64
BHR-25-150 | C150SD/2-3 | S/30 | 7 | +4.297 | +5.536 | 64
BHL-25-150 | C150SD/1-2 | S/28 | 7 | +4.297 | +5.536 | 64
BA-25-150 | C150SD/1-3 | S/29 | 13.7 | +6.051 | +6.203 | 64
BHR-18-300 | C300SD/2-3 | S/66 | 7.9 | +3.969 | +5.349 | 64
BHR-18-350 | C350SD/2-3 | S/81 | 8.4 | +3.886 | +5.337 | 64
BHL-18-350 | C350SD/1-2 | S/79 | 8.4 | +3.886 | +5.337 | 64
BA-18-350 | C350SD/1-3 | S/80 | 16.3 | +5.531 | +5.683 | 64
BHL-18-300 | C300SD/1-2 | S/64 | 7.9 | +3.969 | +5.349 | 64
BA-18-300 | C300SD/1-3 | S/65 | 15.4 | +5.577 | +5.729 | 64
BHR-18-250 | C250SD/2-3 | S/51 | 7 | +4.111 | +5.350 | 64
BHL-18-250 | C250SD/1-2 | S/49 | 7 | +4.111 | +5.350 | 64
BA-18-250 | C250SD/1-3 | S/50 | 15.4 | +5.586 | +5.738 | 64
BHR-18-200 | C200SD/2-3 | S/39 | 6.7 | +4.167 | +5.349 | 64
BHL-18-200 | C200SD/1-2 | S/37 | 6.7 | +4.167 | +5.349 | 64
BA-18-200 | C200SD/1-3 | S/38 | 14.5 | +5.642 | +5.794 | 64
BHR-18-150 | C150SD/2-3 | S/27 | 6.5 | +4.207 | +5.354 | 64
BHL-18-150 | C150SD/1-2 | S/25 | 6.5 | +4.207 | +5.354 | 64
BA-18-150 | C150SD/1-3 | S/26 | 13.7 | +5.687 | +5.839 | 64
BHR-15-350 | C350SD/2-3 | S/78 | 7.9 | +3.886 | +5.266 | 64
BHL-15-350 | C350SD/1-2 | S/76 | 7.9 | +3.886 | +5.266 | 64
BA-15-350 | C350SD/1-3 | S/77 | 16.3 | +5.391 | +5.543 | 64
BHR-15-300 | C300SD/2-3 | S/63 | 7.5 | +3.962 | +5.272 | 64
BHL-15-300 | C300SD/1-2 | S/61 | 7.5 | +3.962 | +5.272 | 64
BA-15-300 | C300SD/1-3 | S/62 | 15.4 | +5.427 | +5.579 | 64
BHR-15-250 | C250SD/2-3 | S/18 | 7 | +4.044 | +5.283 | 64
BHL-15-250 | C250SD/1-2 | S/16 | 7 | +4.044 | +5.283 | 64
BA-15-250 | C250SD/1-3 | S/17 | 15.4 | +5.451 | +5.603 | 64
BHR-15-200 | C200SD/2-3 | S/12 | 6.7 | +4.104 | +5.286 | 64
BHL-15-200 | C200SD/1-2 | S/10 | 6.7 | +4.104 | +5.286 | 64
BHR-12-200 | C200SD/2-3 | S/9 | 6.7 | +4.034 | +5.216 | 64
BHR-15-150 | C150SD/2-3 | S/6 | 6.5 | +4.150 | +5.297 | 64
BA-15-200 | C200SD/1-3 | S/11 | 14.5 | +5.495 | +5.647 | 64
BHL-15-150 | C150SD/1-2 | S/4 | 6.5 | +4.150 | +5.297 | 64
BA-15-150 | C150SD/1-3 | S/5 | 13.7 | +5.539 | +5.691 | 64
BHR-12-350 | C350SD/2-3 | S/24 | 7.9 | +3.816 | +5.196 | 64
BHL-12-350 | C350SD/1-2 | S/22 | 7.9 | +3.816 | +5.196 | 64
BA-12-350 | C350SD/1-3 | S/23 | 16.3 | +5.231 | +5.383 | 64
BHR-12-300 | C300SD/2-3 | S/21 | 7.5 | +3.892 | +5.202 | 64
BHL-12-300 | C300SD/1-2 | S/19 | 7.5 | +3.892 | +5.202 | 64
BA-12-300 | C300SD/1-3 | S/20 | 15.4 | +5.277 | +5.429 | 64
BHR-12-250 | C250SD/2-3 | S/15 | 7 | +3.964 | +5.203 | 64
BHL-12-250 | C250SD/1-2 | S/13 | 7 | +3.964 | +5.203 | 64
BA-12-250 | C250SD/1-3 | S/14 | 15.4 | +5.318 | +5.470 | 64
BHL-12-200 | C200SD/1-2 | S/7 | 6.7 | +4.034 | +5.216 | 64
BA-12-200 | C200SD/1-3 | S/8 | 14.5 | +5.365 | +5.517 | 64
BHR-12-150 | C150SD/2-3 | S/3 | 6.5 | +4.093 | +5.240 | 64
BHL-12-150 | C150SD/1-2 | S/1 | 6.5 | +4.093 | +5.240 | 64
BA-12-150 | C150SD/1-3 | S/2 | 13.7 | +5.400 | +5.552 | 64
RAFTER | C350SD/2-3 | Z/171 | 60.4 | +4.851 | +6.876 | 125
COLUMN | C350SD/3 | Z/1503 | 75.5 | +0.000 | +5.050 | 125
RAFTER | C300SD/2-3 | Z/151 | 51.2 | +4.873 | +6.874 | 96
COLUMN | C300SD/3 | Z/1488 | 63.2 | +0.000 | +5.050 | 96
RAFTER | C250SD/2-3 | Z/132 | 33.2 | +4.892 | +6.872 | 76
COLUMN | C250SD/3 | Z/1472 | 40.5 | +0.000 | +5.050 | 76
RAFTER | C150SD/2-3 | Z/94 | 23.6 | +4.937 | +6.868 | 64
COLUMN | C150SD/3 | Z/92 | 28.1 | +0.000 | +5.050 | 64
PLATE | C350SD/2-3 | PL/97 | 11.8 | +4.577 | +5.345 | 128
PLATE | C300SD/2-3 | PL/72 | 10.1 | +4.578 | +5.322 | 99
PLATE | C250SD/2-3 | PL/55 | 6.1 | +4.692 | +5.252 | 79
PLATE | C150SD/3 | PL/4 | 3 | +4.777 | +5.168 | 67
RAFTER | C350SD/2-3 | Z/168 | 58.2 | +4.784 | +6.320 | 125
COLUMN | C350SD/3 | Z/1501 | 75.7 | +0.000 | +5.057 | 125
RAFTER | C300SD/2-3 | Z/148 | 49.2 | +4.815 | +6.317 | 96
COLUMN | C300SD/3 | Z/1486 | 63.2 | +0.000 | +5.057 | 96
RAFTER | C250SD/2-3 | Z/129 | 31.9 | +4.844 | +6.313 | 76
COLUMN | C250SD/3 | Z/1470 | 40.6 | +0.000 | +5.057 | 76
COLUMN | C200SD/3 | Z/109 | 35.9 | +0.000 | +5.057 | 76
RAFTER | C150SD/2-3 | Z/91 | 22.6 | +4.908 | +6.307 | 64
COLUMN | C150SD/3 | Z/89 | 28.2 | +0.000 | +5.057 | 64
PLATE | C350SD/2-3 | PL/99 | 10.8 | +4.577 | +5.247 | 128
PLATE | C300SD/2-3 | PL/74 | 9.4 | +4.577 | +5.231 | 99
PLATE | C250SD/2-3 | PL/57 | 5.6 | +4.692 | +5.180 | 79
PLATE | C200SD/3 | PL/40 | 3.3 | +4.777 | +5.137 | 79
PLATE | C150SD/3 | PL/6 | 2.7 | +4.777 | +5.120 | 67
RAFTER | C350SD/2-3 | Z/165 | 57.6 | +4.758 | +6.093 | 125
COLUMN | C350SD/3 | Z/1499 | 75.7 | +0.000 | +5.060 | 125
RAFTER | C300SD/2-3 | Z/145 | 48.6 | +4.793 | +6.090 | 96
COLUMN | C300SD/3 | Z/1484 | 63.3 | +0.000 | +5.060 | 96
RAFTER | C250SD/2-3 | Z/126 | 31.5 | +4.825 | +6.086 | 76
COLUMN | C250SD/3 | Z/1468 | 40.6 | +0.000 | +5.060 | 76
RAFTER | C200SD/2-3 | Z/108 | 28.1 | +4.861 | +6.083 | 76
COLUMN | C200SD/3 | Z/106 | 35.9 | +0.000 | +5.060 | 76
RAFTER | C150SD/2-3 | Z/88 | 22.3 | +4.896 | +6.080 | 64
COLUMN | C150SD/3 | Z/86 | 28.2 | +0.000 | +5.060 | 64
PLATE | C350SD/2-3 | PL/101 | 10.5 | +4.577 | +5.205 | 128
PLATE | C300SD/2-3 | PL/76 | 9.1 | +4.577 | +5.192 | 99
PLATE | C250SD/2-3 | PL/59 | 5.3 | +4.692 | +5.149 | 79
PLATE | C200SD/3 | PL/38 | 3.2 | +4.777 | +5.114 | 79
PLATE | C150SD/3 | PL/8 | 2.6 | +4.777 | +5.100 | 67
PLATE | C350SD/2-3 | PL/103 | 10.1 | +4.577 | +5.164 | 128
PLATE | C300SD/2-3 | PL/80 | 8.8 | +4.577 | +5.153 | 99
PLATE | C250SD/3 | PL/64 | 5.2 | +4.692 | +5.119 | 79
PLATE | C200SD/3 | PL/36 | 3.1 | +4.777 | +5.091 | 79
PLATE | C150SD/3 | PL/16 | 2.5 | +4.777 | +5.080 | 67
RAFTER | C350SD/1-2 | Z/1504 | 60.4 | +4.851 | +6.876 | 125
RAFTER | C300SD/1-2 | Z/1489 | 51.2 | +4.873 | +6.874 | 96
RAFTER | C250SD/1-2 | Z/1473 | 33.2 | +4.892 | +6.872 | 76
RAFTER | C200SD/1-2 | Z/5 | 29.7 | +4.915 | +6.870 | 76
RAFTER | C150SD/1-2 | Z/93 | 23.6 | +4.937 | +6.868 | 64
COLUMN | C350SD/1 | Z/1503 | 75.5 | +0.000 | +5.050 | 125
COLUMN | C300SD/1 | Z/1488 | 63.2 | +0.000 | +5.050 | 96
COLUMN | C250SD/1 | Z/1472 | 40.5 | +0.000 | +5.050 | 76
COLUMN | C200SD/1 | Z/111 | 35.9 | +0.000 | +5.050 | 76
COLUMN | C150SD/1 | Z/92 | 28.1 | +0.000 | +5.050 | 64
PLATE | C350SD/1-2 | PL/96 | 11.8 | +4.577 | +5.345 | 128
PLATE | C350SD/1-3 | PL/109 | 12.4 | +6.373 | +6.947 | 128
PLATE | C300SD/1-2 | PL/71 | 10.1 | +4.578 | +5.322 | 99
PLATE | C300SD/1-3 | PL/88 | 10.5 | +6.416 | +6.935 | 99
PLATE | C250SD/1-2 | PL/54 | 6.1 | +4.692 | +5.252 | 79
PLATE | C250SD/2 | PL/67 | 4.7 | +6.540 | +6.924 | 79
PLATE | C200SD/1 | PL/41 | 3.7 | +4.775 | +5.192 | 79
PLATE | C200SD/2 | PL/46 | 3.9 | +6.585 | +6.912 | 79
PLATE | C150SD/1 | PL/3 | 3 | +4.777 | +5.168 | 67
PLATE | C150SD/2 | PL/21 | 2.5 | +6.646 | +6.900 | 67
RAFTER | C350SD/1-2 | Z/1502 | 58.2 | +4.784 | +6.320 | 125
RAFTER | C300SD/1-2 | Z/1487 | 49.2 | +4.815 | +6.317 | 96
RAFTER | C250SD/1-2 | Z/1471 | 31.9 | +4.844 | +6.313 | 76
RAFTER | C200SD/2-3 | Z/110 | 28.5 | +4.876 | +6.310 | 76
RAFTER | C200SD/1-2 | Z/4 | 28.5 | +4.876 | +6.310 | 76
RAFTER | C150SD/1-2 | Z/90 | 22.6 | +4.908 | +6.307 | 64
COLUMN | C350SD/1 | Z/1501 | 75.7 | +0.000 | +5.057 | 125
COLUMN | C300SD/1 | Z/1486 | 63.2 | +0.000 | +5.057 | 96
COLUMN | C250SD/1 | Z/1470 | 40.6 | +0.000 | +5.057 | 76
COLUMN | C200SD/1 | Z/109 | 35.9 | +0.000 | +5.057 | 76
COLUMN | C150SD/1 | Z/89 | 28.2 | +0.000 | +5.057 | 64
PLATE | C350SD/1-2 | PL/98 | 10.8 | +4.577 | +5.247 | 128
PLATE | C350SD/1-3 | PL/108 | 11.8 | +5.849 | +6.357 | 128
PLATE | C300SD/1-2 | PL/73 | 9.4 | +4.577 | +5.231 | 99
PLATE | C300SD/2 | PL/87 | 9.9 | +5.893 | +6.348 | 99
PLATE | C250SD/1-2 | PL/56 | 5.6 | +4.692 | +5.180 | 79
PLATE | C250SD/2 | PL/66 | 4.4 | +5.996 | +6.341 | 79
PLATE | C200SD/1 | PL/39 | 3.3 | +4.777 | +5.137 | 79
PLATE | C200SD/2 | PL/45 | 3.7 | +6.041 | +6.332 | 79
PLATE | C150SD/1 | PL/5 | 2.7 | +4.777 | +5.120 | 67
PLATE | C150SD/2 | PL/18 | 2.3 | +6.099 | +6.324 | 67
RAFTER | C350SD/1-2 | Z/1500 | 57.6 | +4.758 | +6.093 | 125
RAFTER | C300SD/1-2 | Z/1485 | 48.6 | +4.793 | +6.090 | 96
RAFTER | C250SD/1-2 | Z/1469 | 31.5 | +4.825 | +6.086 | 76
RAFTER | C200SD/1-2 | Z/107 | 28.1 | +4.861 | +6.083 | 76
RAFTER | C150SD/1-2 | Z/87 | 22.3 | +4.896 | +6.080 | 64
COLUMN | C350SD/1 | Z/1499 | 75.7 | +0.000 | +5.060 | 125
COLUMN | C300SD/1 | Z/1484 | 63.3 | +0.000 | +5.060 | 96
COLUMN | C250SD/1 | Z/1468 | 40.6 | +0.000 | +5.060 | 76
COLUMN | C200SD/1 | Z/106 | 35.9 | +0.000 | +5.060 | 76
COLUMN | C150SD/1 | Z/86 | 28.2 | +0.000 | +5.060 | 64
PLATE | C350SD/1-2 | PL/100 | 10.5 | +4.577 | +5.205 | 128
PLATE | C350SD/1-3 | PL/107 | 11.4 | +5.638 | +6.119 | 128
PLATE | C300SD/1-2 | PL/75 | 9.1 | +4.577 | +5.192 | 99
PLATE | C300SD/2 | PL/86 | 9.7 | +5.683 | +6.112 | 99
PLATE | C250SD/1-2 | PL/58 | 5.3 | +4.692 | +5.149 | 79
PLATE | C250SD/2 | PL/65 | 4.2 | +5.776 | +6.105 | 79
PLATE | C200SD/1 | PL/37 | 3.2 | +4.777 | +5.114 | 79
PLATE | C200SD/2 | PL/44 | 3.6 | +5.822 | +6.099 | 79
PLATE | C150SD/1 | PL/7 | 2.6 | +4.777 | +5.100 | 67
PLATE | C150SD/2 | PL/17 | 2.3 | +5.878 | +6.092 | 67
PLATE | C350SD/1-2 | PL/102 | 10.1 | +4.577 | +5.164 | 128
PLATE | C350SD/2 | PL/106 | 11.1 | +5.433 | +5.887 | 128
PLATE | C300SD/1-2 | PL/79 | 8.8 | +4.577 | +5.153 | 99
PLATE | C300SD/2 | PL/85 | 9.4 | +5.479 | +5.882 | 99
PLATE | C250SD/1 | PL/62 | 5.2 | +4.692 | +5.119 | 79
PLATE | C250SD/2 | PL/63 | 4.2 | +5.562 | +5.877 | 79
PLATE | C200SD/1 | PL/35 | 3.1 | +4.777 | +5.091 | 79
PLATE | C200SD/2 | PL/43 | 3.5 | +5.609 | +5.872 | 79
PLATE | C150SD/1 | PL/14 | 2.5 | +4.777 | +5.080 | 67
PLATE | C150SD/2 | PL/15 | 2.2 | +5.664 | +5.866 | 67

# IfcMechanicalFastener: Bolt assembly (400)
In: Undefined
Tekla Bolt - Location: Site
Name | NominalDiameter (mm) = Washer diameter (mm) = Bolt size (mm) | NominalLength (mm) = Bolt length (mm) | Material = Bolt standard | Washer count | Washer type | Washer name | Nut count = Bolt count | Nut type | Nut name | Slotted hole y (mm) | Slotted hole x (mm) | Bolt hole diameter (mm) | Bolt Name
40 x Bolt assembly | 12 | 30 | PB1230 | 4 | FLAT | WASHERM12-FLAT | 4 | 4.6-HEX | NUTM12-4.6-HEX | 4 | 8 | 14 | BOLTPB1230
32 x Bolt assembly | 12 | 30 | 8.8S | 4 | HARD | WASHERM12-HARD | 4 | 8.8-HEX | NUTM12-8.8-HEX | 8 | 4 | 14 | BOLTM12*30
16 x Bolt assembly | 12 | 30 | 8.8S | 4 | HARD | WASHERM12-HARD | 4 | 8.8-HEX | NUTM12-8.8-HEX | 4 | 8 | 14 | BOLTM12*30
80 x Bolt assembly | 5 | 25 | TEK_16TPIM | 8 | UNDEF_WASH | UNDEFINED_WASHER5 | 2 | UNDEF_NUT | UNDEFINED_NUTM5 | 0 | 0 | 7 | TEKSCREW_M5*25
40 x Bolt assembly | 5 | 25 | TEK_16TPIM | 16 | UNDEF_WASH | UNDEFINED_WASHER5 | 4 | UNDEF_NUT | UNDEFINED_NUTM5 | 0 | 0 | 7 | TEKSCREW_M5*25
120 x Bolt assembly | 12 | 30 | PB1230 | 4 | FLAT | WASHERM12-FLAT | 4 | 4.6-HEX | NUTM12-4.6-HEX | 4 | 0 | 18 | BOLTPB1230
32 x Bolt assembly | 16 | 40 | 8.8S | 6 | HARD | WASHERM16-HARD | 6 | 8.8-HEX | NUTM16-8.8-HEX | 4 | 0 | 18 | BOLTM16*40
16 x Bolt assembly | 16 | 40 | 8.8S | 6 | HARD | WASHERM16-HARD | 6 | 8.8-HEX | NUTM16-8.8-HEX | 0 | 4 | 18 | BOLTM16*40
16 x Bolt assembly | 16 | 35 | 8.8S | 4 | HARD | WASHERM16-HARD | 4 | 8.8-HEX | NUTM16-8.8-HEX | 4 | 0 | 18 | BOLTM16*35
8 x Bolt assembly | 16 | 35 | 8.8S | 4 | HARD | WASHERM16-HARD | 4 | 8.8-HEX | NUTM16-8.8-HEX | 0 | 4 | 18 | BOLTM16*35

# IfcMember: C:150-19 (40)
In: Undefined
Description: C:150-19; Material: STEEL/G450
Tekla Common - Phase: 1; Class: 5
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 139.7 m2; Height: 152 mm; Width: 64 mm
Pset_MemberCommon - LoadBearing: no
BaseQuantities - GrossSurfaceArea: 0 m2; CrossSectionArea: 0.000561 m2
Name | Bottom elevation | Top elevation | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | Reference | OuterSurfaceArea (m2) | NetVolume (m3) | GrossVolume (m3) | NetWeight (kg) | GrossWeight (kg)
BHR-25-350 | +3.886 | +5.691 | 10.6 | 1.5 | 2400 | S/84 | 1.4762 | 0.00139262 | 0.0013464 | 10.9321 | 10.5692
BHL-25-350 | +3.886 | +5.691 | 10.6 | 1.5 | 2400 | S/82 | 1.4762 | 0.00139262 | 0.0013464 | 10.9321 | 10.5692
BHR-25-250 | +4.151 | +5.602 | 8.4 | 1.2 | 1900 | S/54 | 1.1689 | 0.00110249 | 0.0010659 | 8.65458 | 8.36731
BHR-25-300 | +3.999 | +5.662 | 9.7 | 1.5 | 2200 | S/69 | 1.35328 | 0.00127657 | 0.0012342 | 10.0211 | 9.68847
BHL-25-300 | +3.999 | +5.662 | 9.7 | 1.5 | 2200 | S/67 | 1.35328 | 0.00127657 | 0.0012342 | 10.0211 | 9.68847
BHL-25-250 | +4.151 | +5.602 | 8.4 | 1.2 | 1900 | S/52 | 1.1689 | 0.00110249 | 0.0010659 | 8.65458 | 8.36732
BHR-25-200 | +4.247 | +5.556 | 7.5 | 1 | 1700 | S/42 | 1.04598 | 0.000986442 | 0.0009537 | 7.74357 | 7.48654
BHL-25-200 | +4.247 | +5.556 | 7.5 | 1 | 1700 | S/40 | 1.04598 | 0.000986442 | 0.0009537 | 7.74357 | 7.48655
BHR-25-150 | +4.297 | +5.536 | 7 | 1 | 1600 | S/30 | 0.984521 | 0.000928416 | 0.0008976 | 7.28807 | 7.04616
BHL-25-150 | +4.297 | +5.536 | 7 | 1 | 1600 | S/28 | 0.984521 | 0.000928416 | 0.0008976 | 7.28807 | 7.04616
BHR-18-300 | +3.969 | +5.349 | 7.9 | 1.1 | 1800 | S/66 | 1.10744 | 0.00104447 | 0.0010098 | 8.19907 | 7.92693
BHR-18-350 | +3.886 | +5.337 | 8.4 | 1.2 | 1900 | S/81 | 1.1689 | 0.00110249 | 0.0010659 | 8.65458 | 8.36732
BHL-18-350 | +3.886 | +5.337 | 8.4 | 1.2 | 1900 | S/79 | 1.1689 | 0.00110249 | 0.0010659 | 8.65458 | 8.36732
BHL-18-300 | +3.969 | +5.349 | 7.9 | 1.1 | 1800 | S/64 | 1.10744 | 0.00104447 | 0.0010098 | 8.19907 | 7.92693
BHR-18-250 | +4.111 | +5.350 | 7 | 1 | 1600 | S/51 | 0.984521 | 0.000928416 | 0.0008976 | 7.28807 | 7.04616
BHL-18-250 | +4.111 | +5.350 | 7 | 1 | 1600 | S/49 | 0.984521 | 0.000928416 | 0.0008976 | 7.28807 | 7.04616
BHR-18-200 | +4.167 | +5.349 | 6.7 | 1 | 1520 | S/39 | 0.935353 | 0.000881995 | 0.00085272 | 6.92366 | 6.69385
BHL-18-200 | +4.167 | +5.349 | 6.7 | 1 | 1520 | S/37 | 0.935353 | 0.000881995 | 0.00085272 | 6.92366 | 6.69385
BHR-18-150 | +4.207 | +5.354 | 6.5 | 1 | 1470 | S/27 | 0.904623 | 0.000852982 | 0.00082467 | 6.69591 | 6.47366
BHL-18-150 | +4.207 | +5.354 | 6.5 | 1 | 1470 | S/25 | 0.904623 | 0.000852982 | 0.00082467 | 6.69591 | 6.47366
BHR-15-350 | +3.886 | +5.266 | 7.9 | 1.1 | 1800 | S/78 | 1.10744 | 0.00104447 | 0.0010098 | 8.19907 | 7.92693
BHL-15-350 | +3.886 | +5.266 | 7.9 | 1.1 | 1800 | S/76 | 1.10744 | 0.00104447 | 0.0010098 | 8.19907 | 7.92693
BHR-15-300 | +3.962 | +5.272 | 7.5 | 1 | 1700 | S/63 | 1.04598 | 0.000986442 | 0.0009537 | 7.74357 | 7.48655
BHL-15-300 | +3.962 | +5.272 | 7.5 | 1 | 1700 | S/61 | 1.04598 | 0.000986442 | 0.0009537 | 7.74357 | 7.48654
BHR-15-250 | +4.044 | +5.283 | 7 | 1 | 1600 | S/18 | 0.984521 | 0.000928416 | 0.0008976 | 7.28807 | 7.04616
BHL-15-250 | +4.044 | +5.283 | 7 | 1 | 1600 | S/16 | 0.984521 | 0.000928416 | 0.0008976 | 7.28807 | 7.04616
BHR-15-200 | +4.104 | +5.286 | 6.7 | 1 | 1520 | S/12 | 0.935353 | 0.000881995 | 0.00085272 | 6.92366 | 6.69385
BHL-15-200 | +4.104 | +5.286 | 6.7 | 1 | 1520 | S/10 | 0.935353 | 0.000881995 | 0.00085272 | 6.92366 | 6.69385
BHR-15-150 | +4.150 | +5.297 | 6.5 | 1 | 1470 | S/6 | 0.904623 | 0.000852982 | 0.00082467 | 6.69591 | 6.47366
BHL-15-150 | +4.150 | +5.297 | 6.5 | 1 | 1470 | S/4 | 0.904623 | 0.000852982 | 0.00082467 | 6.69591 | 6.47366
BHR-12-350 | +3.816 | +5.196 | 7.9 | 1.1 | 1800 | S/24 | 1.10744 | 0.00104447 | 0.0010098 | 8.19907 | 7.92693
BHR-12-300 | +3.892 | +5.202 | 7.5 | 1 | 1700 | S/21 | 1.04598 | 0.000986442 | 0.0009537 | 7.74357 | 7.48654
BHR-12-250 | +3.964 | +5.203 | 7 | 1 | 1600 | S/15 | 0.984521 | 0.000928416 | 0.0008976 | 7.28807 | 7.04616
BHR-12-200 | +4.034 | +5.216 | 6.7 | 1 | 1520 | S/9 | 0.935353 | 0.000881995 | 0.00085272 | 6.92366 | 6.69385
BHR-12-150 | +4.093 | +5.240 | 6.5 | 1 | 1470 | S/3 | 0.904623 | 0.000852982 | 0.00082467 | 6.69591 | 6.47366
BHL-12-350 | +3.816 | +5.196 | 7.9 | 1.1 | 1800 | S/22 | 1.10744 | 0.00104447 | 0.0010098 | 8.19907 | 7.92693
BHL-12-300 | +3.892 | +5.202 | 7.5 | 1 | 1700 | S/19 | 1.04598 | 0.000986442 | 0.0009537 | 7.74357 | 7.48654
BHL-12-250 | +3.964 | +5.203 | 7 | 1 | 1600 | S/13 | 0.984521 | 0.000928416 | 0.0008976 | 7.28807 | 7.04616
BHL-12-200 | +4.034 | +5.216 | 6.7 | 1 | 1520 | S/7 | 0.935353 | 0.000881995 | 0.00085272 | 6.92366 | 6.69385
BHL-12-150 | +4.093 | +5.240 | 6.5 | 1 | 1470 | S/1 | 0.904623 | 0.000852982 | 0.00082467 | 6.69591 | 6.47366

# IfcMember: C:150-24 (2)
In: Undefined
Description: C:150-24; Material: STEEL/G450
Tekla Common - Finish: 25 deg; Bottom elevation: +4.937; Top elevation: +6.868; Phase: 1; Class: 1
Tekla Quantity - Weight: 23.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 111.2 m2; Net surface area: 2.6 m2; Height: 152 mm; Width: 64 mm; Length: 4242.2 mm
Pset_MemberCommon - LoadBearing: no
BaseQuantities - Length: 4242.22 mm; OuterSurfaceArea: 2.62996 m2; GrossSurfaceArea: 0 m2; CrossSectionArea: 0.00071 m2; NetVolume: 0.00312974 m3; GrossVolume: 0.00301198 m3; NetWeight: 24.5685 kg; GrossWeight: 23.644 kg
Name | Reference
RAFTER | Z/94
RAFTER | Z/93

# IfcMember: C:200-24 (2)
In: Undefined
Description: C:200-24; Material: STEEL/G450
Tekla Common - Finish: 25 deg; Bottom elevation: +4.915; Top elevation: +6.870; Phase: 1; Class: 1
Tekla Quantity - Weight: 29.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 110 m2; Net surface area: 3.3 m2; Height: 203 mm; Width: 76 mm; Length: 4190.3 mm
Pset_MemberCommon - LoadBearing: no
BaseQuantities - Length: 4190.31 mm; OuterSurfaceArea: 3.26862 m2; GrossSurfaceArea: 0 m2; CrossSectionArea: 0.000903 m2; NetVolume: 0.00389598 m3; GrossVolume: 0.00378385 m3; NetWeight: 30.5835 kg; GrossWeight: 29.7032 kg
Name | Reference
RAFTER | Z/112
RAFTER | Z/5

# IfcMember: C:250-24 (2)
In: Undefined
Description: C:250-24; Material: STEEL/G450
Tekla Common - Finish: 25 deg; Bottom elevation: +4.892; Top elevation: +6.872; Phase: 1; Class: 1
Tekla Quantity - Weight: 33.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 109.7 m2; Net surface area: 3.6 m2; Height: 254 mm; Width: 76 mm; Length: 4138.4 mm
Pset_MemberCommon - LoadBearing: no
BaseQuantities - Length: 4138.39 mm; OuterSurfaceArea: 3.64222 m2; GrossSurfaceArea: 0 m2; CrossSectionArea: 0.001022 m2; NetVolume: 0.00434431 m3; GrossVolume: 0.00422943 m3; NetWeight: 34.1029 kg; GrossWeight: 33.201 kg
Name | Reference
RAFTER | Z/132
RAFTER | Z/1473

# IfcMember: C:300-30 (2)
In: Undefined
Description: C:300-30; Material: STEEL/G450
Tekla Common - Finish: 25 deg; Bottom elevation: +4.873; Top elevation: +6.874; Phase: 1; Class: 1
Tekla Quantity - Weight: 51.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.4 m2; Net surface area: 4.4 m2; Height: 300 mm; Width: 96 mm; Length: 4091.6 mm
Pset_MemberCommon - LoadBearing: no
BaseQuantities - Length: 4091.56 mm; OuterSurfaceArea: 4.47124 m2; GrossSurfaceArea: 0 m2; CrossSectionArea: 0.001593 m2; NetVolume: 0.00666515 m3; GrossVolume: 0.00651785 m3; NetWeight: 52.3214 kg; GrossWeight: 51.1651 kg
Name | Reference
RAFTER | Z/151
RAFTER | Z/1489

# IfcMember: C:350-30 (2)
In: Undefined
Description: C:350-30; Material: STEEL/G450
Tekla Common - Finish: 25 deg; Bottom elevation: +4.851; Top elevation: +6.876; Phase: 1; Class: 1
Tekla Quantity - Weight: 60.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.1 m2; Net surface area: 5.3 m2; Height: 350 mm; Width: 125 mm; Length: 4040.7 mm
Pset_MemberCommon - LoadBearing: no
BaseQuantities - Length: 4040.66 mm; OuterSurfaceArea: 5.26483 m2; GrossSurfaceArea: 0 m2; CrossSectionArea: 0.001905 m2; NetVolume: 0.00785504 m3; GrossVolume: 0.00769746 m3; NetWeight: 61.6621 kg; GrossWeight: 60.425 kg
Name | Reference
RAFTER | Z/171
RAFTER | Z/1504

# IfcPlate: PLT3*238.6 (4)
In: Undefined
Description: PLT3*238.6; Material: STEEL/250
Default - ASSEMBLY_POS: PL/147
Tekla Common - Phase: 1; Class: 2
Tekla Quantity - Weight: 2.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87 m2; Net surface area: 0.2 m2; Height: 238.6 mm; Width: 3 mm; Length: 400 mm
Pset_PlateCommon - LoadBearing: no; Reference: PL/147
BaseQuantities - Width: 238.596 mm; NetArea: 0.198176 m2; GrossArea: 0.0954382 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000290091 m3; GrossVolume: 0.000290091 m3
Name | Bottom elevation | Top elevation
2 x STIFFINER SLEEVE | +5.005 | +5.231
2 x STIFFINER SLEEVE | +4.073 | +4.473

# IfcPlate: PLT3*294.7, PLATE
In: Undefined
Description: PLT3*294.7; Material: STEEL/450
Default - ASSEMBLY_POS: PL/15
Tekla Common - Bottom elevation: +5.664; Top elevation: +5.866; Phase: 1; Class: 11
Tekla Quantity - Weight: 2.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.7 m2; Net surface area: 0.2 m2; Height: 294.7 mm; Width: 3 mm; Length: 429.3 mm
Pset_PlateCommon - LoadBearing: no; Reference: PL/15
BaseQuantities - Width: 294.722 mm; NetArea: 0.191471 m2; GrossArea: 0.126531 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000281369 m3; GrossVolume: 0.000281369 m3

# IfcPlate: PLT3*308.7 (2)
In: Undefined
Description: PLT3*308.7; Material: STEEL/450
Tekla Common - Bottom elevation: +4.777; Top elevation: +5.080; Phase: 1; Class: 11
Tekla Quantity - Weight: 2.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.7 m2; Net surface area: 0.2 m2; Height: 308.7 mm; Width: 3 mm; Length: 451.2 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - NetArea: 0.216526 m2; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Width (mm) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
PLATE | PL/16 | 308.673 | 0.139264 | 0.000318537
PLATE | PL/14 | 308.662 | 0.139258 | 0.000318536

# IfcPlate: PLT3*311, PLATE
In: Undefined
Description: PLT3*311; Material: STEEL/450
Default - ASSEMBLY_POS: PL/17
Tekla Common - Bottom elevation: +5.878; Top elevation: +6.092; Phase: 1; Class: 11
Tekla Quantity - Weight: 2.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.7 m2; Net surface area: 0.2 m2; Height: 311 mm; Width: 3 mm; Length: 438.1 mm
Pset_PlateCommon - LoadBearing: no; Reference: PL/17
BaseQuantities - Width: 310.983 mm; NetArea: 0.196562 m2; GrossArea: 0.136236 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000288955 m3; GrossVolume: 0.000288955 m3

# IfcPlate: PLT3*313.6 (4)
In: Undefined
Description: PLT3*313.6; Material: STEEL/250
Default - ASSEMBLY_POS: PL/148
Tekla Common - Phase: 1; Class: 2
Tekla Quantity - Weight: 3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.7 m2; Net surface area: 0.3 m2; Height: 313.6 mm; Width: 3 mm; Length: 400 mm
Pset_PlateCommon - LoadBearing: no; Reference: PL/148
BaseQuantities - Width: 313.596 mm; NetArea: 0.258626 m2; GrossArea: 0.125438 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000380091 m3; GrossVolume: 0.000380091 m3
Name | Bottom elevation | Top elevation
2 x STIFFINER SLEEVE | +4.968 | +5.243
2 x STIFFINER SLEEVE | +4.023 | +4.423

# IfcPlate: PLT3*314 (2)
In: Undefined
Description: PLT3*314; Material: STEEL/450
Tekla Common - Bottom elevation: +4.777; Top elevation: +5.100; Phase: 1; Class: 11
Tekla Quantity - Weight: 2.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.7 m2; Net surface area: 0.2 m2; Height: 314 mm; Width: 3 mm; Length: 464.4 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - NetArea: 0.223703 m2; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Width (mm) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
PLATE | PL/8 | 314.03 | 0.145845 | 0.000329214
PLATE | PL/7 | 314.009 | 0.145832 | 0.000329208

# IfcPlate: PLT3*318.7 (2)
In: Undefined
Description: PLT3*318.7; Material: STEEL/450
Tekla Common - Bottom elevation: +4.777; Top elevation: +5.120; Phase: 1; Class: 11
Tekla Quantity - Weight: 2.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.5 m2; Net surface area: 0.2 m2; Height: 318.7 mm; Width: 3 mm; Length: 477.9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - NetArea: 0.230962 m2; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Width (mm) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
PLATE | PL/6 | 318.742 | 0.152323 | 0.000340008
PLATE | PL/5 | 318.695 | 0.152296 | 0.000339996

# IfcPlate: PLT3*326, PLATE
In: Undefined
Description: PLT3*326; Material: STEEL/450
Default - ASSEMBLY_POS: PL/18
Tekla Common - Bottom elevation: +6.099; Top elevation: +6.324; Phase: 1; Class: 11
Tekla Quantity - Weight: 2.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.7 m2; Net surface area: 0.2 m2; Height: 326 mm; Width: 3 mm; Length: 444.2 mm
Pset_PlateCommon - LoadBearing: no; Reference: PL/18
BaseQuantities - Width: 326.046 mm; NetArea: 0.201426 m2; GrossArea: 0.144845 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000296202 m3; GrossVolume: 0.000296202 m3

# IfcPlate: PLT3*327, PLATE
In: Undefined
Description: PLT3*327; Material: STEEL/450
Tekla Common - Bottom elevation: +4.777; Top elevation: +5.168; Phase: 1; Class: 11
Default - ASSEMBLY_POS: PL/3
Tekla Quantity - Weight: 3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.5 m2; Net surface area: 0.2 m2; Height: 327 mm; Width: 3.1 mm; Length: 510.3 mm
Pset_PlateCommon - LoadBearing: no; Reference: PL/3
BaseQuantities - Width: 327.001 mm; NetArea: 0.248283 m2; GrossArea: 0.166851 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000365726 m3; GrossVolume: 0.000365726 m3

# IfcPlate: PLT3*327.1, PLATE
In: Undefined
Description: PLT3*327.1; Material: STEEL/450
Default - ASSEMBLY_POS: PL/4
Tekla Common - Bottom elevation: +4.777; Top elevation: +5.168; Phase: 1; Class: 11
Tekla Quantity - Weight: 3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.5 m2; Net surface area: 0.2 m2; Height: 327.1 mm; Width: 3.1 mm; Length: 510.3 mm
Pset_PlateCommon - LoadBearing: no; Reference: PL/4
BaseQuantities - Width: 327.13 mm; NetArea: 0.248286 m2; GrossArea: 0.166929 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000365749 m3; GrossVolume: 0.000365749 m3

# IfcPlate: PLT3*333.3 (2)
In: Undefined
Description: PLT3*333.3; Material: STEEL/450
Tekla Common - Bottom elevation: +4.777; Top elevation: +5.091; Phase: 1; Class: 11
Tekla Quantity - Weight: 3.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.3 m2; Height: 333.3 mm; Width: 3 mm; Length: 496.9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - NetArea: 0.266193 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000392276 m3; GrossVolume: 0.000392276 m3
Name | ASSEMBLY_POS = Reference | Width (mm) | GrossArea (m2)
PLATE | PL/36 | 333.309 | 0.165626
PLATE | PL/35 | 333.291 | 0.165615

# IfcPlate: PLT3*340.9, PLATE
In: Undefined
Description: PLT3*340.9; Material: STEEL/450
Tekla Common - Bottom elevation: +4.777; Top elevation: +5.114; Phase: 1; Class: 11
Default - ASSEMBLY_POS: PL/37
Tekla Quantity - Weight: 3.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.3 m2; Height: 341 mm; Width: 3.1 mm; Length: 511.9 mm
Pset_PlateCommon - LoadBearing: no; Reference: PL/37
BaseQuantities - Width: 340.879 mm; NetArea: 0.276668 m2; GrossArea: 0.174498 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000407881 m3; GrossVolume: 0.000407881 m3

# IfcPlate: PLT3*341, PLATE
In: Undefined
Description: PLT3*341; Material: STEEL/450
Default - ASSEMBLY_POS: PL/38
Tekla Common - Bottom elevation: +4.777; Top elevation: +5.114; Phase: 1; Class: 11
Tekla Quantity - Weight: 3.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.3 m2; Height: 341 mm; Width: 3.2 mm; Length: 511.9 mm
Pset_PlateCommon - LoadBearing: no; Reference: PL/38
BaseQuantities - Width: 341.04 mm; NetArea: 0.276668 m2; GrossArea: 0.174592 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000407881 m3; GrossVolume: 0.000407881 m3

# IfcPlate: PLT3*347.8, PLATE
In: Undefined
Description: PLT3*347.8; Material: STEEL/450
Tekla Common - Bottom elevation: +4.777; Top elevation: +5.137; Phase: 1; Class: 11
Default - ASSEMBLY_POS: PL/39
Tekla Quantity - Weight: 3.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.3 m2; Height: 347.8 mm; Width: 3.2 mm; Length: 527.1 mm
Pset_PlateCommon - LoadBearing: no; Reference: PL/39
BaseQuantities - Width: 347.803 mm; NetArea: 0.287435 m2; GrossArea: 0.183329 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000423916 m3; GrossVolume: 0.000423916 m3

# IfcPlate: PLT3*348.1, PLATE
In: Undefined
Description: PLT3*348.1; Material: STEEL/450
Default - ASSEMBLY_POS: PL/40
Tekla Common - Bottom elevation: +4.777; Top elevation: +5.137; Phase: 1; Class: 11
Tekla Quantity - Weight: 3.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.3 m2; Height: 348.1 mm; Width: 3.3 mm; Length: 527.2 mm
Pset_PlateCommon - LoadBearing: no; Reference: PL/40
BaseQuantities - Width: 348.096 mm; NetArea: 0.287435 m2; GrossArea: 0.183505 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000423916 m3; GrossVolume: 0.000423916 m3

# IfcPlate: PLT3*355.5, PLATE
In: Undefined
Description: PLT3*355.5; Material: STEEL/450
Default - ASSEMBLY_POS: PL/21
Tekla Common - Bottom elevation: +6.646; Top elevation: +6.900; Phase: 1; Class: 11
Tekla Quantity - Weight: 2.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.7 m2; Net surface area: 0.2 m2; Height: 355.5 mm; Width: 3 mm; Length: 448.3 mm
