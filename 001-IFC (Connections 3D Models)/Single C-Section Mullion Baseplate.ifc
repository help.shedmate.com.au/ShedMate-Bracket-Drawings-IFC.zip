Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView_V2.0, QuantityTakeOffAddOnView], Option [BaseQuantities:On], Option [GridExport:On], Option [Assemblies:On], Option [Bolts:On], Option [Rebars:On], Option [PourObjects:Off], Option [Welds:Off], Option [SurfaceTreatments:Off], Option [LocationBy:0], Option [ViewColors:Off], Option [SectionedSpine:Off], Option [PropertySets:On], Option [Export all:Off]
File name: Single C-Section Mullion Baseplate.ifc
Time: 2026-02-19T14:38:48
Author: DESKTOP-BKNQL56\admin
Organization: Structural Designer
Written by: IFC Database Version: Work
Made in: Tekla Structures 2019 Service Pack 13, IFC Export Version: 4.0.0.0 Oct 18 2021

# IfcBuildingStorey, Undefined
In: Undefined
Elevation: 0 mm

# IfcColumn: C:100-19, MULLION
In: Undefined
Description: C:100-19; Material: STEEL/G450
Default - ASSEMBLY_POS: Z/82
Tekla Common - Bottom elevation: +0.000; Top elevation: +4.000; Phase: 1; Class: 2
Tekla Quantity - Weight: 12.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 141.7 m2; Net surface area: 1.8 m2; Height: 102 mm; Width: 51 mm; Length: 3999.7 mm
Pset_ColumnCommon - LoadBearing: no; Reference: Z/82
BaseQuantities - Length: 3999.71 mm; OuterSurfaceArea: 1.81912 m2; NetVolume: 0.00171291 m3; NetWeight: 13.4464 kg

# IfcColumn: C:150-24, MULLION
In: Undefined
Description: C:150-24; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Top elevation: +4.000; Phase: 1; Class: 2
Default - ASSEMBLY_POS: Z/83
Tekla Quantity - Weight: 22.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 111.2 m2; Net surface area: 2.5 m2; Height: 152 mm; Width: 64 mm; Length: 3999.7 mm
Pset_ColumnCommon - LoadBearing: no; Reference: Z/83
BaseQuantities - Length: 3999.71 mm; OuterSurfaceArea: 2.4797 m2; NetVolume: 0.00295083 m3; NetWeight: 23.164 kg

# IfcColumn: C:200-24, MULLION
In: Undefined
Description: C:200-24; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Top elevation: +4.000; Phase: 1; Class: 2
Default - ASSEMBLY_POS: Z/104
Tekla Quantity - Weight: 28.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 110 m2; Net surface area: 3.1 m2; Height: 203 mm; Width: 76 mm; Length: 3999.7 mm
Pset_ColumnCommon - LoadBearing: no; Reference: Z/104
BaseQuantities - Length: 3999.71 mm; OuterSurfaceArea: 3.12003 m2; NetVolume: 0.00371877 m3; NetWeight: 29.1923 kg

# IfcColumn: C:250-24, MULLION
In: Undefined
Description: C:250-24; Material: STEEL/G450
Default - ASSEMBLY_POS: Z/122
Tekla Common - Bottom elevation: +0.000; Top elevation: +5.000; Phase: 1; Class: 2
Tekla Quantity - Weight: 40.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 109.7 m2; Net surface area: 4.4 m2; Height: 254 mm; Width: 76 mm; Length: 4999.6 mm
Pset_ColumnCommon - LoadBearing: no; Reference: Z/122
BaseQuantities - Length: 4999.61 mm; OuterSurfaceArea: 4.39975 m2; NetVolume: 0.00524839 m3; NetWeight: 41.1998 kg

# IfcElementAssembly (8)
In: Undefined
PredefinedType: RIGID_FRAME
Tekla Assembly - Assembly/Cast unit bottom elevation: +0.000
Name | ASSEMBLY_POSITION_CODE = Assembly/Cast unit position code | ASSEMBLY_POS = Assembly/Cast unit Mark | Assembly/Cast unit weight (kg) | Assembly/Cast unit top elevation | Width (mm)
MULLION BASE BRACKET | C250SD/<1 | PL/167 | 0.5 | +0.050 | 50
MULLION BASE BRACKET | C200SD/<1 | PL/166 | 0.5 | +0.050 | 50
MULLION BASE BRACKET | C150SD/<1 | PL/165 | 0.3 | +0.050 | 50
MULLION BASE BRACKET | C100SD/<1 | PL/164 | 0.2 | +0.050 | 45
MULLION | C100SD/<1 | Z/82 | 12.8 | +4.000 | 51
MULLION | C250SD/<1 | Z/122 | 40.1 | +5.000 | 76
MULLION | C200SD/<1 | Z/104 | 28.4 | +4.000 | 76
MULLION | C150SD/<1 | Z/83 | 22.3 | +4.000 | 64

# IfcMechanicalFastener: Bolt assembly (4)
In: Undefined
NominalDiameter: 12 mm; NominalLength: 60 mm; Material: DynaBolt
Tekla Bolt - Washer count: 18; Washer diameter: 12 mm; Washer type: HARD; Washer name: WASHERM12-HARD; Nut count: 2; Nut type: 8.8-HEX; Nut name: NUTM12-8.8-HEX; Slotted hole y: 0 mm; Slotted hole x: 0 mm; Bolt hole diameter: 14 mm; Location: Site; Bolt count: 2; Bolt size: 12 mm; Bolt length: 60 mm; Bolt standard: DynaBolt; Bolt Name: BOLTM12*60

# IfcPlate: PLT3*80, MULLION BASE BRACKET
In: Undefined
Description: PLT3*80; Material: STEEL/450
Tekla Common - Bottom elevation: +0.000; Top elevation: +0.050; Phase: 1; Class: 5
Default - ASSEMBLY_POS: PL/164
Tekla Quantity - Weight: 0.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 91.5 m2; Net surface area: 0 m2; Height: 80 mm; Width: 3 mm; Length: 87.5 mm
Pset_PlateCommon - LoadBearing: no; Reference: PL/164
BaseQuantities - Width: 80 mm; NetArea: 0.015359 m2; GrossArea: 0.00699982 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.0000213771 m3; GrossVolume: 0.0000213771 m3

# IfcPlate: PLT3*92.5 (3)
In: Undefined
Description: PLT3*92.5; Material: STEEL/450
Tekla Common - Bottom elevation: +0.000; Top elevation: +0.050; Phase: 1; Class: 5
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0 m2; Height: 92.5 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 92.4978 mm; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Weight (kg) | Area per tons (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
MULLION BASE BRACKET | PL/167 | 0.5 | 89.3 | 220 | 0.043532 | 0.0203495 | 0.0000620869
MULLION BASE BRACKET | PL/166 | 0.5 | 89.7 | 170 | 0.0337667 | 0.0157246 | 0.0000479762
MULLION BASE BRACKET | PL/165 | 0.3 | 90.3 | 120 | 0.0240013 | 0.0110997 | 0.0000338656
