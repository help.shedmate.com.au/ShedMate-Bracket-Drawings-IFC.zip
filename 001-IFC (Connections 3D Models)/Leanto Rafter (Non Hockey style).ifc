Properties of the parts of a building model (IFC2X3), part 2 of 2

# IfcPlate: PLT3*250.9 (2)
In: Undefined
Description: PLT3*250.9; Material: STEEL/450
Tekla Common - Bottom elevation: +2.330; Top elevation: +2.678; Phase: 1; Class: 11
Tekla Quantity - Weight: 3.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.5 m2; Net surface area: 0.3 m2; Height: 250.9 mm; Width: 3 mm; Length: 686.9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 250.92 mm; NetArea: 0.313095 m2; GrossArea: 0.172357 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000461145 m3; GrossVolume: 0.000461145 m3
Name | ASSEMBLY_POS = Reference
LEANTO BRACKET | PL/303
LEANTO BRACKET | PL/297

# IfcPlate: PLT3*254 (12)
In: Undefined
Description: PLT3*254; Material: STEEL/450
Tekla Common - Phase: 1; Class: 9
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.2 m2; Height: 254 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 254 mm; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
LEANTO COLUMN STIFFIN | Z/1973 | +2.383 | +2.733 | 2.1 | 86.6 | 350 | 0.181424 | 0.0889 | 0.0002667
LEANTO COLUMN STIFFIN | Z/1966 | +2.434 | +2.734 | 1.8 | 86.8 | 300 | 0.155724 | 0.0762 | 0.0002286
2 x LEANTO COLUMN STIFFIN | PL/244 | +2.383 | +2.733 | 2.1 | 86.6 | 350 | 0.181424 | 0.0889 | 0.0002667
2 x LEANTO COLUMN STIFFIN | PL/238 | +2.434 | +2.734 | 1.8 | 86.8 | 300 | 0.155724 | 0.0762 | 0.0002286
LEANTO COLUMN STIFFIN | Z/473 | +2.383 | +2.733 | 2.1 | 86.6 | 350 | 0.181424 | 0.0889 | 0.0002667
LEANTO COLUMN STIFFIN | Z/472 | +2.434 | +2.734 | 1.8 | 86.8 | 300 | 0.155724 | 0.0762 | 0.0002286
LEANTO COLUMN STIFFIN | Z/473 | +2.388 | +2.738 | 2.1 | 86.6 | 350 | 0.181424 | 0.0889 | 0.0002667
LEANTO COLUMN STIFFIN | Z/472 | +2.440 | +2.740 | 1.8 | 86.8 | 300 | 0.155724 | 0.0762 | 0.0002286
LEANTO COLUMN STIFFIN | PL/244 | +2.388 | +2.738 | 2.1 | 86.6 | 350 | 0.181424 | 0.0889 | 0.0002667
LEANTO COLUMN STIFFIN | PL/238 | +2.440 | +2.740 | 1.8 | 86.8 | 300 | 0.155724 | 0.0762 | 0.0002286

# IfcPlate: PLT3*283.7 (2)
In: Undefined
Description: PLT3*283.7; Material: STEEL/450
Tekla Common - Bottom elevation: +2.368; Top elevation: +2.682; Phase: 1; Class: 11
Tekla Quantity - Weight: 4.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.3 m2; Height: 283.7 mm; Width: 3 mm; Length: 732.9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 283.688 mm; NetArea: 0.413649 m2; GrossArea: 0.207919 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000610918 m3; GrossVolume: 0.000610918 m3
Name | ASSEMBLY_POS = Reference
LEANTO BRACKET | PL/268
LEANTO BRACKET | PL/242

# IfcPlate: PLT3*284.7 (2)
In: Undefined
Description: PLT3*284.7; Material: STEEL/450
Tekla Common - Bottom elevation: +2.366; Top elevation: +2.681; Phase: 1; Class: 11
Tekla Quantity - Weight: 4.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.2 m2; Net surface area: 0.3 m2; Height: 284.7 mm; Width: 3 mm; Length: 752.4 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 284.704 mm; NetArea: 0.424703 m2; GrossArea: 0.214208 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000627322 m3; GrossVolume: 0.000627322 m3
Name | ASSEMBLY_POS = Reference
LEANTO BRACKET | PL/276
LEANTO BRACKET | PL/241

# IfcPlate: PLT3*286.1 (2)
In: Undefined
Description: PLT3*286.1; Material: STEEL/450
Tekla Common - Bottom elevation: +2.339; Top elevation: +2.677; Phase: 1; Class: 11
Tekla Quantity - Weight: 4.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.3 m2; Height: 286.1 mm; Width: 3 mm; Length: 743.5 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 286.146 mm; NetArea: 0.41702 m2; GrossArea: 0.212741 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000615918 m3; GrossVolume: 0.000615918 m3
Name | ASSEMBLY_POS = Reference
LEANTO BRACKET | PL/269
LEANTO BRACKET | PL/257

# IfcPlate: PLT3*287.8 (2)
In: Undefined
Description: PLT3*287.8; Material: STEEL/450
Tekla Common - Bottom elevation: +2.337; Top elevation: +2.674; Phase: 1; Class: 11
Tekla Quantity - Weight: 5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.2 m2; Net surface area: 0.3 m2; Height: 287.8 mm; Width: 3 mm; Length: 762.9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 287.844 mm; NetArea: 0.428097 m2; GrossArea: 0.219594 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000632358 m3; GrossVolume: 0.000632358 m3
Name | ASSEMBLY_POS = Reference
LEANTO BRACKET | PL/277
LEANTO BRACKET | PL/256

# IfcPlate: PLT3*294.7 (2)
In: Undefined
Description: PLT3*294.7; Material: STEEL/450
Tekla Common - Bottom elevation: +2.261; Top elevation: +2.683; Phase: 1; Class: 11
Tekla Quantity - Weight: 5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.2 m2; Net surface area: 0.3 m2; Height: 294.7 mm; Width: 3 mm; Length: 782.7 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 294.66 mm; NetArea: 0.430602 m2; GrossArea: 0.230621 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000636056 m3; GrossVolume: 0.000636056 m3
Name | ASSEMBLY_POS = Reference
LEANTO BRACKET | PL/293
LEANTO BRACKET | PL/292

# IfcPlate: PLT3*298.7 (2)
In: Undefined
Description: PLT3*298.7; Material: STEEL/450
Tekla Common - Bottom elevation: +2.258; Top elevation: +2.681; Phase: 1; Class: 11
Tekla Quantity - Weight: 5.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.2 m2; Net surface area: 0.3 m2; Height: 298.7 mm; Width: 3 mm; Length: 801.7 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 298.712 mm; NetArea: 0.441887 m2; GrossArea: 0.239492 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000652808 m3; GrossVolume: 0.000652808 m3
Name | ASSEMBLY_POS = Reference
LEANTO BRACKET | PL/301
LEANTO BRACKET | PL/298

# IfcPlate: PLT3*300 (24)
In: Undefined
Description: PLT3*300; Material: STEEL/450
Tekla Common - Phase: 1; Class: 9
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.2 m2; Height: 300 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 300 mm; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
LEANTO COLUMN STIFFIN | Z/1994 | +2.430 | +2.730 | 2.5 | 86.5 | 350 | 0.2139 | 0.105 | 0.000315
LEANTO COLUMN STIFFIN | Z/1976 | +2.432 | +2.732 | 2.1 | 86.6 | 300 | 0.1836 | 0.09 | 0.00027
LEANTO COLUMN STIFFIN | Z/1977 | +2.381 | +2.731 | 2.5 | 86.5 | 350 | 0.2139 | 0.105 | 0.000315
LEANTO COLUMN STIFFIN | Z/1993 | +2.335 | +2.735 | 2.8 | 86.3 | 400 | 0.2442 | 0.12 | 0.00036
2 x LEANTO COLUMN STIFFIN | PL/226 | +2.430 | +2.730 | 2.5 | 86.5 | 350 | 0.2139 | 0.105 | 0.000315
2 x LEANTO COLUMN STIFFIN | PL/233 | +2.432 | +2.732 | 2.1 | 86.6 | 300 | 0.1836 | 0.09 | 0.00027
2 x LEANTO COLUMN STIFFIN | PL/240 | +2.381 | +2.731 | 2.5 | 86.5 | 350 | 0.2139 | 0.105 | 0.000315
2 x LEANTO COLUMN STIFFIN | PL/246 | +2.335 | +2.735 | 2.8 | 86.3 | 400 | 0.2442 | 0.12 | 0.00036
LEANTO COLUMN STIFFIN | Z/489 | +2.430 | +2.730 | 2.5 | 86.5 | 350 | 0.2139 | 0.105 | 0.000315
LEANTO COLUMN STIFFIN | Z/489 | +2.437 | +2.737 | 2.5 | 86.5 | 350 | 0.2139 | 0.105 | 0.000315
LEANTO COLUMN STIFFIN | Z/480 | +2.432 | +2.732 | 2.1 | 86.6 | 300 | 0.1836 | 0.09 | 0.00027
LEANTO COLUMN STIFFIN | Z/481 | +2.381 | +2.731 | 2.5 | 86.5 | 350 | 0.2139 | 0.105 | 0.000315
LEANTO COLUMN STIFFIN | Z/482 | +2.335 | +2.735 | 2.8 | 86.3 | 400 | 0.2442 | 0.12 | 0.00036
LEANTO COLUMN STIFFIN | Z/480 | +2.438 | +2.738 | 2.1 | 86.6 | 300 | 0.1836 | 0.09 | 0.00027
LEANTO COLUMN STIFFIN | Z/481 | +2.387 | +2.737 | 2.5 | 86.5 | 350 | 0.2139 | 0.105 | 0.000315
LEANTO COLUMN STIFFIN | Z/482 | +2.341 | +2.741 | 2.8 | 86.3 | 400 | 0.2442 | 0.12 | 0.00036
LEANTO COLUMN STIFFIN | PL/226 | +2.437 | +2.737 | 2.5 | 86.5 | 350 | 0.2139 | 0.105 | 0.000315
LEANTO COLUMN STIFFIN | PL/233 | +2.438 | +2.738 | 2.1 | 86.6 | 300 | 0.1836 | 0.09 | 0.00027
LEANTO COLUMN STIFFIN | PL/240 | +2.387 | +2.737 | 2.5 | 86.5 | 350 | 0.2139 | 0.105 | 0.000315
LEANTO COLUMN STIFFIN | PL/246 | +2.341 | +2.741 | 2.8 | 86.3 | 400 | 0.2442 | 0.12 | 0.00036

# IfcPlate: PLT3*334.5 (2)
In: Undefined
Description: PLT3*334.5; Material: STEEL/450
Tekla Common - Bottom elevation: +2.316; Top elevation: +2.681; Phase: 1; Class: 11
Tekla Quantity - Weight: 5.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.2 m2; Net surface area: 0.5 m2; Height: 334.5 mm; Width: 3 mm; Length: 750 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 334.454 mm; NetArea: 0.497291 m2; GrossArea: 0.250846 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.0007357 m3; GrossVolume: 0.0007357 m3
Name | ASSEMBLY_POS = Reference
LEANTO BRACKET | PL/274
LEANTO BRACKET | PL/247

# IfcPlate: PLT3*337.4 (2)
In: Undefined
Description: PLT3*337.4; Material: STEEL/450
Tekla Common - Bottom elevation: +2.287; Top elevation: +2.674; Phase: 1; Class: 11
Tekla Quantity - Weight: 5.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.2 m2; Net surface area: 0.5 m2; Height: 337.4 mm; Width: 3 mm; Length: 762.3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 337.417 mm; NetArea: 0.501841 m2; GrossArea: 0.257211 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000742462 m3; GrossVolume: 0.000742462 m3
Name | ASSEMBLY_POS = Reference
LEANTO BRACKET | PL/275
LEANTO BRACKET | PL/259

# IfcPlate: PLT3*347.7 (2)
In: Undefined
Description: PLT3*347.7; Material: STEEL/450
Tekla Common - Bottom elevation: +2.208; Top elevation: +2.682; Phase: 1; Class: 11
Tekla Quantity - Weight: 6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.2 m2; Net surface area: 0.5 m2; Height: 347.7 mm; Width: 3 mm; Length: 807.5 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 347.681 mm; NetArea: 0.519907 m2; GrossArea: 0.280747 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000769294 m3; GrossVolume: 0.000769294 m3
Name | ASSEMBLY_POS = Reference
LEANTO BRACKET | PL/300
LEANTO BRACKET | PL/299

# IfcPlate: PLT3*350 (18)
In: Undefined
Description: PLT3*350; Material: STEEL/450
Tekla Common - Phase: 1; Class: 9
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 350 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 350 mm; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
LEANTO COLUMN STIFFIN | Z/1995 | +2.379 | +2.729 | 2.9 | 86.5 | 0.2 | 350 | 0.2492 | 0.1225 | 0.0003675
LEANTO COLUMN STIFFIN | Z/1996 | +2.333 | +2.733 | 3.3 | 86.3 | 0.3 | 400 | 0.2845 | 0.14 | 0.00042
LEANTO COLUMN STIFFIN | Z/2003 | +2.282 | +2.732 | 3.7 | 86.2 | 0.3 | 450 | 0.3198 | 0.1575 | 0.0004725
2 x LEANTO COLUMN STIFFIN | PL/239 | +2.379 | +2.729 | 2.9 | 86.3 | 0.2 | 350 | 0.2492 | 0.1225 | 0.0003675
2 x LEANTO COLUMN STIFFIN | PL/245 | +2.333 | +2.733 | 3.3 | 86.3 | 0.3 | 400 | 0.2845 | 0.14 | 0.00042
2 x LEANTO COLUMN STIFFIN | PL/248 | +2.282 | +2.732 | 3.7 | 86.2 | 0.3 | 450 | 0.3198 | 0.1575 | 0.0004725
LEANTO COLUMN STIFFIN | Z/490 | +2.379 | +2.729 | 2.9 | 86.3 | 0.2 | 350 | 0.2492 | 0.1225 | 0.0003675
LEANTO COLUMN STIFFIN | Z/491 | +2.333 | +2.733 | 3.3 | 86.3 | 0.3 | 400 | 0.2845 | 0.14 | 0.00042
LEANTO COLUMN STIFFIN | Z/492 | +2.282 | +2.732 | 3.7 | 86.2 | 0.3 | 450 | 0.3198 | 0.1575 | 0.0004725
LEANTO COLUMN STIFFIN | Z/490 | +2.386 | +2.736 | 2.9 | 86.3 | 0.2 | 350 | 0.2492 | 0.1225 | 0.0003675
LEANTO COLUMN STIFFIN | Z/491 | +2.340 | +2.740 | 3.3 | 86.3 | 0.3 | 400 | 0.2845 | 0.14 | 0.00042
LEANTO COLUMN STIFFIN | Z/492 | +2.290 | +2.740 | 3.7 | 86.2 | 0.3 | 450 | 0.3198 | 0.1575 | 0.0004725
LEANTO COLUMN STIFFIN | PL/239 | +2.386 | +2.736 | 2.9 | 86.3 | 0.2 | 350 | 0.2492 | 0.1225 | 0.0003675
LEANTO COLUMN STIFFIN | PL/245 | +2.340 | +2.740 | 3.3 | 86.3 | 0.3 | 400 | 0.2845 | 0.14 | 0.00042
LEANTO COLUMN STIFFIN | PL/248 | +2.290 | +2.740 | 3.7 | 86.2 | 0.3 | 450 | 0.3198 | 0.1575 | 0.0004725
