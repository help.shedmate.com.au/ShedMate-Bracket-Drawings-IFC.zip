Properties of the parts of a building model (IFC2X3), part 1 of 2

# File
Description: ViewDefinition[CoordinationView_V2.0, QuantityTakeOffAddOnView], Option [BaseQuantities:On], Option [GridExport:On], Option [Assemblies:On], Option [Bolts:On], Option [Rebars:On], Option [PourObjects:Off], Option [Welds:Off], Option [SurfaceTreatments:Off], Option [LocationBy:0], Option [ViewColors:Off], Option [SectionedSpine:Off], Option [PropertySets:On], Option [Export all:Off]
File name: Leanto Rafter (Non Hockey style).ifc
Time: 2026-04-20T14:00:56
Author: DESKTOP-BKNQL56\admin
Organization: Structural Designer
Written by: IFC Database Version: Work
Made in: Tekla Structures 2019 Service Pack 13, IFC Export Version: 4.0.0.0 Oct 18 2021

# IfcBuildingStorey, Undefined
In: Undefined
Elevation: 0 mm

# IfcBeam: C:150-24 (21)
In: Undefined
Description: C:150-24; Material: STEEL/G450
Tekla Common - Phase: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 152 mm; Width: 64 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Finish | Bottom elevation | Top elevation | Class | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x RAFTER | R/30 | 12 deg | +2.359 | +2.654 | 10 | 3.9 | 111.5 | 0.3 | 706 | 706.05 | 0.438944 | 0.000520895 | 4.08903
2 x RAFTER | R/28 | 12 deg | +2.356 | +2.657 | 10 | 4.1 | 111.5 | 0.5 | 731.7 | 731.65 | 0.454806 | 0.000539782 | 4.23729
2 x RAFTER | R/27 | 12 deg | +2.353 | +2.659 | 10 | 4.1 | 111.5 | 0.5 | 757.2 | 757.24 | 0.470661 | 0.000558661 | 4.38549
COLUMN | Z/502 | 5 deg | +0.000 | +3.500 | 12 | 19.5 | 111.2 | 2.2 | 3500 | 3500 | 2.17008 | 0.00258216 | 20.27
2 x RAFTER | R/16 | 5 deg | +2.461 | +2.675 | 10 | 3.9 | 111.5 | 0.3 | 708.6 | 708.64 | 0.440549 | 0.000522806 | 4.10403
2 x RAFTER | R/3 | 3 deg | +2.496 | +2.685 | 10 | 3.9 | 111.5 | 0.3 | 714.7 | 714.65 | 0.444273 | 0.00052724 | 4.13884
2 x RAFTER | R/17 | 5 deg | +2.461 | +2.677 | 10 | 4.1 | 111.5 | 0.5 | 734.2 | 734.24 | 0.456411 | 0.000541693 | 4.25229
2 x RAFTER | R/4 | 3 deg | +2.496 | +2.686 | 10 | 4.1 | 111.5 | 0.5 | 740.2 | 740.19 | 0.460097 | 0.000546083 | 4.28675
2 x RAFTER | R/18 | 5 deg | +2.461 | +2.679 | 10 | 4.1 | 111.5 | 0.5 | 759.8 | 759.84 | 0.472272 | 0.00056058 | 4.40055
COLUMN | Z/464 | 5 deg | +0.000 | +3.500 | 12 | 19.5 | 111.2 | 2.2 | 3500 | 3500 | 2.17008 | 0.00258216 | 20.27
2 x RAFTER | R/5 | 3 deg | +2.496 | +2.688 | 10 | 4.3 | 111.5 | 0.5 | 765.7 | 765.72 | 0.475916 | 0.000564918 | 4.4346
COLUMN | Z/463 | 3 deg | +0.000 | +3.500 | 12 | 19.5 | 111.2 | 2.2 | 3500 | 3500 | 2.17008 | 0.00258216 | 20.27

# IfcBeam: C:200-24 (30)
In: Undefined
Description: C:200-24; Material: STEEL/G450
Tekla Common - Phase: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 203 mm; Width: 76 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Finish | Bottom elevation | Top elevation | Class | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x RAFTER | R/36 | 12 deg | +2.314 | +2.649 | 10 | 4.6 | 110.4 | 0.5 | 653.4 | 653.41 | 0.511258 | 0.000607515 | 4.76899
2 x RAFTER | R/33 | 12 deg | +2.311 | +2.651 | 10 | 4.8 | 110.4 | 0.5 | 680.5 | 680.51 | 0.532385 | 0.000632711 | 4.96678
2 x RAFTER | R/31 | 12 deg | +2.309 | +2.653 | 10 | 5 | 110.4 | 0.5 | 701.6 | 701.59 | 0.548819 | 0.00065231 | 5.12064
2 x RAFTER | R/29 | 12 deg | +2.306 | +2.655 | 10 | 5.1 | 110.4 | 0.7 | 727.2 | 727.19 | 0.568777 | 0.000676112 | 5.30748
COLUMN | Z/506 | 5 deg | +0.000 | +3.500 | 12 | 24.8 | 110.1 | 2.7 | 3500 | 3500 | 2.73046 | 0.00325416 | 25.5452
COLUMN | Z/505 | 5 deg | +0.000 | +3.500 | 12 | 24.8 | 110.1 | 2.7 | 3500 | 3500 | 2.73046 | 0.00325416 | 25.5452
2 x RAFTER | R/14 | 5 deg | +2.411 | +2.670 | 10 | 4.6 | 110.4 | 0.5 | 656 | 656 | 0.513277 | 0.000609923 | 4.78789
2 x RAFTER | R/1 | 3 deg | +2.445 | +2.682 | 10 | 4.6 | 110.4 | 0.5 | 663.9 | 663.92 | 0.519452 | 0.000617286 | 4.8457
2 x RAFTER | R/15 | 5 deg | +2.411 | +2.672 | 10 | 4.8 | 110.4 | 0.5 | 683.1 | 683.1 | 0.534404 | 0.000635119 | 4.98568
2 x RAFTER | R/2 | 3 deg | +2.445 | +2.684 | 10 | 4.8 | 110.4 | 0.5 | 691 | 690.95 | 0.540524 | 0.000642418 | 5.04298
2 x RAFTER | R/21 | 5 deg | +2.411 | +2.674 | 10 | 5 | 110.4 | 0.7 | 704.2 | 704.18 | 0.550838 | 0.000654718 | 5.13954
2 x RAFTER | R/8 | 3 deg | +2.445 | +2.685 | 10 | 5 | 110.4 | 0.7 | 712 | 711.98 | 0.556919 | 0.000661971 | 5.19647
2 x RAFTER | R/22 | 5 deg | +2.411 | +2.676 | 10 | 5.1 | 110.4 | 0.7 | 729.8 | 729.78 | 0.570796 | 0.00067852 | 5.32638
COLUMN | Z/470 | 5 deg | +0.000 | +3.500 | 12 | 24.8 | 110.1 | 2.7 | 3500 | 3500 | 2.73046 | 0.00325416 | 25.5452
COLUMN | Z/469 | 5 deg | +0.000 | +3.500 | 12 | 24.8 | 110.1 | 2.7 | 3500 | 3500 | 2.73046 | 0.00325416 | 25.5452
2 x RAFTER | R/9 | 3 deg | +2.445 | +2.686 | 10 | 5.1 | 110.4 | 0.7 | 737.5 | 737.52 | 0.57683 | 0.000685717 | 5.38288
COLUMN | Z/468 | 3 deg | +0.000 | +3.500 | 12 | 24.8 | 110.1 | 2.7 | 3500 | 3500 | 2.73046 | 0.00325416 | 25.5452
COLUMN | Z/467 | 3 deg | +0.000 | +3.500 | 12 | 24.8 | 110.1 | 2.7 | 3500 | 3500 | 2.73046 | 0.00325416 | 25.5452

# IfcBeam: C:250-24 (27)
In: Undefined
Description: C:250-24; Material: STEEL/G450
Tekla Common - Phase: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 254 mm; Width: 76 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Finish | Bottom elevation | Top elevation | Class | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x RAFTER | R/37 | 12 deg | +2.264 | +2.631 | 10 | 4.6 | 110.1 | 0.5 | 567.2 | 567.16 | 0.500973 | 0.000595382 | 4.67375
2 x RAFTER | R/34 | 12 deg | +2.261 | +2.633 | 10 | 4.8 | 110.1 | 0.5 | 594.3 | 594.26 | 0.524811 | 0.00062383 | 4.89707
2 x RAFTER | R/32 | 12 deg | +2.258 | +2.635 | 10 | 4.8 | 110.1 | 0.5 | 615.3 | 615.34 | 0.543353 | 0.000645959 | 5.07078
COLUMN | Z/512 | 5 deg | +0.000 | +3.500 | 12 | 28.1 | 109.7 | 3.1 | 3500 | 3500 | 3.0807 | 0.00367416 | 28.8422
COLUMN | Z/511 | 5 deg | +0.000 | +3.500 | 12 | 28.1 | 109.7 | 3.1 | 3500 | 3500 | 3.0807 | 0.00367416 | 28.8422
COLUMN | Z/510 | 5 deg | +0.000 | +3.500 | 12 | 28.1 | 109.7 | 3.1 | 3500 | 3500 | 3.0807 | 0.00367416 | 28.8422
2 x RAFTER | R/19 | 5 deg | +2.360 | +2.663 | 10 | 4.6 | 110.1 | 0.5 | 571.2 | 571.23 | 0.504553 | 0.000599654 | 4.70729
2 x RAFTER | R/6 | 3 deg | +2.394 | +2.678 | 10 | 4.6 | 110.1 | 0.5 | 581.1 | 581.13 | 0.513261 | 0.000610047 | 4.78887
2 x RAFTER | R/20 | 5 deg | +2.360 | +2.665 | 10 | 4.8 | 110.1 | 0.5 | 598.3 | 598.33 | 0.528391 | 0.000628103 | 4.93061
2 x RAFTER | R/7 | 3 deg | +2.394 | +2.679 | 10 | 4.8 | 110.1 | 0.5 | 608.2 | 608.17 | 0.537046 | 0.000638433 | 5.0117
2 x RAFTER | R/25 | 5 deg | +2.360 | +2.667 | 10 | 5 | 110.1 | 0.5 | 619.4 | 619.41 | 0.546933 | 0.000650232 | 5.10432
COLUMN | Z/479 | 5 deg | +0.000 | +3.500 | 12 | 28.1 | 109.7 | 3.1 | 3500 | 3500 | 3.0807 | 0.00367416 | 28.8422
COLUMN | Z/478 | 5 deg | +0.000 | +3.500 | 12 | 28.1 | 109.7 | 3.1 | 3500 | 3500 | 3.0807 | 0.00367416 | 28.8422
COLUMN | Z/477 | 5 deg | +0.000 | +3.500 | 12 | 28.1 | 109.7 | 3.1 | 3500 | 3500 | 3.0807 | 0.00367416 | 28.8422
2 x RAFTER | R/12 | 3 deg | +2.394 | +2.681 | 10 | 5 | 110.1 | 0.7 | 629.2 | 629.2 | 0.555544 | 0.000660509 | 5.185
COLUMN | Z/476 | 3 deg | +0.000 | +3.500 | 12 | 28.1 | 109.7 | 3.1 | 3500 | 3500 | 3.0807 | 0.00367416 | 28.8422
COLUMN | Z/475 | 3 deg | +0.000 | +3.500 | 12 | 28.1 | 109.7 | 3.1 | 3500 | 3500 | 3.0807 | 0.00367416 | 28.8422
COLUMN | Z/474 | 3 deg | +0.000 | +3.500 | 12 | 28.1 | 109.7 | 3.1 | 3500 | 3500 | 3.0807 | 0.00367416 | 28.8422

# IfcBeam: C:300-30 (21)
In: Undefined
Description: C:300-30; Material: STEEL/G450
Tekla Common - Phase: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 300 mm; Width: 96 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Finish | Bottom elevation | Top elevation | Class | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x RAFTER | R/38 | 12 deg | +2.219 | +2.629 | 10 | 7 | 87.8 | 0.7 | 563.1 | 563.13 | 0.618196 | 0.000917339 | 7.20111
2 x RAFTER | R/35 | 12 deg | +2.216 | +2.632 | 10 | 7.4 | 87.8 | 0.7 | 590.2 | 590.24 | 0.6478 | 0.000961501 | 7.54778
COLUMN | Z/518 | 5 deg | +0.000 | +3.500 | 12 | 43.8 | 87.5 | 3.8 | 3500 | 3500 | 3.82526 | 0.0057015 | 44.7568
COLUMN | Z/517 | 5 deg | +0.000 | +3.500 | 12 | 43.8 | 87.5 | 3.8 | 3500 | 3500 | 3.82526 | 0.0057015 | 44.7568
COLUMN | Z/516 | 5 deg | +0.000 | +3.500 | 12 | 43.8 | 87.5 | 3.8 | 3500 | 3500 | 3.82526 | 0.0057015 | 44.7568
2 x RAFTER | R/23 | 5 deg | +2.314 | +2.662 | 10 | 7.1 | 87.8 | 0.7 | 567.2 | 567.21 | 0.622651 | 0.000923985 | 7.25328
2 x RAFTER | R/10 | 3 deg | +2.348 | +2.678 | 10 | 7.1 | 87.8 | 0.7 | 578.7 | 578.72 | 0.63522 | 0.000942735 | 7.40047
2 x RAFTER | R/24 | 5 deg | +2.314 | +2.665 | 10 | 7.4 | 87.8 | 0.7 | 594.3 | 594.31 | 0.652245 | 0.000968131 | 7.59983
COLUMN | Z/488 | 5 deg | +0.000 | +3.500 | 12 | 43.8 | 87.5 | 3.8 | 3500 | 3500 | 3.82526 | 0.0057015 | 44.7568
COLUMN | Z/487 | 5 deg | +0.000 | +3.500 | 12 | 43.8 | 87.5 | 3.8 | 3500 | 3500 | 3.82526 | 0.0057015 | 44.7568
COLUMN | Z/486 | 5 deg | +0.000 | +3.500 | 12 | 43.8 | 87.5 | 3.8 | 3500 | 3500 | 3.82526 | 0.0057015 | 44.7568
2 x RAFTER | R/11 | 3 deg | +2.348 | +2.679 | 10 | 7.6 | 87.8 | 0.7 | 605.8 | 605.76 | 0.664748 | 0.000986783 | 7.74625
COLUMN | Z/485 | 3 deg | +0.000 | +3.500 | 12 | 43.8 | 87.5 | 3.8 | 3500 | 3500 | 3.82526 | 0.0057015 | 44.7568
COLUMN | Z/484 | 3 deg | +0.000 | +3.500 | 12 | 43.8 | 87.5 | 3.8 | 3500 | 3500 | 3.82526 | 0.0057015 | 44.7568
COLUMN | Z/483 | 3 deg | +0.000 | +3.500 | 12 | 43.8 | 87.5 | 3.8 | 3500 | 3500 | 3.82526 | 0.0057015 | 44.7568

# IfcBeam: C:350-30 (18)
In: Undefined
Description: C:350-30; Material: STEEL/G450
Tekla Common - Phase: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 350 mm; Width: 125 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Finish | Bottom elevation | Top elevation | Class | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x RAFTER | R/39 | 12 deg | +2.170 | +2.628 | 10 | 8.4 | 87.5 | 0.7 | 558.8 | 558.76 | 0.731394 | 0.00108623 | 8.5269
COLUMN | Z/526 | 5 deg | +0.000 | +3.500 | 12 | 52.3 | 87.1 | 4.6 | 3500 | 3500 | 4.56089 | 0.006804 | 53.4114
COLUMN | Z/525 | 5 deg | +0.000 | +3.500 | 12 | 52.3 | 87.1 | 4.6 | 3500 | 3500 | 4.56089 | 0.006804 | 53.4114
COLUMN | Z/524 | 5 deg | +0.000 | +3.500 | 12 | 52.3 | 87.1 | 4.6 | 3500 | 3500 | 4.56089 | 0.006804 | 53.4114
COLUMN | Z/523 | 5 deg | +0.000 | +3.500 | 12 | 52.3 | 87.1 | 4.6 | 3500 | 3500 | 4.56089 | 0.006804 | 53.4114
2 x RAFTER | R/26 | 5 deg | +2.264 | +2.662 | 10 | 8.4 | 87.5 | 0.7 | 562.8 | 562.83 | 0.736693 | 0.00109414 | 8.58901
COLUMN | Z/500 | 5 deg | +0.000 | +3.500 | 12 | 52.3 | 87.1 | 4.6 | 3500 | 3500 | 4.56089 | 0.006804 | 53.4114
COLUMN | Z/499 | 5 deg | +0.000 | +3.500 | 12 | 52.3 | 87.1 | 4.6 | 3500 | 3500 | 4.56089 | 0.006804 | 53.4114
COLUMN | Z/498 | 5 deg | +0.000 | +3.500 | 12 | 52.3 | 87.1 | 4.6 | 3500 | 3500 | 4.56089 | 0.006804 | 53.4114
COLUMN | Z/497 | 5 deg | +0.000 | +3.500 | 12 | 52.3 | 87.1 | 4.6 | 3500 | 3500 | 4.56089 | 0.006804 | 53.4114
2 x RAFTER | R/13 | 3 deg | +2.298 | +2.678 | 10 | 8.6 | 87.5 | 0.7 | 576.1 | 576.1 | 0.75397 | 0.00111994 | 8.79152
COLUMN | Z/496 | 3 deg | +0.000 | +3.500 | 12 | 52.3 | 87.1 | 4.6 | 3500 | 3500 | 4.56089 | 0.006804 | 53.4114
COLUMN | Z/495 | 3 deg | +0.000 | +3.500 | 12 | 52.3 | 87.1 | 4.6 | 3500 | 3500 | 4.56089 | 0.006804 | 53.4114
COLUMN | Z/494 | 3 deg | +0.000 | +3.500 | 12 | 52.3 | 87.1 | 4.6 | 3500 | 3500 | 4.56089 | 0.006804 | 53.4114
COLUMN | Z/493 | 3 deg | +0.000 | +3.500 | 12 | 52.3 | 87.1 | 4.6 | 3500 | 3500 | 4.56089 | 0.006804 | 53.4114

# IfcBeam: TH:75-95 (78)
In: Undefined
Description: TH:75-95; Material: STEEL/300PLUS
Tekla Common - Phase: 1; Class: 4
Tekla Quantity - Weight: 1.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 0 m2; Net surface area: 0.5 m2; Height: 75 mm; Width: 125 mm; Length: 1000 mm
Pset_BeamCommon - LoadBearing: no
BaseQuantities - Length: 1000 mm; OuterSurfaceArea: 4.5602e-07 m2; NetVolume: 0.000231901 m3; NetWeight: 1.82042 kg
Name | ASSEMBLY_POS = Reference | Finish | Bottom elevation | Top elevation
2 x TH | B/23 | 12 deg | +2.540 | +2.631
4 x TH | B/23 | 12 deg | +2.541 | +2.631
2 x TH | B/23 | 12 deg | +2.542 | +2.632
6 x TH | B/23 | 12 deg | +2.538 | +2.628
2 x TH | B/23 | 12 deg | +2.535 | +2.625
4 x TH | B/23 | 12 deg | +2.536 | +2.626
4 x TH | B/23 | 12 deg | +2.533 | +2.623
2 x TH | B/23 | 12 deg | +2.530 | +2.620
26 x TH | B/21 | 5 deg | +2.625 | +2.707
26 x TH | B/20 | 3 deg | +2.657 | +2.737

# IfcColumn: C:150-24 (3)
In: Undefined
Description: C:150-24; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Top elevation: +3.500; Phase: 1; Class: 12
Tekla Quantity - Weight: 19.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 111.2 m2; Net surface area: 2.2 m2; Height: 152 mm; Width: 64 mm; Length: 3500 mm
BaseQuantities - Length: 3500 mm; OuterSurfaceArea: 2.17008 m2; NetVolume: 0.00258216 m3; NetWeight: 20.27 kg
Pset_ColumnCommon - LoadBearing: no
Name | Finish | ASSEMBLY_POS = Reference
COLUMN | 5 deg | Z/501
COLUMN | 5 deg | Z/449
COLUMN | 3 deg | Z/434

# IfcColumn: C:200-24 (6)
In: Undefined
Description: C:200-24; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Top elevation: +3.500; Phase: 1; Class: 12
Tekla Quantity - Weight: 24.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 110.1 m2; Net surface area: 2.7 m2; Height: 203 mm; Width: 76 mm; Length: 3500 mm
BaseQuantities - Length: 3500 mm; OuterSurfaceArea: 2.73046 m2; NetVolume: 0.00325416 m3; NetWeight: 25.5452 kg
Pset_ColumnCommon - LoadBearing: no
Name | Finish | ASSEMBLY_POS = Reference
COLUMN | 5 deg | Z/504
COLUMN | 5 deg | Z/503
COLUMN | 5 deg | Z/454
COLUMN | 5 deg | Z/450
COLUMN | 3 deg | Z/441
COLUMN | 3 deg | Z/435

# IfcColumn: C:250-24 (9)
In: Undefined
Description: C:250-24; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Top elevation: +3.500; Phase: 1; Class: 12
Tekla Quantity - Weight: 28.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 109.7 m2; Net surface area: 3.1 m2; Height: 254 mm; Width: 76 mm; Length: 3500 mm
BaseQuantities - Length: 3500 mm; OuterSurfaceArea: 3.0807 m2; NetVolume: 0.00367416 m3; NetWeight: 28.8422 kg
Pset_ColumnCommon - LoadBearing: no
Name | Finish | ASSEMBLY_POS = Reference
COLUMN | 5 deg | Z/509
COLUMN | 5 deg | Z/508
COLUMN | 5 deg | Z/507
COLUMN | 5 deg | Z/458
COLUMN | 5 deg | Z/455
COLUMN | 5 deg | Z/451
COLUMN | 3 deg | Z/445
COLUMN | 3 deg | Z/442
COLUMN | 3 deg | Z/437

# IfcColumn: C:300-30 (9)
In: Undefined
Description: C:300-30; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Top elevation: +3.500; Phase: 1; Class: 12
Tekla Quantity - Weight: 43.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.5 m2; Net surface area: 3.8 m2; Height: 300 mm; Width: 96 mm; Length: 3500 mm
BaseQuantities - Length: 3500 mm; OuterSurfaceArea: 3.82526 m2; NetVolume: 0.0057015 m3; NetWeight: 44.7568 kg
Pset_ColumnCommon - LoadBearing: no
Name | Finish | ASSEMBLY_POS = Reference
COLUMN | 5 deg | Z/515
COLUMN | 5 deg | Z/514
COLUMN | 5 deg | Z/513
COLUMN | 5 deg | Z/460
COLUMN | 5 deg | Z/457
COLUMN | 5 deg | Z/453
COLUMN | 3 deg | Z/447
COLUMN | 3 deg | Z/444
COLUMN | 3 deg | Z/440

# IfcColumn: C:350-30 (12)
In: Undefined
Description: C:350-30; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Top elevation: +3.500; Phase: 1; Class: 12
Tekla Quantity - Weight: 52.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.1 m2; Net surface area: 4.6 m2; Height: 350 mm; Width: 125 mm; Length: 3500 mm
BaseQuantities - Length: 3500 mm; OuterSurfaceArea: 4.56089 m2; NetVolume: 0.006804 m3; NetWeight: 53.4114 kg
Pset_ColumnCommon - LoadBearing: no
Name | Finish | ASSEMBLY_POS = Reference
COLUMN | 5 deg | Z/522
COLUMN | 5 deg | Z/521
COLUMN | 5 deg | Z/520
COLUMN | 5 deg | Z/519
COLUMN | 5 deg | Z/461
COLUMN | 5 deg | Z/459
COLUMN | 5 deg | Z/456
COLUMN | 5 deg | Z/452
COLUMN | 3 deg | Z/448
COLUMN | 3 deg | Z/446
COLUMN | 3 deg | Z/443
COLUMN | 3 deg | Z/439

# IfcElementAssembly (390)
In: Undefined
PredefinedType: RIGID_FRAME
Name | ASSEMBLY_POSITION_CODE = Assembly/Cast unit position code | ASSEMBLY_POS = Assembly/Cast unit Mark | Assembly/Cast unit weight (kg) | Assembly/Cast unit bottom elevation | Assembly/Cast unit top elevation | Width (mm)
LEANTO COLUMN STIFFIN | C350>/12deg | Z/1994 | 2.5 | +2.430 | +2.730 | 3
LEANTO COLUMN STIFFIN | C350>/12deg | Z/1995 | 2.9 | +2.379 | +2.729 | 3
LEANTO COLUMN STIFFIN | C350>/12deg | Z/1996 | 3.3 | +2.333 | +2.733 | 3
LEANTO COLUMN STIFFIN | C350>/12deg | Z/2003 | 3.7 | +2.282 | +2.732 | 3
COLUMN | C350>/12deg | Z/526 | 52.3 | +0.000 | +3.500 | 125
COLUMN | C350>/12deg | Z/525 | 52.3 | +0.000 | +3.500 | 125
COLUMN | C350>/12deg | Z/524 | 52.3 | +0.000 | +3.500 | 125
COLUMN | C350>/12deg | Z/523 | 52.3 | +0.000 | +3.500 | 125
RAFTER | C350>/12deg-12deg | R/39 | 8.4 | +2.170 | +2.628 | 125
RAFTER | C350>/12deg-12deg | R/38 | 7 | +2.219 | +2.629 | 96
RAFTER | C350>/12deg-12deg | R/37 | 4.6 | +2.264 | +2.631 | 76
RAFTER | C350>/X-12deg | R/36 | 4.6 | +2.314 | +2.649 | 76
LEANTO BRACKET | C350>/12deg-12deg | PL/300 | 6 | +2.208 | +2.682 | 89.5
LEANTO BRACKET | C350>/12deg-12deg | PL/301 | 5.1 | +2.258 | +2.681 | 94.5
LEANTO BRACKET | C350>/12deg-12deg | PL/303 | 3.6 | +2.330 | +2.678 | 105.1
LEANTO BRACKET | C350>/X-12deg | PL/302 | 2.1 | +2.416 | +2.677 | 105.1
2 x TH | C350>/12deg-12deg | B/23 | 1.8 | +2.540 | +2.631 | 125
4 x TH | C350>/12deg-12deg | B/23 | 1.8 | +2.541 | +2.631 | 125
2 x TH | C350>/X-12deg | B/23 | 1.8 | +2.542 | +2.632 | 125
LEANTO COLUMN STIFFIN | C300-C350/12deg | Z/1976 | 2.1 | +2.432 | +2.732 | 3
LEANTO COLUMN STIFFIN | C300-C350/12deg | Z/1977 | 2.5 | +2.381 | +2.731 | 3
LEANTO COLUMN STIFFIN | C300-C350/12deg | Z/1993 | 2.8 | +2.335 | +2.735 | 3
COLUMN | C300-C350/12deg | Z/518 | 43.8 | +0.000 | +3.500 | 96
COLUMN | C300-C350/12deg | Z/517 | 43.8 | +0.000 | +3.500 | 96
COLUMN | C300-C350/12deg | Z/516 | 43.8 | +0.000 | +3.500 | 96
RAFTER | C300-C350/12deg-12deg | R/35 | 7.4 | +2.216 | +2.632 | 96
RAFTER | C300-C350/12deg-12deg | R/34 | 4.8 | +2.261 | +2.633 | 76
RAFTER | C300-C350/X-12deg | R/33 | 4.8 | +2.311 | +2.651 | 76
LEANTO BRACKET | C300-C350/12deg-12deg | PL/293 | 5 | +2.261 | +2.683 | 75
LEANTO BRACKET | C300-C350/12deg-12deg | PL/295 | 3.5 | +2.333 | +2.680 | 75.6
LEANTO BRACKET | C300-C350/X-12deg | PL/294 | 2 | +2.418 | +2.680 | 75.6
4 x TH | C300-C350/12deg-12deg | B/23 | 1.8 | +2.538 | +2.628 | 125
2 x TH | C300-C350/X-12deg | B/23 | 1.8 | +2.538 | +2.628 | 125
LEANTO COLUMN STIFFIN | C250-C300/12deg | Z/1965 | 1.5 | +2.485 | +2.735 | 3
LEANTO COLUMN STIFFIN | C250-C300/12deg | Z/1973 | 2.1 | +2.383 | +2.733 | 3
LEANTO COLUMN STIFFIN | C250-C300/12deg | Z/1966 | 1.8 | +2.434 | +2.734 | 3
COLUMN | C250-C300/12deg | Z/512 | 28.1 | +0.000 | +3.500 | 76
COLUMN | C250-C300/12deg | Z/511 | 28.1 | +0.000 | +3.500 | 76
COLUMN | C250-C300/12deg | Z/510 | 28.1 | +0.000 | +3.500 | 76
RAFTER | C250-C300/12deg-12deg | R/32 | 4.8 | +2.258 | +2.635 | 76
RAFTER | C250-C300/12deg-12deg | R/31 | 5 | +2.309 | +2.653 | 76
RAFTER | C250-C300/X-12deg | R/30 | 3.9 | +2.359 | +2.654 | 64
LEANTO BRACKET | C250-C300/12deg-12deg | PL/289 | 3.5 | +2.335 | +2.682 | 65.6
LEANTO BRACKET | C250-C300/12deg-12deg | PL/286 | 2 | +2.420 | +2.682 | 65.6
LEANTO BRACKET | C250-C300/X-12deg | PL/287 | 1.5 | +2.471 | +2.681 | 65.6
2 x TH | C250-C300/12deg-12deg | B/23 | 1.8 | +2.535 | +2.625 | 125
2 x TH | C250-C300/12deg-12deg | B/23 | 1.8 | +2.536 | +2.626 | 125
2 x TH | C250-C300/X-12deg | B/23 | 1.8 | +2.536 | +2.626 | 125
LEANTO COLUMN STIFFIN | C200-C250/12deg | Z/1942 | 1.2 | +2.488 | +2.738 | 3
LEANTO COLUMN STIFFIN | C200-C250/12deg | Z/1964 | 1.5 | +2.436 | +2.736 | 3
COLUMN | C200-C250/12deg | Z/506 | 24.8 | +0.000 | +3.500 | 76
COLUMN | C200-C250/12deg | Z/505 | 24.8 | +0.000 | +3.500 | 76
RAFTER | C200-C250/12deg-12deg | R/29 | 5.1 | +2.306 | +2.655 | 76
RAFTER | C200-C250/X-12deg | R/28 | 4.1 | +2.356 | +2.657 | 64
LEANTO BRACKET | C200-C250/12deg-12deg | PL/286 | 2 | +2.422 | +2.684 | 65.6
LEANTO BRACKET | C200-C250/12deg | PL/287 | 1.5 | +2.473 | +2.683 | 65.6
2 x TH | C200-C250/12deg-12deg | B/23 | 1.8 | +2.533 | +2.623 | 125
2 x TH | C200-C250/X-12deg | B/23 | 1.8 | +2.533 | +2.623 | 125
LEANTO COLUMN STIFFIN | C150-C200/12deg | Z/1941 | 0.9 | +2.490 | +2.740 | 3
COLUMN | C150-C200/12deg | Z/502 | 19.5 | +0.000 | +3.500 | 64
RAFTER | C150-C200/X-12deg | R/27 | 4.1 | +2.353 | +2.659 | 64
LEANTO BRACKET | C150-C200/12deg | PL/283 | 1.5 | +2.475 | +2.686 | 59.6
2 x TH | C150-C200/X-12deg | B/23 | 1.8 | +2.530 | +2.620 | 125
LEANTO COLUMN STIFFIN | C350/12deg | PL/226 | 2.5 | +2.430 | +2.730 | 3
LEANTO COLUMN STIFFIN | C350/12deg | PL/239 | 2.9 | +2.379 | +2.729 | 3
LEANTO COLUMN STIFFIN | C350/12deg | PL/245 | 3.3 | +2.333 | +2.733 | 3
LEANTO COLUMN STIFFIN | C300/12deg | PL/233 | 2.1 | +2.432 | +2.732 | 3
LEANTO COLUMN STIFFIN | C300/12deg | PL/240 | 2.5 | +2.381 | +2.731 | 3
LEANTO COLUMN STIFFIN | C250/12deg | PL/224 | 1.5 | +2.485 | +2.735 | 3
LEANTO COLUMN STIFFIN | C200/12deg | PL/213 | 1.2 | +2.488 | +2.738 | 3
LEANTO COLUMN STIFFIN | C350/12deg | PL/248 | 3.7 | +2.282 | +2.732 | 3
LEANTO COLUMN STIFFIN | C300/12deg | PL/246 | 2.8 | +2.335 | +2.735 | 3
LEANTO COLUMN STIFFIN | C250/12deg | PL/244 | 2.1 | +2.383 | +2.733 | 3
LEANTO COLUMN STIFFIN | C250/12deg | PL/238 | 1.8 | +2.434 | +2.734 | 3
LEANTO COLUMN STIFFIN | C200/12deg | PL/237 | 1.5 | +2.436 | +2.736 | 3
LEANTO COLUMN STIFFIN | C150/12deg | PL/210 | 0.9 | +2.490 | +2.740 | 3
COLUMN | C350/12deg | Z/522 | 52.3 | +0.000 | +3.500 | 125
COLUMN | C350/12deg | Z/521 | 52.3 | +0.000 | +3.500 | 125
COLUMN | C350/12deg | Z/520 | 52.3 | +0.000 | +3.500 | 125
COLUMN | C350/12deg | Z/519 | 52.3 | +0.000 | +3.500 | 125
COLUMN | C300/12deg | Z/515 | 43.8 | +0.000 | +3.500 | 96
COLUMN | C300/12deg | Z/514 | 43.8 | +0.000 | +3.500 | 96
COLUMN | C300/12deg | Z/513 | 43.8 | +0.000 | +3.500 | 96
COLUMN | C250/12deg | Z/509 | 28.1 | +0.000 | +3.500 | 76
COLUMN | C250/12deg | Z/508 | 28.1 | +0.000 | +3.500 | 76
COLUMN | C250/12deg | Z/507 | 28.1 | +0.000 | +3.500 | 76
COLUMN | C200/12deg | Z/504 | 24.8 | +0.000 | +3.500 | 76
COLUMN | C200/12deg | Z/503 | 24.8 | +0.000 | +3.500 | 76
COLUMN | C150/12deg | Z/501 | 19.5 | +0.000 | +3.500 | 64
RAFTER | C350/12deg-12deg | R/39 | 8.4 | +2.170 | +2.628 | 125
RAFTER | C350/12deg-12deg | R/38 | 7 | +2.219 | +2.629 | 96
RAFTER | C350/12deg-12deg | R/37 | 4.6 | +2.264 | +2.631 | 76
RAFTER | C350/X-12deg | R/36 | 4.6 | +2.314 | +2.649 | 76
RAFTER | C300/12deg-12deg | R/35 | 7.4 | +2.216 | +2.632 | 96
RAFTER | C300/12deg-12deg | R/34 | 4.8 | +2.261 | +2.633 | 76
RAFTER | C300/X-12deg | R/33 | 4.8 | +2.311 | +2.651 | 76
RAFTER | C250/12deg-12deg | R/32 | 4.8 | +2.258 | +2.635 | 76
RAFTER | C250/12deg-12deg | R/31 | 5 | +2.309 | +2.653 | 76
RAFTER | C250/X-12deg | R/30 | 3.9 | +2.359 | +2.654 | 64
RAFTER | C200/12deg-12deg | R/29 | 5.1 | +2.306 | +2.655 | 76
RAFTER | C200/X-12deg | R/28 | 4.1 | +2.356 | +2.657 | 64
RAFTER | C150/X-12deg | R/27 | 4.1 | +2.353 | +2.659 | 64
LEANTO BRACKET | C350/12deg-12deg | PL/299 | 6 | +2.208 | +2.682 | 89.5
LEANTO BRACKET | C350/12deg-12deg | PL/298 | 5.1 | +2.258 | +2.681 | 94.5
LEANTO BRACKET | C350/12deg-12deg | PL/297 | 3.6 | +2.330 | +2.678 | 105.1
LEANTO BRACKET | C350/X-12deg | PL/296 | 2.1 | +2.416 | +2.677 | 105.1
LEANTO BRACKET | C300/12deg-12deg | PL/292 | 5 | +2.261 | +2.683 | 75
LEANTO BRACKET | C300/12deg-12deg | PL/291 | 3.5 | +2.333 | +2.680 | 75.6
LEANTO BRACKET | C300/X-12deg | PL/290 | 2 | +2.418 | +2.680 | 75.6
LEANTO BRACKET | C250/12deg-12deg | PL/288 | 3.5 | +2.335 | +2.682 | 65.6
LEANTO BRACKET | C250/12deg-12deg | PL/285 | 2 | +2.420 | +2.682 | 65.6
LEANTO BRACKET | C250/X-12deg | PL/284 | 1.5 | +2.471 | +2.681 | 65.6
LEANTO BRACKET | C200/12deg-12deg | PL/285 | 2 | +2.422 | +2.684 | 65.6
LEANTO BRACKET | C200/12deg | PL/284 | 1.5 | +2.473 | +2.683 | 65.6
LEANTO BRACKET | C150/12deg | PL/282 | 1.5 | +2.475 | +2.686 | 59.6
LEANTO COLUMN STIFFIN | C350>/5deg | Z/489 | 2.5 | +2.430 | +2.730 | 3
LEANTO COLUMN STIFFIN | C350>/5deg | Z/490 | 2.9 | +2.379 | +2.729 | 3
LEANTO COLUMN STIFFIN | C350>/5deg | Z/491 | 3.3 | +2.333 | +2.733 | 3
LEANTO COLUMN STIFFIN | C350>/5deg | Z/492 | 3.7 | +2.282 | +2.732 | 3
COLUMN | C350>/5deg | Z/500 | 52.3 | +0.000 | +3.500 | 125
COLUMN | C350>/5deg | Z/499 | 52.3 | +0.000 | +3.500 | 125
COLUMN | C350>/5deg | Z/498 | 52.3 | +0.000 | +3.500 | 125
COLUMN | C350>/5deg | Z/497 | 52.3 | +0.000 | +3.500 | 125
RAFTER | C350>/5deg-5deg | R/26 | 8.4 | +2.264 | +2.662 | 125
RAFTER | C350>/5deg-5deg | R/23 | 7.1 | +2.314 | +2.662 | 96
RAFTER | C350>/5deg-5deg | R/19 | 4.6 | +2.360 | +2.663 | 76
RAFTER | C350>/X-5deg | R/14 | 4.6 | +2.411 | +2.670 | 76
LEANTO BRACKET | C350>/5deg-5deg | PL/275 | 5.8 | +2.287 | +2.674 | 89.5
LEANTO BRACKET | C350>/5deg-5deg | PL/277 | 5 | +2.337 | +2.674 | 94.5
LEANTO BRACKET | C350>/5deg-5deg | PL/281 | 3.5 | +2.395 | +2.672 | 105.1
LEANTO BRACKET | C350>/X-5deg | PL/280 | 2 | +2.460 | +2.673 | 105.1
6 x TH | C350>/5deg-5deg | B/21 | 1.8 | +2.625 | +2.707 | 125
2 x TH | C350>/X-5deg | B/21 | 1.8 | +2.625 | +2.707 | 125
LEANTO COLUMN STIFFIN | C350>/3deg | Z/489 | 2.5 | +2.437 | +2.737 | 3
LEANTO COLUMN STIFFIN | C350>/3deg | Z/490 | 2.9 | +2.386 | +2.736 | 3
LEANTO COLUMN STIFFIN | C350>/3deg | Z/491 | 3.3 | +2.340 | +2.740 | 3
LEANTO COLUMN STIFFIN | C350>/3deg | Z/492 | 3.7 | +2.290 | +2.740 | 3
COLUMN | C350>/3deg | Z/496 | 52.3 | +0.000 | +3.500 | 125
COLUMN | C350>/3deg | Z/495 | 52.3 | +0.000 | +3.500 | 125
COLUMN | C350>/3deg | Z/494 | 52.3 | +0.000 | +3.500 | 125
COLUMN | C350>/3deg | Z/493 | 52.3 | +0.000 | +3.500 | 125
RAFTER | C350>/3deg-3deg | R/13 | 8.6 | +2.298 | +2.678 | 125
RAFTER | C350>/3deg-3deg | R/10 | 7.1 | +2.348 | +2.678 | 96
RAFTER | C350>/3deg-3deg | R/6 | 4.6 | +2.394 | +2.678 | 76
RAFTER | C350>/<3deg | R/1 | 4.6 | +2.445 | +2.682 | 76
LEANTO BRACKET | C350>/3deg-3deg | PL/274 | 5.8 | +2.316 | +2.681 | 89.5
LEANTO BRACKET | C350>/3deg-3deg | PL/276 | 4.8 | +2.366 | +2.681 | 94.5
LEANTO BRACKET | C350>/3deg-3deg | PL/279 | 3.5 | +2.420 | +2.679 | 105.1
LEANTO BRACKET | C350>/<3deg | PL/278 | 2 | +2.480 | +2.679 | 105.1
6 x TH | C350>/3deg-3deg | B/20 | 1.8 | +2.657 | +2.737 | 125
2 x TH | C350>/<3deg | B/20 | 1.8 | +2.657 | +2.737 | 125
LEANTO COLUMN STIFFIN | C300-C350/5deg | Z/480 | 2.1 | +2.432 | +2.732 | 3
LEANTO COLUMN STIFFIN | C300-C350/5deg | Z/481 | 2.5 | +2.381 | +2.731 | 3
LEANTO COLUMN STIFFIN | C300-C350/5deg | Z/482 | 2.8 | +2.335 | +2.735 | 3
COLUMN | C300-C350/5deg | Z/488 | 43.8 | +0.000 | +3.500 | 96
COLUMN | C300-C350/5deg | Z/487 | 43.8 | +0.000 | +3.500 | 96
COLUMN | C300-C350/5deg | Z/486 | 43.8 | +0.000 | +3.500 | 96
RAFTER | C300-C350/5deg-5deg | R/24 | 7.4 | +2.314 | +2.665 | 96
RAFTER | C300-C350/5deg-5deg | R/20 | 4.8 | +2.360 | +2.665 | 76
RAFTER | C300-C350/X-5deg | R/15 | 4.8 | +2.411 | +2.672 | 76
LEANTO BRACKET | C300-C350/5deg-5deg | PL/269 | 4.8 | +2.339 | +2.677 | 75
LEANTO BRACKET | C300-C350/5deg-5deg | PL/273 | 3.3 | +2.397 | +2.675 | 75.6
LEANTO BRACKET | C300-C350/X-5deg | PL/272 | 2 | +2.462 | +2.675 | 75.6
4 x TH | C300-C350/5deg-5deg | B/21 | 1.8 | +2.625 | +2.707 | 125
2 x TH | C300-C350/X-5deg | B/21 | 1.8 | +2.625 | +2.707 | 125
LEANTO COLUMN STIFFIN | C300-C350/3deg | Z/480 | 2.1 | +2.438 | +2.738 | 3
LEANTO COLUMN STIFFIN | C300-C350/3deg | Z/481 | 2.5 | +2.387 | +2.737 | 3
LEANTO COLUMN STIFFIN | C300-C350/3deg | Z/482 | 2.8 | +2.341 | +2.741 | 3
COLUMN | C300-C350/3deg | Z/485 | 43.8 | +0.000 | +3.500 | 96
COLUMN | C300-C350/3deg | Z/484 | 43.8 | +0.000 | +3.500 | 96
COLUMN | C300-C350/3deg | Z/483 | 43.8 | +0.000 | +3.500 | 96
RAFTER | C300-C350/3deg-3deg | R/11 | 7.6 | +2.348 | +2.679 | 96
RAFTER | C300-C350/3deg-3deg | R/7 | 4.8 | +2.394 | +2.679 | 76
RAFTER | C300-C350/<3deg | R/2 | 4.8 | +2.445 | +2.684 | 76
LEANTO BRACKET | C300-C350/3deg-3deg | PL/268 | 4.8 | +2.368 | +2.682 | 75
LEANTO BRACKET | C300-C350/3deg-3deg | PL/271 | 3.3 | +2.422 | +2.680 | 75.6
LEANTO BRACKET | C300-C350/<3deg | PL/270 | 2 | +2.481 | +2.681 | 75.6
4 x TH | C300-C350/3deg-3deg | B/20 | 1.8 | +2.657 | +2.737 | 125
2 x TH | C300-C350/<3deg | B/20 | 1.8 | +2.657 | +2.737 | 125
LEANTO COLUMN STIFFIN | C250-C300/5deg | Z/471 | 1.5 | +2.485 | +2.735 | 3
LEANTO COLUMN STIFFIN | C250-C300/5deg | Z/473 | 2.1 | +2.383 | +2.733 | 3
LEANTO COLUMN STIFFIN | C250-C300/5deg | Z/472 | 1.8 | +2.434 | +2.734 | 3
COLUMN | C250-C300/5deg | Z/479 | 28.1 | +0.000 | +3.500 | 76
COLUMN | C250-C300/5deg | Z/478 | 28.1 | +0.000 | +3.500 | 76
COLUMN | C250-C300/5deg | Z/477 | 28.1 | +0.000 | +3.500 | 76
RAFTER | C250-C300/5deg-5deg | R/25 | 5 | +2.360 | +2.667 | 76
RAFTER | C250-C300/5deg-5deg | R/21 | 5 | +2.411 | +2.674 | 76
RAFTER | C250-C300/X-5deg | R/16 | 3.9 | +2.461 | +2.675 | 64
LEANTO BRACKET | C250-C300/5deg-5deg | PL/267 | 3.3 | +2.399 | +2.677 | 65.6
LEANTO BRACKET | C250-C300/5deg-5deg | PL/265 | 2 | +2.464 | +2.677 | 65.6
LEANTO BRACKET | C250-C300/X-5deg | PL/263 | 1.2 | +2.515 | +2.678 | 65.6
4 x TH | C250-C300/5deg-5deg | B/21 | 1.8 | +2.625 | +2.707 | 125
2 x TH | C250-C300/X-5deg | B/21 | 1.8 | +2.625 | +2.707 | 125
LEANTO COLUMN STIFFIN | C250-C300/3deg | Z/471 | 1.5 | +2.491 | +2.741 | 3
LEANTO COLUMN STIFFIN | C250-C300/3deg | Z/473 | 2.1 | +2.388 | +2.738 | 3
LEANTO COLUMN STIFFIN | C250-C300/3deg | Z/472 | 1.8 | +2.440 | +2.740 | 3
COLUMN | C250-C300/3deg | Z/476 | 28.1 | +0.000 | +3.500 | 76
COLUMN | C250-C300/3deg | Z/475 | 28.1 | +0.000 | +3.500 | 76
COLUMN | C250-C300/3deg | Z/474 | 28.1 | +0.000 | +3.500 | 76
RAFTER | C250-C300/3deg-3deg | R/12 | 5 | +2.394 | +2.681 | 76
RAFTER | C250-C300/3deg-3deg | R/8 | 5 | +2.445 | +2.685 | 76
RAFTER | C250-C300/<3deg | R/3 | 3.9 | +2.496 | +2.685 | 64
LEANTO BRACKET | C250-C300/3deg-3deg | PL/266 | 3.3 | +2.423 | +2.681 | 65.6
LEANTO BRACKET | C250-C300/3deg-3deg | PL/264 | 1.8 | +2.482 | +2.682 | 65.6
LEANTO BRACKET | C250-C300/<3deg | PL/262 | 1.2 | +2.533 | +2.682 | 65.6
4 x TH | C250-C300/3deg-3deg | B/20 | 1.8 | +2.657 | +2.737 | 125
2 x TH | C250-C300/<3deg | B/20 | 1.8 | +2.657 | +2.737 | 125
LEANTO COLUMN STIFFIN | C200-C250/5deg | Z/465 | 1.2 | +2.488 | +2.738 | 3
LEANTO COLUMN STIFFIN | C200-C250/5deg | Z/466 | 1.5 | +2.436 | +2.736 | 3
COLUMN | C200-C250/5deg | Z/470 | 24.8 | +0.000 | +3.500 | 76
COLUMN | C200-C250/5deg | Z/469 | 24.8 | +0.000 | +3.500 | 76
RAFTER | C200-C250/5deg-5deg | R/22 | 5.1 | +2.411 | +2.676 | 76
RAFTER | C200-C250/X-5deg | R/17 | 4.1 | +2.461 | +2.677 | 64
LEANTO BRACKET | C200-C250/5deg | PL/265 | 2 | +2.467 | +2.679 | 65.6
LEANTO BRACKET | C200-C250/5deg | PL/263 | 1.2 | +2.517 | +2.680 | 65.6
2 x TH | C200-C250/5deg-5deg | B/21 | 1.8 | +2.625 | +2.707 | 125
2 x TH | C200-C250/X-5deg | B/21 | 1.8 | +2.625 | +2.707 | 125
LEANTO COLUMN STIFFIN | C200-C250/3deg | Z/465 | 1.2 | +2.492 | +2.742 | 3
LEANTO COLUMN STIFFIN | C200-C250/3deg | Z/466 | 1.5 | +2.441 | +2.741 | 3
COLUMN | C200-C250/3deg | Z/468 | 24.8 | +0.000 | +3.500 | 76
COLUMN | C200-C250/3deg | Z/467 | 24.8 | +0.000 | +3.500 | 76
RAFTER | C200-C250/3deg-3deg | R/9 | 5.1 | +2.445 | +2.686 | 76
RAFTER | C200-C250/<3deg | R/4 | 4.1 | +2.496 | +2.686 | 64
LEANTO BRACKET | C200-C250/3deg | PL/264 | 1.8 | +2.484 | +2.683 | 65.6
LEANTO BRACKET | C200-C250/3deg | PL/262 | 1.2 | +2.534 | +2.684 | 65.6
2 x TH | C200-C250/3deg-3deg | B/20 | 1.8 | +2.657 | +2.737 | 125
2 x TH | C200-C250/<3deg | B/20 | 1.8 | +2.657 | +2.737 | 125
LEANTO COLUMN STIFFIN | C150-C200/5deg | Z/462 | 0.9 | +2.490 | +2.740 | 3
COLUMN | C150-C200/5deg | Z/464 | 19.5 | +0.000 | +3.500 | 64
RAFTER | C150-C200/X-5deg | R/18 | 4.1 | +2.461 | +2.679 | 64
LEANTO BRACKET | C150-C200/5deg | PL/261 | 1.2 | +2.519 | +2.682 | 59.6
2 x TH | C150-C200/X-5deg | B/21 | 1.8 | +2.625 | +2.707 | 125
LEANTO COLUMN STIFFIN | C150-C200/3deg | Z/462 | 0.9 | +2.493 | +2.743 | 3
COLUMN | C150-C200/3deg | Z/463 | 19.5 | +0.000 | +3.500 | 64
RAFTER | C150-C200/<3deg | R/5 | 4.3 | +2.496 | +2.688 | 64
LEANTO BRACKET | C150-C200/3deg | PL/260 | 1.2 | +2.535 | +2.685 | 59.6
2 x TH | C150-C200/<3deg | B/20 | 1.8 | +2.657 | +2.737 | 125
LEANTO COLUMN STIFFIN | C350/5deg | PL/226 | 2.5 | +2.430 | +2.730 | 3
LEANTO COLUMN STIFFIN | C350/5deg | PL/239 | 2.9 | +2.379 | +2.729 | 3
LEANTO COLUMN STIFFIN | C350/5deg | PL/245 | 3.3 | +2.333 | +2.733 | 3
LEANTO COLUMN STIFFIN | C350/3deg | PL/226 | 2.5 | +2.437 | +2.737 | 3
LEANTO COLUMN STIFFIN | C350/3deg | PL/239 | 2.9 | +2.386 | +2.736 | 3
LEANTO COLUMN STIFFIN | C350/3deg | PL/245 | 3.3 | +2.340 | +2.740 | 3
LEANTO COLUMN STIFFIN | C300/5deg | PL/233 | 2.1 | +2.432 | +2.732 | 3
LEANTO COLUMN STIFFIN | C300/5deg | PL/240 | 2.5 | +2.381 | +2.731 | 3
LEANTO COLUMN STIFFIN | C300/3deg | PL/233 | 2.1 | +2.438 | +2.738 | 3
LEANTO COLUMN STIFFIN | C300/3deg | PL/240 | 2.5 | +2.387 | +2.737 | 3
LEANTO COLUMN STIFFIN | C250/5deg | PL/224 | 1.5 | +2.485 | +2.735 | 3
LEANTO COLUMN STIFFIN | C250/3deg | PL/224 | 1.5 | +2.491 | +2.741 | 3
LEANTO COLUMN STIFFIN | C200/5deg | PL/213 | 1.2 | +2.488 | +2.738 | 3
LEANTO COLUMN STIFFIN | C200/3deg | PL/213 | 1.2 | +2.492 | +2.742 | 3
LEANTO COLUMN STIFFIN | C350/5deg | PL/248 | 3.7 | +2.282 | +2.732 | 3
LEANTO COLUMN STIFFIN | C300/5deg | PL/246 | 2.8 | +2.335 | +2.735 | 3
LEANTO COLUMN STIFFIN | C250/5deg | PL/244 | 2.1 | +2.383 | +2.733 | 3
LEANTO COLUMN STIFFIN | C250/5deg | PL/238 | 1.8 | +2.434 | +2.734 | 3
LEANTO COLUMN STIFFIN | C200/5deg | PL/237 | 1.5 | +2.436 | +2.736 | 3
LEANTO COLUMN STIFFIN | C150/5deg | PL/210 | 0.9 | +2.490 | +2.740 | 3
LEANTO COLUMN STIFFIN | C350/3deg | PL/248 | 3.7 | +2.290 | +2.740 | 3
LEANTO COLUMN STIFFIN | C300/3deg | PL/246 | 2.8 | +2.341 | +2.741 | 3
LEANTO COLUMN STIFFIN | C250/3deg | PL/244 | 2.1 | +2.388 | +2.738 | 3
LEANTO COLUMN STIFFIN | C250/3deg | PL/238 | 1.8 | +2.440 | +2.740 | 3
LEANTO COLUMN STIFFIN | C200/3deg | PL/237 | 1.5 | +2.441 | +2.741 | 3
LEANTO COLUMN STIFFIN | C150/3deg | PL/210 | 0.9 | +2.493 | +2.743 | 3
COLUMN | C350/5deg | Z/461 | 52.3 | +0.000 | +3.500 | 125
COLUMN | C350/5deg | Z/459 | 52.3 | +0.000 | +3.500 | 125
COLUMN | C350/5deg | Z/456 | 52.3 | +0.000 | +3.500 | 125
COLUMN | C350/5deg | Z/452 | 52.3 | +0.000 | +3.500 | 125
COLUMN | C300/5deg | Z/460 | 43.8 | +0.000 | +3.500 | 96
COLUMN | C300/5deg | Z/457 | 43.8 | +0.000 | +3.500 | 96
COLUMN | C300/5deg | Z/453 | 43.8 | +0.000 | +3.500 | 96
COLUMN | C250/5deg | Z/458 | 28.1 | +0.000 | +3.500 | 76
COLUMN | C250/5deg | Z/455 | 28.1 | +0.000 | +3.500 | 76
COLUMN | C250/5deg | Z/451 | 28.1 | +0.000 | +3.500 | 76
COLUMN | C200/5deg | Z/454 | 24.8 | +0.000 | +3.500 | 76
COLUMN | C200/5deg | Z/450 | 24.8 | +0.000 | +3.500 | 76
COLUMN | C150/5deg | Z/449 | 19.5 | +0.000 | +3.500 | 64
COLUMN | C350/3deg | Z/448 | 52.3 | +0.000 | +3.500 | 125
COLUMN | C350/3deg | Z/446 | 52.3 | +0.000 | +3.500 | 125
COLUMN | C350/3deg | Z/443 | 52.3 | +0.000 | +3.500 | 125
COLUMN | C300/3deg | Z/447 | 43.8 | +0.000 | +3.500 | 96
COLUMN | C300/3deg | Z/444 | 43.8 | +0.000 | +3.500 | 96
COLUMN | C250/3deg | Z/445 | 28.1 | +0.000 | +3.500 | 76
COLUMN | C250/3deg | Z/442 | 28.1 | +0.000 | +3.500 | 76
COLUMN | C200/3deg | Z/441 | 24.8 | +0.000 | +3.500 | 76
COLUMN | C350/3deg | Z/439 | 52.3 | +0.000 | +3.500 | 125
COLUMN | C300/3deg | Z/440 | 43.8 | +0.000 | +3.500 | 96
COLUMN | C250/3deg | Z/437 | 28.1 | +0.000 | +3.500 | 76
COLUMN | C200/3deg | Z/435 | 24.8 | +0.000 | +3.500 | 76
COLUMN | C150/3deg | Z/434 | 19.5 | +0.000 | +3.500 | 64
RAFTER | C350/5deg-5deg | R/26 | 8.4 | +2.264 | +2.662 | 125
LEANTO BRACKET | C350/5deg-5deg | PL/259 | 5.8 | +2.287 | +2.674 | 89.5
RAFTER | C350/5deg-5deg | R/23 | 7.1 | +2.314 | +2.662 | 96
LEANTO BRACKET | C350/5deg-5deg | PL/256 | 5 | +2.337 | +2.674 | 94.5
RAFTER | C350/5deg-5deg | R/19 | 4.6 | +2.360 | +2.663 | 76
LEANTO BRACKET | C350/5deg-5deg | PL/253 | 3.5 | +2.395 | +2.672 | 105.1
RAFTER | C350/X-5deg | R/14 | 4.6 | +2.411 | +2.670 | 76
LEANTO BRACKET | C350/X-5deg | PL/249 | 2 | +2.460 | +2.673 | 105.1
RAFTER | C300/5deg-5deg | R/24 | 7.4 | +2.314 | +2.665 | 96
LEANTO BRACKET | C300/5deg-5deg | PL/257 | 4.8 | +2.339 | +2.677 | 75
RAFTER | C300/5deg-5deg | R/20 | 4.8 | +2.360 | +2.665 | 76
LEANTO BRACKET | C300/5deg-5deg | PL/254 | 3.3 | +2.397 | +2.675 | 75.6
RAFTER | C300/X-5deg | R/15 | 4.8 | +2.411 | +2.672 | 76
LEANTO BRACKET | C300/X-5deg | PL/250 | 2 | +2.462 | +2.675 | 75.6
RAFTER | C250/5deg-5deg | R/25 | 5 | +2.360 | +2.667 | 76
LEANTO BRACKET | C250/5deg-5deg | PL/258 | 3.3 | +2.399 | +2.677 | 65.6
RAFTER | C250/5deg-5deg | R/21 | 5 | +2.411 | +2.674 | 76
LEANTO BRACKET | C250/5deg-5deg | PL/255 | 2 | +2.464 | +2.677 | 65.6
RAFTER | C250/X-5deg | R/16 | 3.9 | +2.461 | +2.675 | 64
LEANTO BRACKET | C250/X-5deg | PL/251 | 1.2 | +2.515 | +2.678 | 65.6
RAFTER | C200/5deg-5deg | R/22 | 5.1 | +2.411 | +2.676 | 76
LEANTO BRACKET | C200/5deg | PL/255 | 2 | +2.467 | +2.679 | 65.6
RAFTER | C200/X-5deg | R/17 | 4.1 | +2.461 | +2.677 | 64
LEANTO BRACKET | C200/5deg | PL/251 | 1.2 | +2.517 | +2.680 | 65.6
RAFTER | C150/X-5deg | R/18 | 4.1 | +2.461 | +2.679 | 64
LEANTO BRACKET | C150/5deg | PL/252 | 1.2 | +2.519 | +2.682 | 59.6
RAFTER | C350/3deg-3deg | R/13 | 8.6 | +2.298 | +2.678 | 125
LEANTO BRACKET | C350/3deg-3deg | PL/247 | 5.8 | +2.316 | +2.681 | 89.5
RAFTER | C350/3deg-3deg | R/10 | 7.1 | +2.348 | +2.678 | 96
LEANTO BRACKET | C350/3deg-3deg | PL/241 | 4.8 | +2.366 | +2.681 | 94.5
RAFTER | C350/3deg-3deg | R/6 | 4.6 | +2.394 | +2.678 | 76
LEANTO BRACKET | C350/3deg-3deg | PL/234 | 3.5 | +2.420 | +2.679 | 105.1
RAFTER | C350/<3deg | R/1 | 4.6 | +2.445 | +2.682 | 76
LEANTO BRACKET | C350/<3deg | PL/171 | 2 | +2.480 | +2.679 | 105.1
RAFTER | C300/3deg-3deg | R/11 | 7.6 | +2.348 | +2.679 | 96
LEANTO BRACKET | C300/3deg-3deg | PL/242 | 4.8 | +2.368 | +2.682 | 75
RAFTER | C300/3deg-3deg | R/7 | 4.8 | +2.394 | +2.679 | 76
LEANTO BRACKET | C300/3deg-3deg | PL/235 | 3.3 | +2.422 | +2.680 | 75.6
RAFTER | C250/3deg-3deg | R/12 | 5 | +2.394 | +2.681 | 76
LEANTO BRACKET | C250/3deg-3deg | PL/243 | 3.3 | +2.423 | +2.681 | 65.6
RAFTER | C300/<3deg | R/2 | 4.8 | +2.445 | +2.684 | 76
LEANTO BRACKET | C300/<3deg | PL/205 | 2 | +2.481 | +2.681 | 75.6
RAFTER | C250/3deg-3deg | R/8 | 5 | +2.445 | +2.685 | 76
LEANTO BRACKET | C250/3deg-3deg | PL/236 | 1.8 | +2.482 | +2.682 | 65.6
RAFTER | C250/<3deg | R/3 | 3.9 | +2.496 | +2.685 | 64
LEANTO BRACKET | C250/<3deg | PL/206 | 1.2 | +2.533 | +2.682 | 65.6
RAFTER | C200/3deg-3deg | R/9 | 5.1 | +2.445 | +2.686 | 76
LEANTO BRACKET | C200/3deg | PL/236 | 1.8 | +2.484 | +2.683 | 65.6
RAFTER | C200/<3deg | R/4 | 4.1 | +2.496 | +2.686 | 64
LEANTO BRACKET | C200/3deg | PL/206 | 1.2 | +2.534 | +2.684 | 65.6
RAFTER | C150/<3deg | R/5 | 4.3 | +2.496 | +2.688 | 64
LEANTO BRACKET | C150/3deg | PL/209 | 1.2 | +2.535 | +2.685 | 59.6

# IfcMechanicalFastener: Bolt assembly (312)
In: Undefined
Tekla Bolt - Location: Site
Name | NominalDiameter (mm) = Washer diameter (mm) = Bolt size (mm) | NominalLength (mm) = Bolt length (mm) | Material = Bolt standard | Washer count | Washer type | Washer name | Nut count = Bolt count | Nut type | Nut name | Slotted hole y (mm) | Slotted hole x (mm) | Bolt hole diameter (mm) | Bolt Name
84 x Bolt assembly | 5 | 25 | TEK_16TPIM | 8 | UNDEF_WASH | UNDEFINED_WASHER5 | 4 | UNDEF_NUT | UNDEFINED_NUTM5 | 0 | 0 | 7 | TEKSCREW_M5*25
36 x Bolt assembly | 5 | 25 | TEK_16TPIM | 10 | UNDEF_WASH | UNDEFINED_WASHER5 | 5 | UNDEF_NUT | UNDEFINED_NUTM5 | 0 | 0 | 7 | TEKSCREW_M5*25
12 x Bolt assembly | 16 | 40 | 8.8S | 3 | HARD | WASHERM16-HARD | 3 | 8.8-HEX | NUTM16-8.8-HEX | 0 | 0 | 18 | BOLTM16*40
6 x Bolt assembly | 16 | 40 | 8.8S | 3 | HARD | WASHERM16-HARD | 3 | 8.8-HEX | NUTM16-8.8-HEX | 36 | 0 | 18 | BOLTM16*40
6 x Bolt assembly | 16 | 40 | 8.8S | 3 | HARD | WASHERM16-HARD | 3 | 8.8-HEX | NUTM16-8.8-HEX | 56 | 0 | 18 | BOLTM16*40
6 x Bolt assembly | 12 | 30 | 8.8S | 2 | HARD | WASHERM12-HARD | 2 | 8.8-HEX | NUTM12-8.8-HEX | 56 | 0 | 14 | BOLTM12*30
18 x Bolt assembly | 16 | 40 | 8.8S | 6 | HARD | WASHERM16-HARD | 6 | 8.8-HEX | NUTM16-8.8-HEX | 8 | 4 | 18 | BOLTM16*40
18 x Bolt assembly | 16 | 35 | 8.8S | 4 | HARD | WASHERM16-HARD | 4 | 8.8-HEX | NUTM16-8.8-HEX | 8 | 4 | 18 | BOLTM16*35
42 x Bolt assembly | 12 | 30 | 8.8S | 4 | HARD | WASHERM12-HARD | 4 | 8.8-HEX | NUTM12-8.8-HEX | 8 | 4 | 14 | BOLTM12*30
6 x Bolt assembly | 16 | 40 | 8.8S | 3 | HARD | WASHERM16-HARD | 3 | 8.8-HEX | NUTM16-8.8-HEX | 26 | 0 | 18 | BOLTM16*40
6 x Bolt assembly | 12 | 30 | 8.8S | 2 | HARD | WASHERM12-HARD | 2 | 8.8-HEX | NUTM12-8.8-HEX | 26 | 0 | 14 | BOLTM12*30
36 x Bolt assembly | 5 | 25 | TEK_16TPIM | 6 | UNDEF_WASH | UNDEFINED_WASHER5 | 3 | UNDEF_NUT | UNDEFINED_NUTM5 | 0 | 0 | 7 | TEKSCREW_M5*25
6 x Bolt assembly | 16 | 35 | 8.8S | 3 | HARD | WASHERM16-HARD | 3 | 8.8-HEX | NUTM16-8.8-HEX | 0 | 0 | 18 | BOLTM16*35
18 x Bolt assembly | 12 | 30 | 8.8S | 2 | HARD | WASHERM12-HARD | 2 | 8.8-HEX | NUTM12-8.8-HEX | 0 | 0 | 14 | BOLTM12*30
12 x Bolt assembly | 12 | 30 | 8.8S | 2 | HARD | WASHERM12-HARD | 2 | 8.8-HEX | NUTM12-8.8-HEX | 16 | 0 | 14 | BOLTM12*30

# IfcPlate: PLT3*132.9 (2)
In: Undefined
Description: PLT3*132.9; Material: STEEL/450
Tekla Common - Bottom elevation: +2.535; Top elevation: +2.685; Phase: 1; Class: 11
Tekla Quantity - Weight: 1.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.6 m2; Net surface area: 0.1 m2; Height: 132.9 mm; Width: 3 mm; Length: 429.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 132.881 mm; NetArea: 0.114756 m2; GrossArea: 0.0570876 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000166885 m3; GrossVolume: 0.000166885 m3
Name | ASSEMBLY_POS = Reference
LEANTO BRACKET | PL/260
LEANTO BRACKET | PL/209

# IfcPlate: PLT3*133.2 (4)
In: Undefined
Description: PLT3*133.2; Material: STEEL/450
Tekla Common - Phase: 1; Class: 11
Tekla Quantity - Weight: 1.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.6 m2; Net surface area: 0.1 m2; Height: 133.2 mm; Width: 3 mm; Length: 435.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - NetArea: 0.116354 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000169229 m3; GrossVolume: 0.000169229 m3
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Width (mm) | GrossArea (m2)
LEANTO BRACKET | PL/262 | +2.533 | +2.682 | 133.192 | 0.0580194
LEANTO BRACKET | PL/262 | +2.534 | +2.684 | 133.198 | 0.0580216
LEANTO BRACKET | PL/206 | +2.533 | +2.682 | 133.192 | 0.0580194
LEANTO BRACKET | PL/206 | +2.534 | +2.684 | 133.198 | 0.0580216

# IfcPlate: PLT3*134.8 (2)
In: Undefined
Description: PLT3*134.8; Material: STEEL/450
Tekla Common - Bottom elevation: +2.519; Top elevation: +2.682; Phase: 1; Class: 11
Tekla Quantity - Weight: 1.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.6 m2; Net surface area: 0.1 m2; Height: 134.8 mm; Width: 3 mm; Length: 434.8 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 134.803 mm; NetArea: 0.115596 m2; GrossArea: 0.0586099 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000168116 m3; GrossVolume: 0.000168116 m3
Name | ASSEMBLY_POS = Reference
LEANTO BRACKET | PL/261
LEANTO BRACKET | PL/252

# IfcPlate: PLT3*135.3 (4)
In: Undefined
Description: PLT3*135.3; Material: STEEL/450
Tekla Common - Phase: 1; Class: 11
Tekla Quantity - Weight: 1.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.6 m2; Net surface area: 0.1 m2; Height: 135.3 mm; Width: 3 mm; Length: 440.8 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - NetArea: 0.117198 m2; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Width (mm) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
LEANTO BRACKET | PL/263 | +2.515 | +2.678 | 135.324 | 0.0596459 | 0.000170465
LEANTO BRACKET | PL/263 | +2.517 | +2.680 | 135.325 | 0.0596461 | 0.000170466
LEANTO BRACKET | PL/251 | +2.515 | +2.678 | 135.324 | 0.0596459 | 0.000170465
LEANTO BRACKET | PL/251 | +2.517 | +2.680 | 135.325 | 0.0596461 | 0.000170466

# IfcPlate: PLT3*141.5 (2)
In: Undefined
Description: PLT3*141.5; Material: STEEL/450
Tekla Common - Bottom elevation: +2.475; Top elevation: +2.686; Phase: 1; Class: 11
Tekla Quantity - Weight: 1.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.6 m2; Net surface area: 0.1 m2; Height: 141.5 mm; Width: 3 mm; Length: 454.2 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 141.455 mm; NetArea: 0.119105 m2; GrossArea: 0.064242 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000173256 m3; GrossVolume: 0.000173256 m3
Name | ASSEMBLY_POS = Reference
LEANTO BRACKET | PL/283
LEANTO BRACKET | PL/282

# IfcPlate: PLT3*142.7 (4)
In: Undefined
Description: PLT3*142.7; Material: STEEL/450
Tekla Common - Phase: 1; Class: 11
Tekla Quantity - Weight: 1.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.6 m2; Net surface area: 0.1 m2; Height: 142.7 mm; Width: 3 mm; Length: 460 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
LEANTO BRACKET | PL/287 | +2.471 | +2.681 | 142.701 | 0.120735 | 0.0656448 | 0.000175647
LEANTO BRACKET | PL/287 | +2.473 | +2.683 | 142.702 | 0.120734 | 0.0656449 | 0.000175646
LEANTO BRACKET | PL/284 | +2.471 | +2.681 | 142.701 | 0.120735 | 0.0656448 | 0.000175647
LEANTO BRACKET | PL/284 | +2.473 | +2.683 | 142.702 | 0.120734 | 0.0656449 | 0.000175646

# IfcPlate: PLT3*152 (6)
In: Undefined
Description: PLT3*152; Material: STEEL/450
Tekla Common - Phase: 1; Class: 9
Tekla Quantity - Weight: 0.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.6 m2; Net surface area: 0.1 m2; Height: 152 mm; Width: 3 mm; Length: 250 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 152 mm; NetArea: 0.078412 m2; GrossArea: 0.038 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000114 m3; GrossVolume: 0.000114 m3
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation
LEANTO COLUMN STIFFIN | Z/1941 | +2.490 | +2.740
2 x LEANTO COLUMN STIFFIN | PL/210 | +2.490 | +2.740
LEANTO COLUMN STIFFIN | Z/462 | +2.490 | +2.740
LEANTO COLUMN STIFFIN | Z/462 | +2.493 | +2.743
LEANTO COLUMN STIFFIN | PL/210 | +2.493 | +2.743

# IfcPlate: PLT3*183.2 (4)
In: Undefined
Description: PLT3*183.2; Material: STEEL/450
Tekla Common - Phase: 1; Class: 11
Tekla Quantity - Weight: 1.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87 m2; Net surface area: 0.2 m2; Height: 183.2 mm; Width: 3 mm; Length: 438.2 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
LEANTO BRACKET | PL/264 | +2.482 | +2.682 | 183.203 | 0.160597 | 0.0802881 | 0.000235043
LEANTO BRACKET | PL/264 | +2.484 | +2.683 | 183.2 | 0.160594 | 0.0802856 | 0.000235038
LEANTO BRACKET | PL/236 | +2.482 | +2.682 | 183.203 | 0.160597 | 0.0802881 | 0.000235043
LEANTO BRACKET | PL/236 | +2.484 | +2.683 | 183.2 | 0.160594 | 0.0802856 | 0.000235038

# IfcPlate: PLT3*183.7 (2)
In: Undefined
Description: PLT3*183.7; Material: STEEL/450
Tekla Common - Bottom elevation: +2.481; Top elevation: +2.681; Phase: 1; Class: 11
Tekla Quantity - Weight: 2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87 m2; Net surface area: 0.2 m2; Height: 183.7 mm; Width: 3 mm; Length: 448.2 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 183.726 mm; NetArea: 0.164262 m2; GrossArea: 0.0823522 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000240451 m3; GrossVolume: 0.000240451 m3
Name | ASSEMBLY_POS = Reference
LEANTO BRACKET | PL/270
LEANTO BRACKET | PL/205

# IfcPlate: PLT3*185.3 (6)
In: Undefined
Description: PLT3*185.3; Material: STEEL/450
Tekla Common - Phase: 1; Class: 11
Tekla Quantity - Weight: 2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87 m2; Net surface area: 0.2 m2; Height: 185.3 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Length (mm) | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
LEANTO BRACKET | PL/278 | +2.480 | +2.679 | 477.7 | 185.265 | 0.175072 | 0.0884985 | 0.000256399
LEANTO BRACKET | PL/265 | +2.464 | +2.677 | 445.2 | 185.331 | 0.162082 | 0.082505 | 0.000237232
LEANTO BRACKET | PL/265 | +2.467 | +2.679 | 445.2 | 185.322 | 0.162081 | 0.0825007 | 0.000237231
LEANTO BRACKET | PL/255 | +2.464 | +2.677 | 445.2 | 185.331 | 0.162082 | 0.082505 | 0.000237232
LEANTO BRACKET | PL/255 | +2.467 | +2.679 | 445.2 | 185.322 | 0.162081 | 0.0825007 | 0.000237231
LEANTO BRACKET | PL/171 | +2.480 | +2.679 | 477.7 | 185.265 | 0.175072 | 0.0884985 | 0.000256399

# IfcPlate: PLT3*186.2 (2)
In: Undefined
Description: PLT3*186.2; Material: STEEL/450
Tekla Common - Bottom elevation: +2.462; Top elevation: +2.675; Phase: 1; Class: 11
Tekla Quantity - Weight: 2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87 m2; Net surface area: 0.2 m2; Height: 186.2 mm; Width: 3 mm; Length: 455.1 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 186.196 mm; NetArea: 0.165756 m2; GrossArea: 0.0847448 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000242653 m3; GrossVolume: 0.000242653 m3
Name | ASSEMBLY_POS = Reference
LEANTO BRACKET | PL/272
LEANTO BRACKET | PL/250

# IfcPlate: PLT3*188.8 (2)
In: Undefined
Description: PLT3*188.8; Material: STEEL/450
Tekla Common - Bottom elevation: +2.460; Top elevation: +2.673; Phase: 1; Class: 11
Tekla Quantity - Weight: 2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87 m2; Net surface area: 0.2 m2; Height: 188.8 mm; Width: 3 mm; Length: 484.5 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 188.764 mm; NetArea: 0.17659 m2; GrossArea: 0.0914606 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000258639 m3; GrossVolume: 0.000258639 m3
Name | ASSEMBLY_POS = Reference
LEANTO BRACKET | PL/280
LEANTO BRACKET | PL/249

# IfcPlate: PLT3*192.7 (4)
In: Undefined
Description: PLT3*192.7; Material: STEEL/450
Tekla Common - Phase: 1; Class: 11
Tekla Quantity - Weight: 2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87 m2; Net surface area: 0.2 m2; Height: 192.7 mm; Width: 3 mm; Length: 470.7 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
LEANTO BRACKET | PL/286 | +2.420 | +2.682 | 192.708 | 0.168098 | 0.0907157 | 0.000246099
LEANTO BRACKET | PL/286 | +2.422 | +2.684 | 192.709 | 0.168099 | 0.090716 | 0.0002461
LEANTO BRACKET | PL/285 | +2.420 | +2.682 | 192.708 | 0.168098 | 0.0907157 | 0.000246099
LEANTO BRACKET | PL/285 | +2.422 | +2.684 | 192.709 | 0.168099 | 0.090716 | 0.0002461

# IfcPlate: PLT3*194.8 (2)
In: Undefined
Description: PLT3*194.8; Material: STEEL/450
Tekla Common - Bottom elevation: +2.418; Top elevation: +2.680; Phase: 1; Class: 11
Tekla Quantity - Weight: 2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87 m2; Net surface area: 0.2 m2; Height: 194.8 mm; Width: 3 mm; Length: 480.5 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 194.778 mm; NetArea: 0.171839 m2; GrossArea: 0.0935961 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00025162 m3; GrossVolume: 0.00025162 m3
Name | ASSEMBLY_POS = Reference
LEANTO BRACKET | PL/294
LEANTO BRACKET | PL/290

# IfcPlate: PLT3*200.9 (2)
In: Undefined
Description: PLT3*200.9; Material: STEEL/450
Tekla Common - Bottom elevation: +2.416; Top elevation: +2.677; Phase: 1; Class: 11
Tekla Quantity - Weight: 2.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87 m2; Net surface area: 0.2 m2; Height: 200.9 mm; Width: 3 mm; Length: 509.4 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 200.921 mm; NetArea: 0.182872 m2; GrossArea: 0.102344 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000267904 m3; GrossVolume: 0.000267904 m3
Name | ASSEMBLY_POS = Reference
LEANTO BRACKET | PL/302
LEANTO BRACKET | PL/296

# IfcPlate: PLT3*203 (12)
In: Undefined
Description: PLT3*203; Material: STEEL/450
Tekla Common - Phase: 1; Class: 9
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.1 m2; Height: 203 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 203 mm; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
LEANTO COLUMN STIFFIN | Z/1942 | +2.488 | +2.738 | 1.2 | 87.1 | 250 | 0.104218 | 0.05075 | 0.00015225
LEANTO COLUMN STIFFIN | Z/1964 | +2.436 | +2.736 | 1.5 | 87 | 300 | 0.124818 | 0.0609 | 0.0001827
2 x LEANTO COLUMN STIFFIN | PL/213 | +2.488 | +2.738 | 1.2 | 87.1 | 250 | 0.104218 | 0.05075 | 0.00015225
2 x LEANTO COLUMN STIFFIN | PL/237 | +2.436 | +2.736 | 1.5 | 87 | 300 | 0.124818 | 0.0609 | 0.0001827
LEANTO COLUMN STIFFIN | Z/465 | +2.488 | +2.738 | 1.2 | 87.1 | 250 | 0.104218 | 0.05075 | 0.00015225
LEANTO COLUMN STIFFIN | Z/466 | +2.436 | +2.736 | 1.5 | 87 | 300 | 0.124818 | 0.0609 | 0.0001827
LEANTO COLUMN STIFFIN | Z/465 | +2.492 | +2.742 | 1.2 | 87.1 | 250 | 0.104218 | 0.05075 | 0.00015225
LEANTO COLUMN STIFFIN | Z/466 | +2.441 | +2.741 | 1.5 | 87 | 300 | 0.124818 | 0.0609 | 0.0001827
LEANTO COLUMN STIFFIN | PL/213 | +2.492 | +2.742 | 1.2 | 87.1 | 250 | 0.104218 | 0.05075 | 0.00015225
LEANTO COLUMN STIFFIN | PL/237 | +2.441 | +2.741 | 1.5 | 87 | 300 | 0.124818 | 0.0609 | 0.0001827

# IfcPlate: PLT3*233.2 (2)
In: Undefined
Description: PLT3*233.2; Material: STEEL/450
Tekla Common - Bottom elevation: +2.423; Top elevation: +2.681; Phase: 1; Class: 11
Tekla Quantity - Weight: 3.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.5 m2; Net surface area: 0.3 m2; Height: 233.2 mm; Width: 3 mm; Length: 606 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 233.197 mm; NetArea: 0.282042 m2; GrossArea: 0.141317 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000415175 m3; GrossVolume: 0.000415175 m3
Name | ASSEMBLY_POS = Reference
LEANTO BRACKET | PL/266
LEANTO BRACKET | PL/243

# IfcPlate: PLT3*233.7 (2)
In: Undefined
Description: PLT3*233.7; Material: STEEL/450
Tekla Common - Bottom elevation: +2.422; Top elevation: +2.680; Phase: 1; Class: 11
Tekla Quantity - Weight: 3.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.5 m2; Net surface area: 0.3 m2; Height: 233.7 mm; Width: 3 mm; Length: 616 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 233.719 mm; NetArea: 0.286709 m2; GrossArea: 0.143968 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000422085 m3; GrossVolume: 0.000422085 m3
Name | ASSEMBLY_POS = Reference
LEANTO BRACKET | PL/271
LEANTO BRACKET | PL/235

# IfcPlate: PLT3*235.3 (4)
In: Undefined
Description: PLT3*235.3; Material: STEEL/450
Tekla Common - Phase: 1; Class: 11
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.5 m2; Net surface area: 0.3 m2; Height: 235.3 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Length (mm) | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
LEANTO BRACKET | PL/279 | +2.420 | +2.679 | 3.5 | 645.5 | 235.268 | 0.300476 | 0.151854 | 0.00044247
LEANTO BRACKET | PL/267 | +2.399 | +2.677 | 3.3 | 614.9 | 235.331 | 0.284444 | 0.144706 | 0.00041873
LEANTO BRACKET | PL/258 | +2.399 | +2.677 | 3.3 | 614.9 | 235.331 | 0.284444 | 0.144706 | 0.00041873
LEANTO BRACKET | PL/234 | +2.420 | +2.679 | 3.5 | 645.5 | 235.268 | 0.300476 | 0.151854 | 0.00044247

# IfcPlate: PLT3*236.2 (2)
In: Undefined
Description: PLT3*236.2; Material: STEEL/450
Tekla Common - Bottom elevation: +2.397; Top elevation: +2.675; Phase: 1; Class: 11
Tekla Quantity - Weight: 3.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.5 m2; Net surface area: 0.3 m2; Height: 236.2 mm; Width: 3 mm; Length: 624.9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 236.195 mm; NetArea: 0.28912 m2; GrossArea: 0.14759 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000425654 m3; GrossVolume: 0.000425654 m3
Name | ASSEMBLY_POS = Reference
LEANTO BRACKET | PL/273
LEANTO BRACKET | PL/254

# IfcPlate: PLT3*238.8 (2)
In: Undefined
Description: PLT3*238.8; Material: STEEL/450
Tekla Common - Bottom elevation: +2.395; Top elevation: +2.672; Phase: 1; Class: 11
Tekla Quantity - Weight: 3.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.5 m2; Net surface area: 0.3 m2; Height: 238.8 mm; Width: 3 mm; Length: 654.2 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 238.764 mm; NetArea: 0.302917 m2; GrossArea: 0.156211 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000446084 m3; GrossVolume: 0.000446084 m3
Name | ASSEMBLY_POS = Reference
LEANTO BRACKET | PL/281
LEANTO BRACKET | PL/253

# IfcPlate: PLT3*242.7 (2)
In: Undefined
Description: PLT3*242.7; Material: STEEL/450
Tekla Common - Bottom elevation: +2.335; Top elevation: +2.682; Phase: 1; Class: 11
Tekla Quantity - Weight: 3.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.5 m2; Net surface area: 0.3 m2; Height: 242.7 mm; Width: 3 mm; Length: 648.3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 242.707 mm; NetArea: 0.294284 m2; GrossArea: 0.157339 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000433283 m3; GrossVolume: 0.000433283 m3
Name | ASSEMBLY_POS = Reference
LEANTO BRACKET | PL/289
LEANTO BRACKET | PL/288

# IfcPlate: PLT3*244.8 (2)
In: Undefined
Description: PLT3*244.8; Material: STEEL/450
Tekla Common - Bottom elevation: +2.333; Top elevation: +2.680; Phase: 1; Class: 11
Tekla Quantity - Weight: 3.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.5 m2; Net surface area: 0.3 m2; Height: 244.8 mm; Width: 3 mm; Length: 658 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 244.779 mm; NetArea: 0.299044 m2; GrossArea: 0.161076 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000440334 m3; GrossVolume: 0.000440334 m3
Name | ASSEMBLY_POS = Reference
LEANTO BRACKET | PL/295
LEANTO BRACKET | PL/291

# IfcPlate: PLT3*250 (6)
In: Undefined
Description: PLT3*250; Material: STEEL/450
Tekla Common - Phase: 1; Class: 9
Tekla Quantity - Weight: 1.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.1 m2; Height: 250 mm; Width: 3 mm; Length: 254 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 250 mm; NetArea: 0.130024 m2; GrossArea: 0.0635 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.0001905 m3; GrossVolume: 0.0001905 m3
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Area per tons (m2)
LEANTO COLUMN STIFFIN | Z/1965 | +2.485 | +2.735 | 87
2 x LEANTO COLUMN STIFFIN | PL/224 | +2.485 | +2.735 | 86.8
LEANTO COLUMN STIFFIN | Z/471 | +2.485 | +2.735 | 86.8
LEANTO COLUMN STIFFIN | Z/471 | +2.491 | +2.741 | 86.8
LEANTO COLUMN STIFFIN | PL/224 | +2.491 | +2.741 | 86.8
