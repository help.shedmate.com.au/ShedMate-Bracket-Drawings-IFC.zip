Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView_V2.0, QuantityTakeOffAddOnView], Option [BaseQuantities:On], Option [GridExport:On], Option [Assemblies:On], Option [Bolts:On], Option [Rebars:On], Option [PourObjects:Off], Option [Welds:Off], Option [SurfaceTreatments:Off], Option [LocationBy:0], Option [ViewColors:Off], Option [SectionedSpine:Off], Option [PropertySets:On], Option [Export all:Off]
File name: Single C-Section Leanto Bracket Hockey style.ifc
Time: 2026-03-26T07:36:19
Author: DESKTOP-BKNQL56\admin
Organization: Structural Designer
Written by: IFC Database Version: Work
Made in: Tekla Structures 2019 Service Pack 13, IFC Export Version: 4.0.0.0 Oct 18 2021

# IfcBuildingStorey, Undefined
In: Undefined
Elevation: 0 mm

# IfcBeam: C:150-24 (9)
In: Undefined
Description: C:150-24; Material: STEEL/G450
Tekla Common - Phase: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 152 mm; Width: 64 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Finish | Bottom elevation | Top elevation | Class | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x RAFTER | R/42 | 12 deg | +2.353 | +2.689 | 10 | 5 | 111.5 | 0.7 | 900.4 | 900.37 | 0.559345 | 0.000664257 | 5.21442
COLUMN | Z/966 | 5 deg | +0.000 | +3.500 | 12 | 19.5 | 111.2 | 2.2 | 3500 | 3500 | 2.17008 | 0.00258216 | 20.27
2 x RAFTER | R/41 | 5 deg | +2.461 | +2.691 | 10 | 5 | 111.5 | 0.7 | 900.4 | 900.37 | 0.559345 | 0.000664257 | 5.21442
COLUMN | Z/965 | 5 deg | +0.000 | +3.500 | 12 | 19.5 | 111.2 | 2.2 | 3500 | 3500 | 2.17008 | 0.00258216 | 20.27
2 x RAFTER | R/40 | 3 deg | +2.496 | +2.695 | 10 | 5 | 111.5 | 0.7 | 905.9 | 905.92 | 0.562784 | 0.000668352 | 5.24656
COLUMN | Z/964 | 3 deg | +0.000 | +3.500 | 12 | 19.5 | 111.2 | 2.2 | 3500 | 3500 | 2.17008 | 0.00258216 | 20.27

# IfcBeam: C:200-24 (9)
In: Undefined
Description: C:200-24; Material: STEEL/G450
Tekla Common - Phase: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 203 mm; Width: 76 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Finish | Bottom elevation | Top elevation | Class | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x RAFTER | Z/536 | 12 deg | +3.368 | +3.741 | 10 | 5.9 | 110.3 | 0.7 | 837.6 | 837.65 | 0.654891 | 0.000778813 | 6.11369
COLUMN | Z/537 | 12 deg | +0.000 | +5.063 | 12 | 35.9 | 110 | 3.9 | 5063.3 | 5063.16 | 3.9491 | 0.00470752 | 36.9541
2 x RAFTER | Z/534 | 5 deg | +3.469 | +3.745 | 10 | 5.9 | 110.3 | 0.7 | 837.6 | 837.65 | 0.654891 | 0.000778813 | 6.11369
COLUMN | Z/535 | 12 deg | +0.000 | +5.063 | 12 | 35.9 | 110 | 3.9 | 5063.3 | 5063.16 | 3.9491 | 0.00470752 | 36.9541
2 x RAFTER | Z/551 | 3 deg | +3.498 | +3.745 | 10 | 5.9 | 110.3 | 0.7 | 837.6 | 837.65 | 0.654891 | 0.000778813 | 6.11369
COLUMN | Z/969 | 12 deg | +0.000 | +5.063 | 12 | 35.9 | 110 | 3.9 | 5063.3 | 5063.16 | 3.9491 | 0.00470752 | 36.9541

# IfcBeam: C:250-24 (9)
In: Undefined
Description: C:250-24; Material: STEEL/G450
Tekla Common - Phase: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 254 mm; Width: 76 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Finish | Bottom elevation | Top elevation | Class | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x RAFTER | Z/1560 | 12 deg | +3.322 | +3.738 | 10 | 6.5 | 110 | 0.7 | 809.4 | 809.45 | 0.714092 | 0.000849728 | 6.67037
COLUMN | Z/1563 | 12 deg | +0.000 | +5.063 | 12 | 40.6 | 109.7 | 4.5 | 5063.3 | 5063.25 | 4.45573 | 0.0053152 | 41.7243
2 x RAFTER | Z/1558 | 5 deg | +3.419 | +3.743 | 10 | 6.5 | 110 | 0.7 | 809.4 | 809.45 | 0.714092 | 0.000849728 | 6.67037
COLUMN | Z/1562 | 12 deg | +0.000 | +5.063 | 12 | 40.6 | 109.7 | 4.5 | 5063.3 | 5063.25 | 4.45573 | 0.0053152 | 41.7243
2 x RAFTER | Z/980 | 3 deg | +3.448 | +3.744 | 10 | 6.5 | 110 | 0.7 | 809.4 | 809.45 | 0.714092 | 0.000849728 | 6.67037
COLUMN | Z/972 | 12 deg | +0.000 | +5.063 | 12 | 40.6 | 109.7 | 4.5 | 5063.3 | 5063.25 | 4.45573 | 0.0053152 | 41.7243

# IfcBeam: C:300-30 (9)
In: Undefined
Description: C:300-30; Material: STEEL/G450
Tekla Common - Phase: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 300 mm; Width: 96 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Finish | Bottom elevation | Top elevation | Class | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x RAFTER | Z/1567 | 12 deg | +3.196 | +3.736 | 10 | 14.8 | 87.5 | 1.3 | 1186 | 1186.01 | 1.29838 | 0.00193201 | 15.1663
COLUMN | Z/1570 | 12 deg | +0.011 | +5.063 | 12 | 63.2 | 87.3 | 5.5 | 5051.8 | 5051.81 | 5.51983 | 0.0082294 | 64.6008
2 x RAFTER | Z/1565 | 5 deg | +3.339 | +3.742 | 10 | 14.8 | 87.5 | 1.3 | 1186 | 1186.01 | 1.29838 | 0.00193201 | 15.1663
COLUMN | Z/1569 | 12 deg | +0.011 | +5.063 | 12 | 63.2 | 87.3 | 5.5 | 5051.8 | 5051.81 | 5.51983 | 0.0082294 | 64.6008
2 x RAFTER | Z/1564 | 3 deg | +3.370 | +3.731 | 10 | 14.8 | 87.5 | 1.3 | 1186 | 1186.01 | 1.29838 | 0.00193201 | 15.1663
COLUMN | Z/975 | 12 deg | +0.000 | +5.052 | 12 | 63.2 | 87.3 | 5.5 | 5051.8 | 5051.81 | 5.51983 | 0.0082294 | 64.6008

# IfcBeam: C:350-30 (9)
In: Undefined
Description: C:350-30; Material: STEEL/G450
Tekla Common - Phase: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 350 mm; Width: 125 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Finish | Bottom elevation | Top elevation | Class | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x RAFTER | Z/1573 | 12 deg | +3.151 | +3.734 | 10 | 17.3 | 87.3 | 1.5 | 1156.3 | 1156.35 | 1.50946 | 0.00224794 | 17.6464
COLUMN | Z/1576 | 12 deg | +0.011 | +5.063 | 12 | 75.5 | 87.1 | 6.6 | 5052 | 5052.04 | 6.58164 | 0.00982116 | 77.0961
2 x RAFTER | Z/977 | 5 deg | +3.290 | +3.740 | 10 | 17.3 | 87.3 | 1.5 | 1156.3 | 1156.35 | 1.50946 | 0.00224794 | 17.6464
COLUMN | Z/1575 | 12 deg | +0.011 | +5.063 | 12 | 75.5 | 87.1 | 6.6 | 5052 | 5052.04 | 6.58164 | 0.00982116 | 77.0961
2 x RAFTER | Z/1571 | 3 deg | +3.320 | +3.730 | 10 | 17.3 | 87.3 | 1.5 | 1156.3 | 1156.35 | 1.50946 | 0.00224794 | 17.6464
COLUMN | Z/979 | 12 deg | +0.000 | +5.052 | 12 | 75.5 | 87.1 | 6.6 | 5052 | 5052.04 | 6.58164 | 0.00982116 | 77.0961

# IfcBeam: TH:75-95 (30)
In: Undefined
Description: TH:75-95; Material: STEEL/300PLUS
Tekla Common - Phase: 1; Class: 4
Tekla Quantity - Weight: 1.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 0 m2; Net surface area: 0.4 m2; Height: 75 mm; Width: 125 mm; Length: 1000 mm
Pset_BeamCommon - LoadBearing: no
BaseQuantities - Length: 1000 mm; OuterSurfaceArea: 4.5602e-07 m2; NetVolume: 0.000231901 m3; NetWeight: 1.82042 kg
Name | ASSEMBLY_POS = Reference | Finish | Bottom elevation | Top elevation
2 x TH | Z/564 | 12 deg | +3.615 | +3.705
2 x TH | Z/563 | 5 deg | +3.690 | +3.772
4 x TH | Z/560 | 3 deg | +3.700 | +3.779
2 x TH | Z/564 | 12 deg | +3.612 | +3.702
2 x TH | Z/563 | 5 deg | +3.689 | +3.771
2 x TH | Z/564 | 12 deg | +3.609 | +3.699
2 x TH | Z/563 | 5 deg | +3.689 | +3.770
4 x TH | Z/560 | 3 deg | +3.711 | +3.790
2 x TH | Z/564 | 12 deg | +3.606 | +3.696
2 x TH | Z/563 | 5 deg | +3.688 | +3.770
2 x TH | B/23 | 12 deg | +2.530 | +2.620
2 x TH | B/21 | 5 deg | +2.625 | +2.707
2 x TH | B/20 | 3 deg | +2.657 | +2.737

# IfcColumn: C:150-24 (3)
In: Undefined
Description: C:150-24; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Top elevation: +3.500; Phase: 1; Class: 12
Tekla Quantity - Weight: 19.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 111.2 m2; Net surface area: 2.2 m2; Height: 152 mm; Width: 64 mm; Length: 3500 mm
BaseQuantities - Length: 3500 mm; OuterSurfaceArea: 2.17008 m2; NetVolume: 0.00258216 m3; NetWeight: 20.27 kg
Pset_ColumnCommon - LoadBearing: no
Name | Finish | ASSEMBLY_POS = Reference
COLUMN | 5 deg | Z/962
COLUMN | 5 deg | Z/961
COLUMN | 3 deg | Z/960

# IfcColumn: C:200-24 (3)
In: Undefined
Description: C:200-24; Material: STEEL/G450
Tekla Common - Finish: 12 deg; Bottom elevation: +0.000; Top elevation: +5.063; Phase: 1; Class: 12
Tekla Quantity - Weight: 35.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 110 m2; Net surface area: 3.9 m2; Height: 203 mm; Width: 76 mm; Length: 5063.3 mm
BaseQuantities - Length: 5063.16 mm; OuterSurfaceArea: 3.9491 m2; NetVolume: 0.00470752 m3; NetWeight: 36.9541 kg
Pset_ColumnCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference
COLUMN | Z/559
COLUMN | Z/557
COLUMN | Z/967

# IfcColumn: C:250-24 (3)
In: Undefined
Description: C:250-24; Material: STEEL/G450
Tekla Common - Finish: 12 deg; Bottom elevation: +0.000; Top elevation: +5.063; Phase: 1; Class: 12
Tekla Quantity - Weight: 40.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 109.7 m2; Net surface area: 4.5 m2; Height: 254 mm; Width: 76 mm; Length: 5063.3 mm
Pset_ColumnCommon - LoadBearing: no
BaseQuantities - Length: 5063.25 mm; OuterSurfaceArea: 4.45573 m2; NetVolume: 0.0053152 m3; NetWeight: 41.7243 kg
Name | ASSEMBLY_POS = Reference
COLUMN | Z/1561
COLUMN | Z/1559
COLUMN | Z/970

# IfcColumn: C:300-30 (3)
In: Undefined
Description: C:300-30; Material: STEEL/G450
Tekla Common - Finish: 12 deg; Phase: 1; Class: 12
Tekla Quantity - Weight: 63.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.3 m2; Net surface area: 5.5 m2; Height: 300 mm; Width: 96 mm; Length: 5051.8 mm
BaseQuantities - Length: 5051.81 mm; OuterSurfaceArea: 5.51983 m2; NetVolume: 0.0082294 m3; NetWeight: 64.6008 kg
Pset_ColumnCommon - LoadBearing: no
Name | Bottom elevation | Top elevation | ASSEMBLY_POS = Reference
COLUMN | +0.011 | +5.063 | Z/1568
COLUMN | +0.011 | +5.063 | Z/1566
COLUMN | +0.000 | +5.052 | Z/973

# IfcColumn: C:350-30 (3)
In: Undefined
Description: C:350-30; Material: STEEL/G450
Tekla Common - Finish: 12 deg; Phase: 1; Class: 12
Tekla Quantity - Weight: 75.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.1 m2; Net surface area: 6.6 m2; Height: 350 mm; Width: 125 mm; Length: 5052 mm
BaseQuantities - Length: 5052.04 mm; OuterSurfaceArea: 6.58164 m2; NetVolume: 0.00982116 m3; NetWeight: 77.0961 kg
Pset_ColumnCommon - LoadBearing: no
Name | Bottom elevation | Top elevation | ASSEMBLY_POS = Reference
COLUMN | +0.011 | +5.063 | Z/1574
COLUMN | +0.011 | +5.063 | Z/1572
COLUMN | +0.000 | +5.052 | Z/976

# IfcElementAssembly (150)
In: Undefined
PredefinedType: RIGID_FRAME
Name | ASSEMBLY_POSITION_CODE = Assembly/Cast unit position code | ASSEMBLY_POS = Assembly/Cast unit Mark | Assembly/Cast unit weight (kg) | Assembly/Cast unit bottom elevation | Assembly/Cast unit top elevation | Width (mm)
LEANTO COLUMN STIFFEN | C350>/3deg | Z/978 | 4.4 | +2.900 | +3.430 | 3
LEANTO COLUMN STIFFEN | C350>/5deg | Z/978 | 4.4 | +2.904 | +3.434 | 3
RAFTER | C350>/5deg-12deg | Z/1573 | 17.3 | +3.151 | +3.734 | 125
COLUMN | C350>/12deg | Z/1576 | 75.5 | +0.011 | +5.063 | 125
RAFTER | C350>/3deg-5deg | Z/977 | 17.3 | +3.290 | +3.740 | 125
COLUMN | C350>/5deg | Z/1575 | 75.5 | +0.011 | +5.063 | 125
LEANTO COLUMN STIFFEN | C350>/12deg | Z/978 | 4.4 | +2.879 | +3.409 | 3
RAFTER | C350>/<3deg | Z/1571 | 17.3 | +3.320 | +3.730 | 125
COLUMN | C350>/3deg | Z/979 | 75.5 | +0.000 | +5.052 | 125
LEANTO BRACKET | C350>/5deg-12deg | PL/682 | 8.4 | +2.929 | +3.682 | 95.5
2 x TH | C350>/5deg-12deg | Z/564 | 1.8 | +3.615 | +3.705 | 125
LEANTO BRACKET | C350>/3deg-5deg | PL/681 | 8.4 | +2.954 | +3.713 | 95.5
2 x TH | C350>/3deg-5deg | Z/563 | 1.8 | +3.690 | +3.772 | 125
LEANTO BRACKET | C350>/<3deg | PL/680 | 8.4 | +2.950 | +3.709 | 736.63
2 x TH | C350>/<3deg | Z/560 | 1.8 | +3.700 | +3.779 | 125
LEANTO COLUMN STIFFEN | C300-C350/3deg | Z/974 | 3.4 | +3.001 | +3.481 | 3
LEANTO COLUMN STIFFEN | C300-C350/5deg | Z/974 | 3.4 | +3.005 | +3.485 | 3
RAFTER | C300-C350/5deg-12deg | Z/1567 | 14.8 | +3.196 | +3.736 | 96
COLUMN | C300-C350/12deg | Z/1570 | 63.2 | +0.011 | +5.063 | 96
RAFTER | C300-C350/3deg-5deg | Z/1565 | 14.8 | +3.339 | +3.742 | 96
COLUMN | C300-C350/5deg | Z/1569 | 63.2 | +0.011 | +5.063 | 96
LEANTO COLUMN STIFFEN | C300-C350/12deg | Z/974 | 3.4 | +2.980 | +3.460 | 3
RAFTER | C300-C350/<3deg | Z/1564 | 14.8 | +3.370 | +3.731 | 96
COLUMN | C300-C350/3deg | Z/975 | 63.2 | +0.000 | +5.052 | 96
LEANTO BRACKET | C300-C350/5deg-12deg | PL/675 | 6.7 | +3.030 | +3.684 | 81
2 x TH | C300-C350/5deg-12deg | Z/564 | 1.8 | +3.612 | +3.702 | 125
LEANTO BRACKET | C300-C350/3deg-5deg | PL/674 | 6.5 | +3.055 | +3.714 | 81
2 x TH | C300-C350/3deg-5deg | Z/563 | 1.8 | +3.689 | +3.771 | 125
LEANTO BRACKET | C300-C350/<3deg | PL/673 | 6.5 | +3.051 | +3.711 | 81
2 x TH | C300-C350/<3deg | Z/560 | 1.8 | +3.700 | +3.779 | 125
LEANTO COLUMN STIFFEN | C250-C300/3deg | Z/971 | 2.6 | +3.111 | +3.541 | 3
LEANTO COLUMN STIFFEN | C250-C300/5deg | Z/971 | 2.6 | +3.104 | +3.534 | 3
LEANTO COLUMN STIFFEN | C250-C300/12deg | Z/971 | 2.6 | +3.080 | +3.510 | 3
RAFTER | C250-C300/5deg-12deg | Z/1560 | 6.5 | +3.322 | +3.738 | 76
COLUMN | C250-C300/12deg | Z/1563 | 40.6 | +0.000 | +5.063 | 76
RAFTER | C250-C300/3deg-5deg | Z/1558 | 6.5 | +3.419 | +3.743 | 76
COLUMN | C250-C300/5deg | Z/1562 | 40.6 | +0.000 | +5.063 | 76
RAFTER | C250-C300/<3deg | Z/980 | 6.5 | +3.448 | +3.744 | 76
COLUMN | C250-C300/3deg | Z/972 | 40.6 | +0.000 | +5.063 | 76
LEANTO BRACKET | C250-C300/5deg-12deg | PL/668 | 5.1 | +3.130 | +3.685 | 71
2 x TH | C250-C300/5deg-12deg | Z/564 | 1.8 | +3.609 | +3.699 | 125
LEANTO BRACKET | C250-C300/3deg-5deg | PL/667 | 5 | +3.154 | +3.714 | 71
2 x TH | C250-C300/3deg-5deg | Z/563 | 1.8 | +3.689 | +3.770 | 125
LEANTO BRACKET | C250-C300/<3deg | PL/666 | 5 | +3.161 | +3.721 | 71
2 x TH | C250-C300/<3deg | Z/560 | 1.8 | +3.711 | +3.790 | 125
LEANTO COLUMN STIFFEN | C200-C250/3deg | Z/968 | 1.8 | +3.213 | +3.593 | 3
LEANTO COLUMN STIFFEN | C200-C250/5deg | Z/968 | 1.8 | +3.206 | +3.586 | 3
RAFTER | C200-C250/5deg-12deg | Z/536 | 5.9 | +3.368 | +3.741 | 76
COLUMN | C200-C250/12deg | Z/537 | 35.9 | +0.000 | +5.063 | 76
RAFTER | C200-C250/3deg-5deg | Z/534 | 5.9 | +3.469 | +3.745 | 76
COLUMN | C200-C250/5deg | Z/535 | 35.9 | +0.000 | +5.063 | 76
LEANTO COLUMN STIFFEN | C200-C250/12deg | Z/968 | 1.8 | +3.182 | +3.562 | 3
RAFTER | C200-C250/<3deg | Z/551 | 5.9 | +3.498 | +3.745 | 76
COLUMN | C200-C250/3deg | Z/969 | 35.9 | +0.000 | +5.063 | 76
LEANTO BRACKET | C200-C250/5deg-12deg | PL/661 | 3.8 | +3.232 | +3.688 | 71
2 x TH | C200-C250/5deg-12deg | Z/564 | 1.8 | +3.606 | +3.696 | 125
LEANTO BRACKET | C200-C250/3deg-5deg | PL/660 | 3.7 | +3.256 | +3.716 | 71
2 x TH | C200-C250/3deg-5deg | Z/563 | 1.8 | +3.688 | +3.770 | 125
LEANTO BRACKET | C200-C250/<3deg | PL/659 | 3.7 | +3.263 | +3.723 | 71
2 x TH | C200-C250/<3deg | Z/560 | 1.8 | +3.711 | +3.790 | 125
LEANTO COLUMN STIFFEN | C150-C200/3deg | Z/963 | 1.1 | +2.282 | +2.592 | 3
LEANTO COLUMN STIFFEN | C150-C200/5deg | Z/963 | 1.1 | +2.270 | +2.580 | 3
LEANTO COLUMN STIFFEN | C150-C200/12deg | Z/963 | 1.1 | +2.240 | +2.550 | 3
RAFTER | C150-C200/5deg-12deg | R/42 | 5 | +2.353 | +2.689 | 64
COLUMN | C150-C200/12deg | Z/966 | 19.5 | +0.000 | +3.500 | 64
RAFTER | C150-C200/3deg-5deg | R/41 | 5 | +2.461 | +2.691 | 64
COLUMN | C150-C200/5deg | Z/965 | 19.5 | +0.000 | +3.500 | 64
RAFTER | C150-C200/<3deg | R/40 | 5 | +2.496 | +2.695 | 64
COLUMN | C150-C200/3deg | Z/964 | 19.5 | +0.000 | +3.500 | 64
LEANTO BRACKET | C150-C200/5deg-12deg | PL/653 | 2.3 | +2.290 | +2.627 | 65
2 x TH | C150-C200/5deg-12deg | B/23 | 1.8 | +2.530 | +2.620 | 125
LEANTO BRACKET | C150-C200/3deg-5deg | PL/652 | 2.2 | +2.320 | +2.659 | 65
2 x TH | C150-C200/3deg-5deg | B/21 | 1.8 | +2.625 | +2.707 | 125
LEANTO BRACKET | C150-C200/<3deg | PL/654 | 2.2 | +2.332 | +2.672 | 65
2 x TH | C150-C200/<3deg | B/20 | 1.8 | +2.657 | +2.737 | 125
LEANTO COLUMN STIFFEN | C350/3deg | PL/679 | 4.4 | +2.900 | +3.430 | 3
LEANTO COLUMN STIFFEN | C350/5deg | Z/978 | 4.4 | +2.904 | +3.434 | 3
LEANTO COLUMN STIFFEN | C300/3deg | PL/672 | 3.4 | +3.001 | +3.481 | 3
LEANTO COLUMN STIFFEN | C300/5deg | Z/974 | 3.4 | +3.005 | +3.485 | 3
LEANTO COLUMN STIFFEN | C250/3deg | PL/665 | 2.6 | +3.111 | +3.541 | 3
LEANTO COLUMN STIFFEN | C250/5deg | Z/971 | 2.6 | +3.104 | +3.534 | 3
LEANTO COLUMN STIFFEN | C250/12deg | Z/971 | 2.6 | +3.080 | +3.510 | 3
LEANTO COLUMN STIFFEN | C150/3deg | PL/651 | 1.1 | +2.282 | +2.592 | 3
LEANTO COLUMN STIFFEN | C150/5deg | Z/963 | 1.1 | +2.270 | +2.580 | 3
LEANTO COLUMN STIFFEN | C200/3deg | PL/658 | 1.8 | +3.213 | +3.593 | 3
LEANTO COLUMN STIFFEN | C200/5deg | Z/968 | 1.8 | +3.206 | +3.586 | 3
LEANTO COLUMN STIFFEN | C150/12deg | Z/963 | 1.1 | +2.240 | +2.550 | 3
COLUMN | C150/12deg | Z/962 | 19.5 | +0.000 | +3.500 | 64
RAFTER | C150/5deg-12deg | R/42 | 5 | +2.353 | +2.689 | 64
LEANTO BRACKET | C150/5deg-12deg | PL/650 | 2.3 | +2.290 | +2.627 | 65
COLUMN | C150/5deg | Z/961 | 19.5 | +0.000 | +3.500 | 64
RAFTER | C150/3deg-5deg | R/41 | 5 | +2.461 | +2.691 | 64
LEANTO BRACKET | C150/3deg-5deg | PL/649 | 2.2 | +2.320 | +2.659 | 65
COLUMN | C350/12deg | Z/1574 | 75.5 | +0.011 | +5.063 | 125
RAFTER | C350/5deg-12deg | Z/1573 | 17.3 | +3.151 | +3.734 | 125
LEANTO BRACKET | C350/5deg-12deg | PL/678 | 8.4 | +2.929 | +3.682 | 95.5
COLUMN | C300/12deg | Z/1568 | 63.2 | +0.011 | +5.063 | 96
RAFTER | C300/5deg-12deg | Z/1567 | 14.8 | +3.196 | +3.736 | 96
LEANTO BRACKET | C300/5deg-12deg | PL/671 | 6.7 | +3.030 | +3.684 | 81
COLUMN | C250/12deg | Z/1561 | 40.6 | +0.000 | +5.063 | 76
RAFTER | C250/5deg-12deg | Z/1560 | 6.5 | +3.322 | +3.738 | 76
LEANTO BRACKET | C250/5deg-12deg | PL/664 | 5.1 | +3.130 | +3.685 | 71
COLUMN | C200/12deg | Z/559 | 35.9 | +0.000 | +5.063 | 76
RAFTER | C200/5deg-12deg | Z/536 | 5.9 | +3.368 | +3.741 | 76
LEANTO BRACKET | C200/5deg-12deg | PL/657 | 3.8 | +3.232 | +3.688 | 71
COLUMN | C350/5deg | Z/1572 | 75.5 | +0.011 | +5.063 | 125
RAFTER | C350/3deg-5deg | Z/977 | 17.3 | +3.290 | +3.740 | 125
LEANTO BRACKET | C350/3deg-5deg | PL/677 | 8.4 | +2.954 | +3.713 | 95.5
COLUMN | C300/5deg | Z/1566 | 63.2 | +0.011 | +5.063 | 96
RAFTER | C300/3deg-5deg | Z/1565 | 14.8 | +3.339 | +3.742 | 96
LEANTO BRACKET | C300/3deg-5deg | PL/670 | 6.5 | +3.055 | +3.714 | 81
COLUMN | C250/5deg | Z/1559 | 40.6 | +0.000 | +5.063 | 76
RAFTER | C250/3deg-5deg | Z/1558 | 6.5 | +3.419 | +3.743 | 76
LEANTO BRACKET | C250/3deg-5deg | PL/663 | 5 | +3.154 | +3.714 | 71
COLUMN | C200/5deg | Z/557 | 35.9 | +0.000 | +5.063 | 76
RAFTER | C200/3deg-5deg | Z/534 | 5.9 | +3.469 | +3.745 | 76
LEANTO BRACKET | C200/3deg-5deg | PL/656 | 3.7 | +3.256 | +3.716 | 71
COLUMN | C150/3deg | Z/960 | 19.5 | +0.000 | +3.500 | 64
RAFTER | C150/<3deg | R/40 | 5 | +2.496 | +2.695 | 64
LEANTO BRACKET | C150/<3deg | PL/648 | 2.2 | +2.332 | +2.672 | 65
LEANTO COLUMN STIFFEN | C350/12deg | Z/978 | 4.4 | +2.879 | +3.409 | 3
LEANTO COLUMN STIFFEN | C300/12deg | Z/974 | 3.4 | +2.980 | +3.460 | 3
LEANTO COLUMN STIFFEN | C200/12deg | Z/968 | 1.8 | +3.182 | +3.562 | 3
COLUMN | C350/3deg | Z/976 | 75.5 | +0.000 | +5.052 | 125
RAFTER | C350/<3deg | Z/1571 | 17.3 | +3.320 | +3.730 | 125
LEANTO BRACKET | C350/<3deg | PL/676 | 8.4 | +2.950 | +3.709 | 736.63
COLUMN | C300/3deg | Z/973 | 63.2 | +0.000 | +5.052 | 96
RAFTER | C300/<3deg | Z/1564 | 14.8 | +3.370 | +3.731 | 96
LEANTO BRACKET | C300/<3deg | PL/669 | 6.5 | +3.051 | +3.711 | 81
RAFTER | C250/<3deg | Z/980 | 6.5 | +3.448 | +3.744 | 76
COLUMN | C250/3deg | Z/970 | 40.6 | +0.000 | +5.063 | 76
LEANTO BRACKET | C250/<3deg | PL/662 | 5 | +3.161 | +3.721 | 71
COLUMN | C200/3deg | Z/967 | 35.9 | +0.000 | +5.063 | 76
RAFTER | C200/<3deg | Z/551 | 5.9 | +3.498 | +3.745 | 76
LEANTO BRACKET | C200/<3deg | PL/655 | 3.7 | +3.263 | +3.723 | 71

# IfcMechanicalFastener: Bolt assembly (120)
In: Undefined
Tekla Bolt - Location: Site
Name | NominalDiameter (mm) = Washer diameter (mm) | NominalLength (mm) = Bolt length (mm) | Material = Bolt standard | Washer count = Nut count | Washer type | Washer name | Nut type | Nut name | Slotted hole y (mm) | Slotted hole x (mm) | Bolt hole diameter (mm) | Bolt count | Bolt size (mm) | Bolt Name
12 x Bolt assembly | 5 | 3 | TEK_16TPIM | 0 | UNDEF_WASH | UNDEFINED_WASHER5 | UNDEF_NUT | UNDEFINED_NUTM5 | 0 | 0 | 7 | 5 | 7 | TEKSCREW_M5*25
12 x Bolt assembly | 16 | 40 | 8.8S | 8 | HARD | WASHERM16-HARD | 8.8-HEX | NUTM16-8.8-HEX | 4 | 0 | 18 | 8 | 16 | BOLTM16*40
12 x Bolt assembly | 16 | 40 | 8.8S | 5 | HARD | WASHERM16-HARD | 8.8-HEX | NUTM16-8.8-HEX | 0 | 4 | 18 | 5 | 16 | BOLTM16*40
36 x Bolt assembly | 5 | 3 | TEK_16TPIM | 0 | UNDEF_WASH | UNDEFINED_WASHER5 | UNDEF_NUT | UNDEFINED_NUTM5 | 0 | 0 | 7 | 4 | 7 | TEKSCREW_M5*25
6 x Bolt assembly | 16 | 35 | 8.8S | 6 | HARD | WASHERM16-HARD | 8.8-HEX | NUTM16-8.8-HEX | 4 | 0 | 18 | 6 | 16 | BOLTM16*35
6 x Bolt assembly | 16 | 35 | 8.8S | 4 | HARD | WASHERM16-HARD | 8.8-HEX | NUTM16-8.8-HEX | 0 | 4 | 18 | 4 | 16 | BOLTM16*35
6 x Bolt assembly | 12 | 30 | 8.8S | 6 | HARD | WASHERM12-HARD | 8.8-HEX | NUTM12-8.8-HEX | 8 | 4 | 14 | 6 | 12 | BOLTM12*30
6 x Bolt assembly | 12 | 30 | 8.8S | 4 | HARD | WASHERM12-HARD | 8.8-HEX | NUTM12-8.8-HEX | 4 | 8 | 14 | 4 | 12 | BOLTM12*30
12 x Bolt assembly | 5 | 3 | TEK_16TPIM | 0 | UNDEF_WASH | UNDEFINED_WASHER5 | UNDEF_NUT | UNDEFINED_NUTM5 | 0 | 0 | 7 | 3 | 7 | TEKSCREW_M5*25
6 x Bolt assembly | 12 | 30 | 8.8S | 4 | HARD | WASHERM12-HARD | 8.8-HEX | NUTM12-8.8-HEX | 8 | 4 | 14 | 4 | 12 | BOLTM12*30
4 x Bolt assembly | 12 | 30 | 8.8S | 3 | HARD | WASHERM12-HARD | 8.8-HEX | NUTM12-8.8-HEX | 8 | 4 | 14 | 3 | 12 | BOLTM12*30
2 x Bolt assembly | 12 | 30 | 8.8S | 3 | HARD | WASHERM12-HARD | 8.8-HEX | NUTM12-8.8-HEX | 0 | 0 | 14 | 3 | 12 | BOLTM12*30

# IfcPlate: PLT3*152 (6)
In: Undefined
Description: PLT3*152; Material: STEEL/450
Tekla Common - Phase: 1; Class: 9
Tekla Quantity - Weight: 1.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.3 m2; Net surface area: 0.1 m2; Height: 152 mm; Width: 3 mm; Length: 310 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 152 mm; NetArea: 0.097012 m2; GrossArea: 0.04712 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00014136 m3; GrossVolume: 0.00014136 m3
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation
LEANTO COLUMN STIFFEN | Z/963 | +2.282 | +2.592
2 x LEANTO COLUMN STIFFEN | Z/963 | +2.270 | +2.580
2 x LEANTO COLUMN STIFFEN | Z/963 | +2.240 | +2.550
LEANTO COLUMN STIFFEN | PL/651 | +2.282 | +2.592

# IfcPlate: PLT3*203 (6)
In: Undefined
Description: PLT3*203; Material: STEEL/450
Tekla Common - Phase: 1; Class: 9
Tekla Quantity - Weight: 1.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.9 m2; Net surface area: 0.2 m2; Height: 203 mm; Width: 3 mm; Length: 380 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 203 mm; NetArea: 0.157778 m2; GrossArea: 0.07714 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00023142 m3; GrossVolume: 0.00023142 m3
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation
LEANTO COLUMN STIFFEN | Z/968 | +3.213 | +3.593
2 x LEANTO COLUMN STIFFEN | Z/968 | +3.206 | +3.586
2 x LEANTO COLUMN STIFFEN | Z/968 | +3.182 | +3.562
LEANTO COLUMN STIFFEN | PL/658 | +3.213 | +3.593

# IfcPlate: PLT3*218.2 (2)
In: Undefined
Description: PLT3*218.2; Material: STEEL/450
Tekla Common - Bottom elevation: +2.320; Top elevation: +2.659; Phase: 1; Class: 11
Tekla Quantity - Weight: 2.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.1 m2; Net surface area: 0.2 m2; Height: 218.2 mm; Width: 3 mm; Length: 619.1 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 218.191 mm; NetArea: 0.191207 m2; GrossArea: 0.135074 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000279333 m3; GrossVolume: 0.000279333 m3
Name | ASSEMBLY_POS = Reference
LEANTO BRACKET | PL/652
LEANTO BRACKET | PL/649

# IfcPlate: PLT3*219 (2)
In: Undefined
Description: PLT3*219; Material: STEEL/450
Tekla Common - Bottom elevation: +2.332; Top elevation: +2.672; Phase: 1; Class: 11
Tekla Quantity - Weight: 2.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.1 m2; Net surface area: 0.2 m2; Height: 219 mm; Width: 3 mm; Length: 619.9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 219.005 mm; NetArea: 0.190058 m2; GrossArea: 0.135764 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000277593 m3; GrossVolume: 0.000277593 m3
Name | ASSEMBLY_POS = Reference
LEANTO BRACKET | PL/654
LEANTO BRACKET | PL/648

# IfcPlate: PLT3*226.2 (2)
In: Undefined
Description: PLT3*226.2; Material: STEEL/450
Tekla Common - Bottom elevation: +2.290; Top elevation: +2.627; Phase: 1; Class: 11
Tekla Quantity - Weight: 2.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.1 m2; Net surface area: 0.2 m2; Height: 226.2 mm; Width: 3 mm; Length: 615.4 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 226.169 mm; NetArea: 0.196816 m2; GrossArea: 0.139174 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000287806 m3; GrossVolume: 0.000287806 m3
Name | ASSEMBLY_POS = Reference
LEANTO BRACKET | PL/653
LEANTO BRACKET | PL/650

# IfcPlate: PLT3*254 (6)
In: Undefined
Description: PLT3*254; Material: STEEL/450
Tekla Common - Phase: 1; Class: 9
Tekla Quantity - Weight: 2.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.5 m2; Net surface area: 0.2 m2; Height: 254 mm; Width: 3 mm; Length: 430 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 254 mm; NetArea: 0.222544 m2; GrossArea: 0.10922 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00032766 m3; GrossVolume: 0.00032766 m3
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation
LEANTO COLUMN STIFFEN | Z/971 | +3.111 | +3.541
2 x LEANTO COLUMN STIFFEN | Z/971 | +3.104 | +3.534
2 x LEANTO COLUMN STIFFEN | Z/971 | +3.080 | +3.510
LEANTO COLUMN STIFFEN | PL/665 | +3.111 | +3.541

# IfcPlate: PLT3*300 (6)
In: Undefined
Description: PLT3*300; Material: STEEL/450
Tekla Common - Phase: 1; Class: 9
Tekla Quantity - Weight: 3.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.4 m2; Height: 300 mm; Width: 3 mm; Length: 480 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 300 mm; NetArea: 0.29268 m2; GrossArea: 0.144 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000432 m3; GrossVolume: 0.000432 m3
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation
LEANTO COLUMN STIFFEN | Z/974 | +3.001 | +3.481
2 x LEANTO COLUMN STIFFEN | Z/974 | +3.005 | +3.485
2 x LEANTO COLUMN STIFFEN | Z/974 | +2.980 | +3.460
LEANTO COLUMN STIFFEN | PL/672 | +3.001 | +3.481

# IfcPlate: PLT3*350 (6)
In: Undefined
Description: PLT3*350; Material: STEEL/450
Tekla Common - Phase: 1; Class: 9
Tekla Quantity - Weight: 4.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.1 m2; Net surface area: 0.4 m2; Height: 350 mm; Width: 3 mm; Length: 530 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 350 mm; NetArea: 0.37628 m2; GrossArea: 0.1855 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.0005565 m3; GrossVolume: 0.0005565 m3
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation
LEANTO COLUMN STIFFEN | Z/978 | +2.900 | +3.430
2 x LEANTO COLUMN STIFFEN | Z/978 | +2.904 | +3.434
2 x LEANTO COLUMN STIFFEN | Z/978 | +2.879 | +3.409
LEANTO COLUMN STIFFEN | PL/679 | +2.900 | +3.430

# IfcPlate: PLT3*476 (2)
In: Undefined
Description: PLT3*476; Material: STEEL/450
Tekla Common - Bottom elevation: +3.263; Top elevation: +3.723; Phase: 1; Class: 11
Tekla Quantity - Weight: 3.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.6 m2; Net surface area: 0.4 m2; Height: 476 mm; Width: 3 mm; Length: 632.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 475.995 mm; NetArea: 0.322026 m2; GrossArea: 0.301132 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000473607 m3; GrossVolume: 0.000473607 m3
Name | ASSEMBLY_POS = Reference
LEANTO BRACKET | PL/659
LEANTO BRACKET | PL/655

# IfcPlate: PLT3*486.2 (2)
In: Undefined
Description: PLT3*486.2; Material: STEEL/450
Tekla Common - Bottom elevation: +3.256; Top elevation: +3.716; Phase: 1; Class: 11
Tekla Quantity - Weight: 3.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.6 m2; Net surface area: 0.4 m2; Height: 486.2 mm; Width: 3 mm; Length: 631.9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 486.216 mm; NetArea: 0.324544 m2; GrossArea: 0.307224 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000477408 m3; GrossVolume: 0.000477408 m3
Name | ASSEMBLY_POS = Reference
LEANTO BRACKET | PL/660
LEANTO BRACKET | PL/656

# IfcPlate: PLT3*519 (2)
In: Undefined
Description: PLT3*519; Material: STEEL/450
Tekla Common - Bottom elevation: +3.232; Top elevation: +3.688; Phase: 1; Class: 11
Tekla Quantity - Weight: 3.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.5 m2; Net surface area: 0.4 m2; Height: 519 mm; Width: 3 mm; Length: 626.2 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 518.967 mm; NetArea: 0.332413 m2; GrossArea: 0.324989 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000489301 m3; GrossVolume: 0.000489301 m3
Name | ASSEMBLY_POS = Reference
LEANTO BRACKET | PL/661
LEANTO BRACKET | PL/657

# IfcPlate: PLT3*575.9 (2)
In: Undefined
Description: PLT3*575.9; Material: STEEL/450
Tekla Common - Bottom elevation: +3.161; Top elevation: +3.721; Phase: 1; Class: 11
Tekla Quantity - Weight: 5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.4 m2; Height: 575.9 mm; Width: 3 mm; Length: 682.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 575.939 mm; NetArea: 0.430208 m2; GrossArea: 0.393162 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00063458 m3; GrossVolume: 0.00063458 m3
Name | ASSEMBLY_POS = Reference
LEANTO BRACKET | PL/666
LEANTO BRACKET | PL/662

# IfcPlate: PLT3*586 (2)
In: Undefined
Description: PLT3*586; Material: STEEL/450
Tekla Common - Bottom elevation: +3.154; Top elevation: +3.714; Phase: 1; Class: 11
Tekla Quantity - Weight: 5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.4 m2; Height: 586 mm; Width: 3 mm; Length: 681.9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 586.03 mm; NetArea: 0.432963 m2; GrossArea: 0.399605 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000638741 m3; GrossVolume: 0.000638741 m3
Name | ASSEMBLY_POS = Reference
LEANTO BRACKET | PL/667
LEANTO BRACKET | PL/663

# IfcPlate: PLT3*617.9 (2)
In: Undefined
Description: PLT3*617.9; Material: STEEL/450
Tekla Common - Bottom elevation: +3.130; Top elevation: +3.685; Phase: 1; Class: 11
Tekla Quantity - Weight: 5.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.4 m2; Height: 617.9 mm; Width: 3 mm; Length: 676.2 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 617.869 mm; NetArea: 0.44172 m2; GrossArea: 0.417823 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000651986 m3; GrossVolume: 0.000651986 m3
Name | ASSEMBLY_POS = Reference
LEANTO BRACKET | PL/668
LEANTO BRACKET | PL/664

# IfcPlate: PLT3*676.4 (2)
In: Undefined
Description: PLT3*676.4; Material: STEEL/450
Tekla Common - Bottom elevation: +3.051; Top elevation: +3.711; Phase: 1; Class: 11
Tekla Quantity - Weight: 6.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.1 m2; Net surface area: 0.7 m2; Height: 676.4 mm; Width: 3 mm; Length: 742.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 676.394 mm; NetArea: 0.560926 m2; GrossArea: 0.502312 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000829265 m3; GrossVolume: 0.000829265 m3
Name | ASSEMBLY_POS = Reference
LEANTO BRACKET | PL/673
LEANTO BRACKET | PL/669

# IfcPlate: PLT3*686.7 (2)
In: Undefined
Description: PLT3*686.7; Material: STEEL/450
Tekla Common - Bottom elevation: +3.055; Top elevation: +3.714; Phase: 1; Class: 11
Tekla Quantity - Weight: 6.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.1 m2; Net surface area: 0.7 m2; Height: 686.7 mm; Width: 3 mm; Length: 741.8 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 686.716 mm; NetArea: 0.563958 m2; GrossArea: 0.509431 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000833848 m3; GrossVolume: 0.000833848 m3
Name | ASSEMBLY_POS = Reference
LEANTO BRACKET | PL/674
LEANTO BRACKET | PL/670

# IfcPlate: PLT3*718.9 (2)
In: Undefined
Description: PLT3*718.9; Material: STEEL/450
Tekla Common - Bottom elevation: +3.030; Top elevation: +3.684; Phase: 1; Class: 11
Tekla Quantity - Weight: 6.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.1 m2; Net surface area: 0.7 m2; Height: 718.9 mm; Width: 3 mm; Length: 736.1 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 718.862 mm; NetArea: 0.573542 m2; GrossArea: 0.529128 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000848353 m3; GrossVolume: 0.000848353 m3
Name | ASSEMBLY_POS = Reference
LEANTO BRACKET | PL/675
LEANTO BRACKET | PL/671

# IfcPlate: PLT3*759.6 (2)
In: Undefined
Description: PLT3*759.6; Material: STEEL/450
Tekla Common - Bottom elevation: +2.950; Top elevation: +3.709; Phase: 1; Class: 11
Tekla Quantity - Weight: 8.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.7 m2; Height: 759.6 mm; Width: 3 mm; Length: 824.2 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 759.588 mm; NetArea: 0.712704 m2; GrossArea: 0.626051 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.0010555 m3; GrossVolume: 0.0010555 m3
Name | ASSEMBLY_POS = Reference
LEANTO BRACKET | PL/680
LEANTO BRACKET | PL/676

# IfcPlate: PLT3*787.8 (2)
In: Undefined
Description: PLT3*787.8; Material: STEEL/450
Tekla Common - Bottom elevation: +2.954; Top elevation: +3.713; Phase: 1; Class: 11
Tekla Quantity - Weight: 8.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.7 m2; Height: 787.8 mm; Width: 3 mm; Length: 806.3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 787.785 mm; NetArea: 0.715879 m2; GrossArea: 0.63518 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.0010603 m3; GrossVolume: 0.0010603 m3
Name | ASSEMBLY_POS = Reference
LEANTO BRACKET | PL/681
LEANTO BRACKET | PL/677

# IfcPlate: PLT3*800.2 (2)
In: Undefined
Description: PLT3*800.2; Material: STEEL/450
Tekla Common - Bottom elevation: +2.929; Top elevation: +3.682; Phase: 1; Class: 11
Tekla Quantity - Weight: 8.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.7 m2; Height: 800.2 mm; Width: 3 mm; Length: 820.8 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 800.2 mm; NetArea: 0.726165 m2; GrossArea: 0.656796 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00107588 m3; GrossVolume: 0.00107588 m3
Name | ASSEMBLY_POS = Reference
LEANTO BRACKET | PL/682
LEANTO BRACKET | PL/678
