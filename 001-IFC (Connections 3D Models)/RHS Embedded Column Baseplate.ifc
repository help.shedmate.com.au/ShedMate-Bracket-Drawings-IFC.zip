Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView_V2.0, QuantityTakeOffAddOnView], Option [BaseQuantities:On], Option [GridExport:On], Option [Assemblies:On], Option [Bolts:On], Option [Rebars:On], Option [PourObjects:Off], Option [Welds:Off], Option [SurfaceTreatments:On], Option [LocationBy:0], Option [ViewColors:Off], Option [SectionedSpine:Off], Option [PropertySets:On], Option [Export all:Off]
File name: R.ifc
Time: 2026-03-05T21:06:04
Author: DESKTOP-BQ0Q680\danie
Organization: Structural Designer
Written by: IFC Database Version: Work
Made in: Tekla Structures 2019 Service Pack 13, IFC Export Version: 4.0.0.0 Oct 18 2021

# IfcBuildingStorey, Undefined
In: Undefined
Elevation: 0 mm

# IfcColumn: RHS:100x50x5.0 (4)
In: Undefined
Description: RHS:100x50x5.0; Material: STEEL/300PLUS
Pset_ColumnCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
COLUMN | C/3(?) | 438 | 0.122202 | 0.0006132 | 4.81362
COLUMN | C/4(?) | 888 | 0.247752 | 0.0012432 | 9.75912
COLUMN | C/0(?) | 438 | 0.122202 | 0.0006132 | 4.81362
COLUMN | C/1(?) | 888 | 0.247752 | 0.0012432 | 9.75912

# IfcColumn: RHS:150x100x5.0 (4)
In: Undefined
Description: RHS:150x100x5.0; Material: STEEL/300PLUS
Pset_ColumnCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
COLUMN | C/3(?) | 438 | 0.209802 | 0.0010512 | 8.25192
COLUMN | C/4(?) | 888 | 0.425352 | 0.0021312 | 16.7299
COLUMN | C/0(?) | 438 | 0.209802 | 0.0010512 | 8.25192
COLUMN | C/1(?) | 888 | 0.425352 | 0.0021312 | 16.7299

# IfcColumn: RHS:150x50x5.0 (4)
In: Undefined
Description: RHS:150x50x5.0; Material: STEEL/300PLUS
Pset_ColumnCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
COLUMN | C/3(?) | 438 | 0.166002 | 0.0008322 | 6.53277
COLUMN | C/4(?) | 888 | 0.336552 | 0.0016872 | 13.2445
COLUMN | C/0(?) | 438 | 0.166002 | 0.0008322 | 6.53277
COLUMN | C/1(?) | 888 | 0.336552 | 0.0016872 | 13.2445

# IfcColumn: RHS:200x100x5.0 (4)
In: Undefined
Description: RHS:200x100x5.0; Material: STEEL/300PLUS
Pset_ColumnCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
COLUMN | C/3(?) | 438 | 0.253602 | 0.0012702 | 9.97107
COLUMN | C/4(?) | 888 | 0.514152 | 0.0025752 | 20.2153
COLUMN | C/0(?) | 438 | 0.253602 | 0.0012702 | 9.97107
COLUMN | C/1(?) | 888 | 0.514152 | 0.0025752 | 20.2153

# IfcColumn: RHS:250x150x5.0 (4)
In: Undefined
Description: RHS:250x150x5.0; Material: STEEL/300PLUS
Pset_ColumnCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
COLUMN | C/3(?) | 438 | 0.341202 | 0.0017082 | 13.4094
COLUMN | C/4(?) | 888 | 0.691752 | 0.0034632 | 27.1861
COLUMN | C/0(?) | 438 | 0.341202 | 0.0017082 | 13.4094
COLUMN | C/1(?) | 888 | 0.691752 | 0.0034632 | 27.1861

# IfcDiscreteAccessory: BASEPLATE (30)
In: Undefined
Material: STEEL/450
Name | Description | NetArea (m2) = GrossArea (m2) | CrossSectionArea (m2) | NetVolume (m3) = GrossVolume (m3)
4 x BASEPLATE | PLT12*270 | 0.21516 | 0.00324 | 0.0011988
2 x BASEPLATE | PLT6*210 | 0.13644 | 0.00126 | 0.0003906
4 x BASEPLATE | PLT12*220 | 0.15376 | 0.00264 | 0.0008448
2 x BASEPLATE | PLT6*160 | 0.08824 | 0.00096 | 0.0002496
4 x BASEPLATE | PLT12*220 | 0.13056 | 0.00264 | 0.0007128
2 x BASEPLATE | PLT6*160 | 0.07164 | 0.00096 | 0.0002016
4 x BASEPLATE | PLT12*170 | 0.10236 | 0.00204 | 0.0005508
BASEPLATE | FL6*110 | 0.05004 | 0.00066 | 0.0001386
BASEPLATE | FL6*110 | 0.05584 | 0.00066 | 0.0001551
4 x BASEPLATE | PLT12*170 | 0.08416 | 0.00204 | 0.0004488
2 x BASEPLATE | FL6*110 | 0.03844 | 0.00066 | 0.0001056

# IfcElementAssembly (30)
In: Undefined
PredefinedType: RIGID_FRAME
Name | ASSEMBLY_POSITION_CODE | ASSEMBLY_POS | Width (mm)
COLUMN | RHS250X150/TYPE2 | C/4(?) | 270
COLUMN | RHS250X150/TYPE2 | C/3(?) | 270
BASEPLATE | RHS250X150/TYPE2 | A/7(?) | 6
COLUMN | RHS200X100/TYPE2 | C/4(?) | 220
COLUMN | RHS200X100/TYPE2 | C/3(?) | 220
BASEPLATE | RHS200X100/TYPE2 | A/7(?) | 6
COLUMN | RHS150X100/TYPE2 | C/4(?) | 220
COLUMN | RHS150X100/TYPE2 | C/3(?) | 220
BASEPLATE | RHS150X100/TYPE2 | A/7(?) | 6
COLUMN | RHS150X50/TYPE2 | C/4(?) | 170
COLUMN | RHS150X50/TYPE2 | C/3(?) | 170
BASEPLATE | RHS150X50/TYPE2 | A/7(?) | 6
COLUMN | RHS250X150/TYPE1 | C/1(?) | 270
COLUMN | RHS250X150/TYPE1 | C/0(?) | 270
BASEPLATE | RHS250X150/TYPE1 | A/7(?) | 6
COLUMN | RHS200X100/TYPE1 | C/1(?) | 220
COLUMN | RHS200X100/TYPE1 | C/0(?) | 220
BASEPLATE | RHS200X100/TYPE1 | A/7(?) | 6
COLUMN | RHS150X100/TYPE1 | C/1(?) | 220
COLUMN | RHS150X100/TYPE1 | C/0(?) | 220
BASEPLATE | RHS150X100/TYPE1 | A/7(?) | 6
COLUMN | RHS150X50/TYPE1 | C/1(?) | 170
COLUMN | RHS150X50/TYPE1 | C/0(?) | 170
BASEPLATE | RHS150X50/TYPE1 | A/7(?) | 6
COLUMN | RHS100X50/TYPE1 | C/1(?) | 170
COLUMN | RHS100X50/TYPE2 | C/4(?) | 170
COLUMN | RHS100X50/TYPE2 | C/3(?) | 170
BASEPLATE | RHS100X50/TYPE2 | A/7(?) | 6
BASEPLATE | RHS100X50/TYPE1 | A/7(?) | 6
COLUMN | RHS100X50/TYPE1 | C/0(?) | 170

# IfcMechanicalFastener: Bolt assembly (10)
In: Undefined
NominalDiameter: 16 mm; NominalLength: 50 mm; Material: 8.8S
