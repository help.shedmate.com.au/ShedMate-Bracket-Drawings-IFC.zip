Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView_V2.0, QuantityTakeOffAddOnView], Option [BaseQuantities:On], Option [GridExport:On], Option [Assemblies:On], Option [Bolts:On], Option [Rebars:On], Option [PourObjects:Off], Option [Welds:Off], Option [SurfaceTreatments:On], Option [LocationBy:0], Option [ViewColors:Off], Option [SectionedSpine:Off], Option [PropertySets:On], Option [Export all:Off]
File name: STRAP FLYBRACING.ifc
Time: 2026-08-22T18:24:31
Author: LAPTOP-2P0BGI6B\lablab
Organization: Structural Designer
Written by: IFC Database Version: Work
Made in: Tekla Structures 2019 Service Pack 13, IFC Export Version: 4.0.0.0 Oct 18 2021

# IfcBuildingStorey, Undefined
In: Undefined
Elevation: 0 mm

# IfcBeam: C:150-12, RAFTER
In: Undefined
Description: C:150-12; Material: STEEL/G450
Default - ASSEMBLY_POS: Z/2675(?)
Pset_BeamCommon - LoadBearing: no; Reference: Z/2675(?)
BaseQuantities - Length: 3942.51 mm; OuterSurfaceArea: 2.40882 m2; NetVolume: 0.00143917 m3; NetWeight: 11.2975 kg

# IfcBeam: C:150-24, COLUMN
In: Undefined
Description: C:150-24; Material: STEEL/G450
Default - ASSEMBLY_POS: Z/2676
Pset_BeamCommon - LoadBearing: no; Reference: Z/2676
BaseQuantities - Length: 5063.14 mm; OuterSurfaceArea: 3.1386 m2; NetVolume: 0.00373538 m3; NetWeight: 29.3228 kg

# IfcBeam: Z:100-10 (2)
In: Undefined
Description: Z:100-10; Material: STEEL/300PLUS
Default - ASSEMBLY_POS: Z/2672(?)
Pset_BeamCommon - LoadBearing: no; Reference: Z/2672(?)
BaseQuantities - Length: 875 mm; OuterSurfaceArea: 0.39595 m2; NetVolume: 0.000196875 m3; NetWeight: 1.54547 kg

# IfcCovering: 12 deg (2)
In: Undefined
Material: Undefined/Undefined

# IfcDiscreteAccessory: PURLIN_CLEAT
In: Undefined
Description: PLT8*64; Material: STEEL/250
BaseQuantities - NetArea: 0.014848 m2; GrossArea: 0.014848 m2; CrossSectionArea: 0.000512 m2; NetVolume: 0.000049152 m3; GrossVolume: 0.000049152 m3

# IfcElementAssembly (8)
In: Undefined
PredefinedType: RIGID_FRAME
Name | ASSEMBLY_POSITION_CODE | ASSEMBLY_POS | Width (mm)
Flybrace | M12 Turnbuckle/- | FB/23(?) | 153.2
TH | M12 Turnbuckle>/- | Z/2672(?) | 101
TH | M8 Turnbuckle-M12 Turnbuckle/- | Z/2672(?) | 101
RAFTER | M12 Turnbuckle/- | Z/2675(?) | 64
COLUMN | M12 Turnbuckle/ | Z/2676 | 64
PLATE | M12 Turnbuckle/ | P/1 | 49
BRACING | M12 Turnbuckle/ | Z/2650 | 21
PLATE | M12 Turnbuckle/ | Z/2673 | 72.5

# IfcMechanicalFastener: Bolt assembly (19)
In: Undefined
Name | NominalDiameter (mm) | NominalLength (mm) | Material
Bolt assembly | 10 | 18.4 | 14-10x25 Hex (Cat 5)
2 x Bolt assembly | 5 | 12.7 | SCREW
6 x Bolt assembly | 12 | 30 | PB1230
7 x Bolt assembly | 12 | 1 | PB1230
Bolt assembly | 12 | 6 | 8.8S
2 x Bolt assembly | 12 | 30 | 8.8S

# IfcMember: M12_NUT, BRACING
In: Undefined
Description: M12_NUT; Material: STEEL/250
Pset_MemberCommon - LoadBearing: no; Reference: Z/2650
BaseQuantities - Length: 8.00018 mm; OuterSurfaceArea: 0.00107689 m2; GrossSurfaceArea: 0 m2; CrossSectionArea: 0.000286 m2; NetVolume: 0.00000229156 m3; GrossVolume: 0.00000228805 m3; NetWeight: 0.0179887 kg; GrossWeight: 0.0179612 kg

# IfcPlate: FL6*40, PLATE
In: Undefined
Description: FL6*40; Material: STEEL/250
Default - ASSEMBLY_POS: P/1
Pset_PlateCommon - LoadBearing: no; Reference: P/1
BaseQuantities - Width: 40 mm; NetArea: 0.0156269 m2; GrossArea: 0.00641699 m2; CrossSectionArea: 0.000036 m2; NetVolume: 0.0000392947 m3; GrossVolume: 0.0000392947 m3

# IfcPlate: PLT1.2*30, Flybrace
In: Undefined
Description: PLT1.2*30; Material: STEEL/.
Default - ASSEMBLY_POS: FB/23(?)
Pset_PlateCommon - LoadBearing: no; Reference: FB/23(?)
BaseQuantities - Width: 30 mm; NetArea: 0.0361668 m2; GrossArea: 0.0172814 m2; CrossSectionArea: 0.00000144 m2; NetVolume: 0.0000213116 m3; GrossVolume: 0.0000213116 m3

# IfcPlate: PLT3*313.3, PLATE
In: Undefined
Description: PLT3*313.3; Material: STEEL/G450
Default - ASSEMBLY_POS: Z/2673
Pset_PlateCommon - LoadBearing: no; Reference: Z/2673
BaseQuantities - Width: 313.286 mm; NetArea: 0.21672 m2; GrossArea: 0.139471 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000318273 m3; GrossVolume: 0.000318273 m3
