Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView_V2.0, QuantityTakeOffAddOnView], Option [BaseQuantities:On], Option [GridExport:On], Option [Assemblies:On], Option [Bolts:On], Option [Rebars:On], Option [PourObjects:Off], Option [Welds:Off], Option [SurfaceTreatments:Off], Option [LocationBy:0], Option [ViewColors:Off], Option [SectionedSpine:Off], Option [PropertySets:On], Option [Export all:Off]
File name: Inline Fascia Plate.ifc
Time: 2026-04-17T10:38:35
Author: DESKTOP-BKNQL56\admin
Organization: Structural Designer
Written by: IFC Database Version: Work
Made in: Tekla Structures 2019 Service Pack 13, IFC Export Version: 4.0.0.0 Oct 18 2021

# IfcBuildingStorey, Undefined
In: Undefined
Elevation: 0 mm

# IfcBeam: C:100-15 (30)
In: Undefined
Description: C:100-15; Material: STEEL/G450
Tekla Common - Bottom elevation: +2.398; Top elevation: +2.500; Phase: 1; Class: 13
Tekla Quantity - Weight: 0.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 179.6 m2; Net surface area: 0.1 m2; Height: 102 mm; Width: 51 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
6 x FASCIA | F/32 | 279 | 0.127062 | 0.0000941625 | 0.739176
12 x FASCIA | F/28 | 289 | 0.131592 | 0.0000975375 | 0.765669
6 x FASCIA | F/24 | 295 | 0.13431 | 0.0000995625 | 0.781566
6 x FASCIA | F/36 | 264.5 | 0.120494 | 0.0000892688 | 0.70076

# IfcBeam: C:150-15 (30)
In: Undefined
Description: C:150-15; Material: STEEL/G450
Tekla Common - Bottom elevation: +1.848; Top elevation: +2.000; Phase: 1; Class: 13
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 177.2 m2; Net surface area: 0.2 m2; Height: 152 mm; Width: 64 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Weight (kg) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
6 x FASCIA | F/31 | 1 | 279 | 0.171942 | 0.000127643 | 1.00199
12 x FASCIA | F/27 | 1 | 289 | 0.178072 | 0.000132218 | 1.03791
6 x FASCIA | F/23 | 1 | 295 | 0.18175 | 0.000134963 | 1.05946
6 x FASCIA | F/35 | 0.8 | 264.5 | 0.163054 | 0.000121009 | 0.949919

# IfcBeam: C:150-24 (2)
In: Undefined
Description: C:150-24; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Top elevation: +2.500; Phase: 1; Class: 12
Default - ASSEMBLY_POS: C/42
Tekla Quantity - Weight: 13.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 111.3 m2; Net surface area: 1.6 m2; Height: 152 mm; Width: 64 mm; Length: 2500 mm
Pset_BeamCommon - LoadBearing: no; Reference: C/42
BaseQuantities - Length: 2500 mm; OuterSurfaceArea: 1.55048 m2; NetVolume: 0.0018444 m3; NetWeight: 14.4785 kg

# IfcBeam: C:200-15 (30)
In: Undefined
Description: C:200-15; Material: STEEL/G450
Tekla Common - Bottom elevation: +1.297; Top elevation: +1.500; Phase: 1; Class: 13
Tekla Quantity - Weight: 1.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.2 m2; Height: 203 mm; Width: 76 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Area per tons (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
6 x FASCIA | F/30 | 176.1 | 279 | 0.214017 | 0.00015903 | 1.24839
12 x FASCIA | F/26 | 176 | 289 | 0.221647 | 0.00016473 | 1.29313
6 x FASCIA | F/22 | 176 | 295 | 0.226225 | 0.00016815 | 1.31998
6 x FASCIA | F/34 | 176.1 | 264.5 | 0.202954 | 0.000150765 | 1.18351

# IfcBeam: C:200-24 (2)
In: Undefined
Description: C:200-24; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Top elevation: +2.500; Phase: 1; Class: 12
Default - ASSEMBLY_POS: C/44
Tekla Quantity - Weight: 17.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 110.1 m2; Net surface area: 2 m2; Height: 203 mm; Width: 76 mm; Length: 2500 mm
Pset_BeamCommon - LoadBearing: no; Reference: C/44
BaseQuantities - Length: 2500 mm; OuterSurfaceArea: 1.95086 m2; NetVolume: 0.0023244 m3; NetWeight: 18.2465 kg

# IfcBeam: C:250-19 (30)
In: Undefined
Description: C:250-19; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.746; Top elevation: +1.000; Phase: 1; Class: 13
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 138.8 m2; Height: 254 mm; Width: 76 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
6 x FASCIA | F/29 | 1.8 | 0.2 | 279 | 0.245668 | 0.000230806 | 1.81182
12 x FASCIA | F/25 | 1.8 | 0.3 | 289 | 0.254414 | 0.000239078 | 1.87676
6 x FASCIA | F/21 | 1.9 | 0.3 | 295 | 0.259662 | 0.000244042 | 1.91573
6 x FASCIA | F/33 | 1.8 | 0.2 | 264.5 | 0.232986 | 0.00021881 | 1.71766

# IfcBeam: C:250-24 (2)
In: Undefined
Description: C:250-24; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Top elevation: +2.500; Phase: 1; Class: 12
Default - ASSEMBLY_POS: C/46
Tekla Quantity - Weight: 20.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 109.7 m2; Net surface area: 2.2 m2; Height: 254 mm; Width: 76 mm; Length: 2500 mm
Pset_BeamCommon - LoadBearing: no; Reference: C/46
BaseQuantities - Length: 2500 mm; OuterSurfaceArea: 2.2011 m2; NetVolume: 0.0026244 m3; NetWeight: 20.6015 kg

# IfcBeam: C:300-24 (2)
In: Undefined
Description: C:300-24; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Top elevation: +2.500; Phase: 1; Class: 12
Default - ASSEMBLY_POS: C/49
Tekla Quantity - Weight: 24.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 108.6 m2; Net surface area: 2.7 m2; Height: 300 mm; Width: 96 mm; Length: 2500 mm
Pset_BeamCommon - LoadBearing: no; Reference: C/49
BaseQuantities - Length: 2500 mm; OuterSurfaceArea: 2.70158 m2; NetVolume: 0.0032244 m3; NetWeight: 25.3115 kg

# IfcBeam: C:350-30 (2)
In: Undefined
Description: C:350-30; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Top elevation: +2.500; Phase: 1; Class: 12
Tekla Quantity - Weight: 37.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.2 m2; Net surface area: 3.3 m2; Height: 350 mm; Width: 125 mm; Length: 2500 mm
Pset_BeamCommon - LoadBearing: no
BaseQuantities - Length: 2500 mm; OuterSurfaceArea: 3.25889 m2; NetVolume: 0.00486 m3; NetWeight: 38.151 kg
Name | ASSEMBLY_POS = Reference
COLUMN | C/52
COLUMN | C/51

# IfcColumn: C:150-24 (4)
In: Undefined
Description: C:150-24; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Top elevation: +2.500; Phase: 1; Class: 12
Tekla Quantity - Weight: 13.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 111.3 m2; Net surface area: 1.6 m2; Height: 152 mm; Width: 64 mm; Length: 2500 mm
BaseQuantities - Length: 2500 mm; OuterSurfaceArea: 1.55048 m2; NetVolume: 0.0018444 m3; NetWeight: 14.4785 kg
Default - ASSEMBLY_POS: C/41
Pset_ColumnCommon - LoadBearing: no; Reference: C/41

# IfcColumn: C:200-24 (4)
In: Undefined
Description: C:200-24; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Top elevation: +2.500; Phase: 1; Class: 12
Tekla Quantity - Weight: 17.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 110.1 m2; Net surface area: 2 m2; Height: 203 mm; Width: 76 mm; Length: 2500 mm
BaseQuantities - Length: 2500 mm; OuterSurfaceArea: 1.95086 m2; NetVolume: 0.0023244 m3; NetWeight: 18.2465 kg
Default - ASSEMBLY_POS: C/43
Pset_ColumnCommon - LoadBearing: no; Reference: C/43

# IfcColumn: C:250-24 (4)
In: Undefined
Description: C:250-24; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Top elevation: +2.500; Phase: 1; Class: 12
Tekla Quantity - Weight: 20.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 109.7 m2; Net surface area: 2.2 m2; Height: 254 mm; Width: 76 mm; Length: 2500 mm
BaseQuantities - Length: 2500 mm; OuterSurfaceArea: 2.2011 m2; NetVolume: 0.0026244 m3; NetWeight: 20.6015 kg
Default - ASSEMBLY_POS: C/45
Pset_ColumnCommon - LoadBearing: no; Reference: C/45

# IfcColumn: C:300-24 (4)
In: Undefined
Description: C:300-24; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Top elevation: +2.500; Phase: 1; Class: 12
Tekla Quantity - Weight: 24.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 108.6 m2; Net surface area: 2.7 m2; Height: 300 mm; Width: 96 mm; Length: 2500 mm
BaseQuantities - Length: 2500 mm; OuterSurfaceArea: 2.70158 m2; NetVolume: 0.0032244 m3; NetWeight: 25.3115 kg
Pset_ColumnCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference
3 x COLUMN | C/47
COLUMN | C/48

# IfcColumn: C:350-30 (4)
In: Undefined
Description: C:350-30; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Top elevation: +2.500; Phase: 1; Class: 12
Tekla Quantity - Weight: 37.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.2 m2; Net surface area: 3.3 m2; Height: 350 mm; Width: 125 mm; Length: 2500 mm
BaseQuantities - Length: 2500 mm; OuterSurfaceArea: 3.25889 m2; NetVolume: 0.00486 m3; NetWeight: 38.151 kg
Default - ASSEMBLY_POS: C/50
Pset_ColumnCommon - LoadBearing: no; Reference: C/50

# IfcElementAssembly (230)
In: Undefined
PredefinedType: RIGID_FRAME
Name | ASSEMBLY_POSITION_CODE = Assembly/Cast unit position code | ASSEMBLY_POS = Assembly/Cast unit Mark | Assembly/Cast unit weight (kg) | Assembly/Cast unit bottom elevation | Assembly/Cast unit top elevation | Width (mm)
INLINE FASCIA PLATE | C150/2Ctype2 | Z/1930 | 0.8 | +1.348 | +1.449 | 3
COLUMN | C150/2Ctype2 | C/42 | 13.9 | +0.000 | +2.500 | 64
COLUMN | C150/2Ctype2 | C/41 | 13.9 | +0.000 | +2.500 | 64
INLINE FASCIA PLATE | C200/2Ctype2 | Z/1931 | 0.8 | +1.348 | +1.449 | 3
COLUMN | C200/2Ctype2 | C/44 | 17.7 | +0.000 | +2.500 | 76
COLUMN | C200/2Ctype2 | C/43 | 17.7 | +0.000 | +2.500 | 76
INLINE FASCIA PLATE | C250/2Ctype2 | Z/1931 | 0.8 | +1.348 | +1.449 | 3
COLUMN | C250/2Ctype2 | C/46 | 20.1 | +0.000 | +2.500 | 76
COLUMN | C250/2Ctype2 | C/45 | 20.1 | +0.000 | +2.500 | 76
INLINE FASCIA PLATE | C300/2Ctype2 | Z/1940 | 0.8 | +1.348 | +1.449 | 3
COLUMN | C300/2Ctype2 | C/49 | 24.9 | +0.000 | +2.500 | 96
COLUMN | C300/2Ctype2 | C/47 | 24.9 | +0.000 | +2.500 | 96
FASCIA | C300/2Ctype2 | F/30 | 1.2 | +1.297 | +1.500 | 76
FASCIA | C250/2Ctype2 | F/26 | 1.2 | +1.297 | +1.500 | 76
FASCIA | C200/2Ctype2 | F/26 | 1.2 | +1.297 | +1.500 | 76
FASCIA | C150/2Ctype2 | F/22 | 1.2 | +1.297 | +1.500 | 76
COLUMN | C350/2Ctype2 | C/52 | 37.4 | +0.000 | +2.500 | 125
COLUMN | C350/2Ctype2 | C/50 | 37.4 | +0.000 | +2.500 | 125
INLINE FASCIA PLATE | C350/2Ctype2 | PL/829 | 0.8 | +1.348 | +1.449 | 3
FASCIA | C350/2Ctype2 | F/34 | 1.2 | +1.297 | +1.500 | 76
INLINE FASCIA PLATE | C150/2Ctype1 | Z/1909 | 1 | +1.348 | +1.449 | 3
COLUMN | C150/2Ctype1 | C/42 | 13.9 | +0.000 | +2.500 | 64
COLUMN | C150/2Ctype1 | C/41 | 13.9 | +0.000 | +2.500 | 64
INLINE FASCIA PLATE | C200/2Ctype1 | Z/1928 | 1 | +1.348 | +1.449 | 3
COLUMN | C200/2Ctype1 | C/44 | 17.7 | +0.000 | +2.500 | 76
COLUMN | C200/2Ctype1 | C/43 | 17.7 | +0.000 | +2.500 | 76
INLINE FASCIA PLATE | C250/2Ctype1 | Z/1928 | 1 | +1.348 | +1.449 | 3
COLUMN | C250/2Ctype1 | C/46 | 20.1 | +0.000 | +2.500 | 76
COLUMN | C250/2Ctype1 | C/45 | 20.1 | +0.000 | +2.500 | 76
INLINE FASCIA PLATE | C300/2Ctype1 | Z/1929 | 1 | +1.348 | +1.449 | 3
COLUMN | C300/2Ctype1 | C/49 | 24.9 | +0.000 | +2.500 | 96
COLUMN | C300/2Ctype1 | C/47 | 24.9 | +0.000 | +2.500 | 96
2 x FASCIA | C300/2Ctype1 | F/30 | 1.2 | +1.297 | +1.500 | 76
2 x FASCIA | C250/2Ctype1 | F/26 | 1.2 | +1.297 | +1.500 | 76
2 x FASCIA | C200/2Ctype1 | F/26 | 1.2 | +1.297 | +1.500 | 76
2 x FASCIA | C150/2Ctype1 | F/22 | 1.2 | +1.297 | +1.500 | 76
COLUMN | C350/2Ctype1 | C/51 | 37.4 | +0.000 | +2.500 | 125
COLUMN | C350/2Ctype1 | C/50 | 37.4 | +0.000 | +2.500 | 125
2 x FASCIA | C350/2Ctype1 | F/34 | 1.2 | +1.297 | +1.500 | 76
INLINE FASCIA PLATE | C150/1Ctype2 | Z/1897 | 0.5 | +1.348 | +1.449 | 3
COLUMN | C150/1Ctype2 | C/41 | 13.9 | +0.000 | +2.500 | 64
INLINE FASCIA PLATE | C200/1Ctype2 | Z/1907 | 0.5 | +1.348 | +1.449 | 3
COLUMN | C200/1Ctype2 | C/43 | 17.7 | +0.000 | +2.500 | 76
INLINE FASCIA PLATE | C250/1Ctype2 | Z/1907 | 0.5 | +1.348 | +1.449 | 3
COLUMN | C250/1Ctype2 | C/45 | 20.1 | +0.000 | +2.500 | 76
INLINE FASCIA PLATE | C300/1Ctype2 | Z/1908 | 0.5 | +1.348 | +1.449 | 3
COLUMN | C300/1Ctype2 | C/48 | 24.9 | +0.000 | +2.500 | 96
COLUMN | C350/1Ctype2 | C/50 | 37.4 | +0.000 | +2.500 | 125
INLINE FASCIA PLATE | C350/1Ctype2 | PL/827 | 0.5 | +1.348 | +1.449 | 3
FASCIA | C350/1Ctype2 | F/34 | 1.2 | +1.297 | +1.500 | 76
FASCIA | C300/1Ctype2 | F/30 | 1.2 | +1.297 | +1.500 | 76
FASCIA | C250/1Ctype2 | F/26 | 1.2 | +1.297 | +1.500 | 76
FASCIA | C200/1Ctype2 | F/26 | 1.2 | +1.297 | +1.500 | 76
FASCIA | C150/1Ctype2 | F/22 | 1.2 | +1.297 | +1.500 | 76
COLUMN | C350/1Ctype1 | C/50 | 37.4 | +0.000 | +2.500 | 125
INLINE FASCIA PLATE | C350/1Ctype1 | PL/826 | 0.8 | +1.348 | +1.449 | 3
2 x FASCIA | C350/1Ctype1 | F/34 | 1.2 | +1.297 | +1.500 | 76
COLUMN | C300/1Ctype1 | C/47 | 24.9 | +0.000 | +2.500 | 96
INLINE FASCIA PLATE | C300/1Ctype1 | Z/1896 | 0.8 | +1.348 | +1.449 | 3
2 x FASCIA | C300/1Ctype1 | F/30 | 1.2 | +1.297 | +1.500 | 76
COLUMN | C250/1Ctype1 | C/45 | 20.1 | +0.000 | +2.500 | 76
INLINE FASCIA PLATE | C250/1Ctype1 | Z/1895 | 0.8 | +1.348 | +1.449 | 3
2 x FASCIA | C250/1Ctype1 | F/26 | 1.2 | +1.297 | +1.500 | 76
COLUMN | C200/1Ctype1 | C/43 | 17.7 | +0.000 | +2.500 | 76
INLINE FASCIA PLATE | C200/1Ctype1 | Z/1895 | 0.8 | +1.348 | +1.449 | 3
2 x FASCIA | C200/1Ctype1 | F/26 | 1.2 | +1.297 | +1.500 | 76
COLUMN | C150/1Ctype1 | C/41 | 13.9 | +0.000 | +2.500 | 64
INLINE FASCIA PLATE | C150/1Ctype1 | Z/1633 | 0.8 | +1.348 | +1.449 | 3
2 x FASCIA | C150/1Ctype1 | F/22 | 1.2 | +1.297 | +1.500 | 76
INLINE FASCIA PLATE | C350/2Ctype1 | PL/828 | 1 | +1.348 | +1.449 | 3
INLINE FASCIA PLATE | C150/2Ctype2 | Z/1930 | 0.8 | +0.823 | +0.923 | 3
FASCIA | C150/2Ctype2 | F/21 | 1.9 | +0.746 | +1.000 | 76
INLINE FASCIA PLATE | C200/2Ctype2 | Z/1931 | 0.8 | +0.823 | +0.923 | 3
FASCIA | C200/2Ctype2 | F/25 | 1.8 | +0.746 | +1.000 | 76
INLINE FASCIA PLATE | C250/2Ctype2 | Z/1931 | 0.8 | +0.823 | +0.923 | 3
FASCIA | C250/2Ctype2 | F/25 | 1.8 | +0.746 | +1.000 | 76
INLINE FASCIA PLATE | C300/2Ctype2 | Z/1940 | 0.8 | +0.823 | +0.923 | 3
FASCIA | C300/2Ctype2 | F/29 | 1.8 | +0.746 | +1.000 | 76
FASCIA | C350/2Ctype2 | F/33 | 1.8 | +0.746 | +1.000 | 76
INLINE FASCIA PLATE | C350/2Ctype2 | PL/829 | 0.8 | +0.823 | +0.923 | 3
INLINE FASCIA PLATE | C150/2Ctype1 | Z/1909 | 1 | +0.823 | +0.923 | 3
2 x FASCIA | C150/2Ctype1 | F/21 | 1.9 | +0.746 | +1.000 | 76
INLINE FASCIA PLATE | C200/2Ctype1 | Z/1928 | 1 | +0.823 | +0.923 | 3
2 x FASCIA | C200/2Ctype1 | F/25 | 1.8 | +0.746 | +1.000 | 76
INLINE FASCIA PLATE | C250/2Ctype1 | Z/1928 | 1 | +0.823 | +0.923 | 3
2 x FASCIA | C250/2Ctype1 | F/25 | 1.8 | +0.746 | +1.000 | 76
INLINE FASCIA PLATE | C300/2Ctype1 | Z/1929 | 1 | +0.823 | +0.923 | 3
2 x FASCIA | C300/2Ctype1 | F/29 | 1.8 | +0.746 | +1.000 | 76
INLINE FASCIA PLATE | C350/2Ctype1 | PL/828 | 1 | +0.823 | +0.923 | 3
2 x FASCIA | C350/2Ctype1 | F/33 | 1.8 | +0.746 | +1.000 | 76
INLINE FASCIA PLATE | C150/1Ctype2 | Z/1897 | 0.5 | +0.823 | +0.923 | 3
FASCIA | C150/1Ctype2 | F/21 | 1.9 | +0.746 | +1.000 | 76
INLINE FASCIA PLATE | C200/1Ctype2 | Z/1907 | 0.5 | +0.823 | +0.923 | 3
FASCIA | C200/1Ctype2 | F/25 | 1.8 | +0.746 | +1.000 | 76
INLINE FASCIA PLATE | C250/1Ctype2 | Z/1907 | 0.5 | +0.823 | +0.923 | 3
FASCIA | C250/1Ctype2 | F/25 | 1.8 | +0.746 | +1.000 | 76
INLINE FASCIA PLATE | C300/1Ctype2 | Z/1908 | 0.5 | +0.823 | +0.923 | 3
FASCIA | C300/1Ctype2 | F/29 | 1.8 | +0.746 | +1.000 | 76
FASCIA | C350/1Ctype2 | F/33 | 1.8 | +0.746 | +1.000 | 76
INLINE FASCIA PLATE | C350/1Ctype2 | PL/827 | 0.5 | +0.823 | +0.923 | 3
2 x FASCIA | C350/1Ctype1 | F/33 | 1.8 | +0.746 | +1.000 | 76
INLINE FASCIA PLATE | C350/1Ctype1 | PL/826 | 0.8 | +0.823 | +0.923 | 3
2 x FASCIA | C300/1Ctype1 | F/29 | 1.8 | +0.746 | +1.000 | 76
INLINE FASCIA PLATE | C300/1Ctype1 | Z/1896 | 0.8 | +0.823 | +0.923 | 3
2 x FASCIA | C250/1Ctype1 | F/25 | 1.8 | +0.746 | +1.000 | 76
INLINE FASCIA PLATE | C250/1Ctype1 | Z/1895 | 0.8 | +0.823 | +0.923 | 3
2 x FASCIA | C200/1Ctype1 | F/25 | 1.8 | +0.746 | +1.000 | 76
INLINE FASCIA PLATE | C200/1Ctype1 | Z/1895 | 0.8 | +0.823 | +0.923 | 3
2 x FASCIA | C150/1Ctype1 | F/21 | 1.9 | +0.746 | +1.000 | 76
INLINE FASCIA PLATE | C150/1Ctype1 | Z/1633 | 0.8 | +0.823 | +0.923 | 3
INLINE FASCIA PLATE | C150/2Ctype2 | Z/1930 | 0.8 | +1.874 | +1.974 | 3
INLINE FASCIA PLATE | C150/2Ctype2 | Z/1930 | 0.8 | +2.399 | +2.499 | 3
INLINE FASCIA PLATE | C200/2Ctype2 | Z/1931 | 0.8 | +1.874 | +1.974 | 3
INLINE FASCIA PLATE | C200/2Ctype2 | Z/1931 | 0.8 | +2.399 | +2.499 | 3
INLINE FASCIA PLATE | C250/2Ctype2 | Z/1931 | 0.8 | +1.874 | +1.974 | 3
INLINE FASCIA PLATE | C250/2Ctype2 | Z/1931 | 0.8 | +2.399 | +2.499 | 3
INLINE FASCIA PLATE | C300/2Ctype2 | Z/1940 | 0.8 | +1.874 | +1.974 | 3
INLINE FASCIA PLATE | C300/2Ctype2 | Z/1940 | 0.8 | +2.399 | +2.499 | 3
FASCIA | C300/2Ctype2 | F/31 | 1 | +1.848 | +2.000 | 64
FASCIA | C300/2Ctype2 | F/32 | 0.8 | +2.398 | +2.500 | 51
FASCIA | C250/2Ctype2 | F/27 | 1 | +1.848 | +2.000 | 64
FASCIA | C250/2Ctype2 | F/28 | 0.8 | +2.398 | +2.500 | 51
FASCIA | C200/2Ctype2 | F/27 | 1 | +1.848 | +2.000 | 64
FASCIA | C200/2Ctype2 | F/28 | 0.8 | +2.398 | +2.500 | 51
FASCIA | C150/2Ctype2 | F/23 | 1 | +1.848 | +2.000 | 64
FASCIA | C150/2Ctype2 | F/24 | 0.8 | +2.398 | +2.500 | 51
FASCIA | C350/2Ctype2 | F/35 | 0.8 | +1.848 | +2.000 | 64
INLINE FASCIA PLATE | C350/2Ctype2 | PL/829 | 0.8 | +1.874 | +1.974 | 3
FASCIA | C350/2Ctype2 | F/36 | 0.8 | +2.398 | +2.500 | 51
INLINE FASCIA PLATE | C350/2Ctype2 | PL/829 | 0.8 | +2.399 | +2.499 | 3
INLINE FASCIA PLATE | C150/2Ctype1 | Z/1909 | 1 | +1.874 | +1.974 | 3
INLINE FASCIA PLATE | C150/2Ctype1 | Z/1909 | 1 | +2.399 | +2.499 | 3
INLINE FASCIA PLATE | C200/2Ctype1 | Z/1928 | 1 | +1.874 | +1.974 | 3
INLINE FASCIA PLATE | C200/2Ctype1 | Z/1928 | 1 | +2.399 | +2.499 | 3
INLINE FASCIA PLATE | C250/2Ctype1 | Z/1928 | 1 | +1.874 | +1.974 | 3
INLINE FASCIA PLATE | C250/2Ctype1 | Z/1928 | 1 | +2.399 | +2.499 | 3
INLINE FASCIA PLATE | C300/2Ctype1 | Z/1929 | 1 | +1.874 | +1.974 | 3
INLINE FASCIA PLATE | C300/2Ctype1 | Z/1929 | 1 | +2.399 | +2.499 | 3
2 x FASCIA | C300/2Ctype1 | F/31 | 1 | +1.848 | +2.000 | 64
2 x FASCIA | C300/2Ctype1 | F/32 | 0.8 | +2.398 | +2.500 | 51
2 x FASCIA | C250/2Ctype1 | F/27 | 1 | +1.848 | +2.000 | 64
2 x FASCIA | C250/2Ctype1 | F/28 | 0.8 | +2.398 | +2.500 | 51
2 x FASCIA | C200/2Ctype1 | F/27 | 1 | +1.848 | +2.000 | 64
2 x FASCIA | C200/2Ctype1 | F/28 | 0.8 | +2.398 | +2.500 | 51
2 x FASCIA | C150/2Ctype1 | F/23 | 1 | +1.848 | +2.000 | 64
2 x FASCIA | C150/2Ctype1 | F/24 | 0.8 | +2.398 | +2.500 | 51
2 x FASCIA | C350/2Ctype1 | F/35 | 0.8 | +1.848 | +2.000 | 64
2 x FASCIA | C350/2Ctype1 | F/36 | 0.8 | +2.398 | +2.500 | 51
INLINE FASCIA PLATE | C350/2Ctype1 | PL/828 | 1 | +2.399 | +2.499 | 3
INLINE FASCIA PLATE | C350/2Ctype1 | PL/828 | 1 | +1.874 | +1.974 | 3
INLINE FASCIA PLATE | C150/1Ctype2 | Z/1897 | 0.5 | +1.874 | +1.974 | 3
INLINE FASCIA PLATE | C150/1Ctype2 | Z/1897 | 0.5 | +2.399 | +2.499 | 3
INLINE FASCIA PLATE | C200/1Ctype2 | Z/1907 | 0.5 | +1.874 | +1.974 | 3
INLINE FASCIA PLATE | C200/1Ctype2 | Z/1907 | 0.5 | +2.399 | +2.499 | 3
INLINE FASCIA PLATE | C250/1Ctype2 | Z/1907 | 0.5 | +1.874 | +1.974 | 3
INLINE FASCIA PLATE | C250/1Ctype2 | Z/1907 | 0.5 | +2.399 | +2.499 | 3
INLINE FASCIA PLATE | C300/1Ctype2 | Z/1908 | 0.5 | +1.874 | +1.974 | 3
INLINE FASCIA PLATE | C300/1Ctype2 | Z/1908 | 0.5 | +2.399 | +2.499 | 3
FASCIA | C350/1Ctype2 | F/35 | 0.8 | +1.848 | +2.000 | 64
INLINE FASCIA PLATE | C350/1Ctype2 | PL/827 | 0.5 | +1.874 | +1.974 | 3
FASCIA | C350/1Ctype2 | F/36 | 0.8 | +2.398 | +2.500 | 51
INLINE FASCIA PLATE | C350/1Ctype2 | PL/827 | 0.5 | +2.399 | +2.499 | 3
FASCIA | C300/1Ctype2 | F/31 | 1 | +1.848 | +2.000 | 64
FASCIA | C300/1Ctype2 | F/32 | 0.8 | +2.398 | +2.500 | 51
FASCIA | C250/1Ctype2 | F/27 | 1 | +1.848 | +2.000 | 64
FASCIA | C250/1Ctype2 | F/28 | 0.8 | +2.398 | +2.500 | 51
FASCIA | C200/1Ctype2 | F/27 | 1 | +1.848 | +2.000 | 64
FASCIA | C200/1Ctype2 | F/28 | 0.8 | +2.398 | +2.500 | 51
FASCIA | C150/1Ctype2 | F/23 | 1 | +1.848 | +2.000 | 64
FASCIA | C150/1Ctype2 | F/24 | 0.8 | +2.398 | +2.500 | 51
2 x FASCIA | C350/1Ctype1 | F/35 | 0.8 | +1.848 | +2.000 | 64
INLINE FASCIA PLATE | C350/1Ctype1 | PL/826 | 0.8 | +1.874 | +1.974 | 3
2 x FASCIA | C350/1Ctype1 | F/36 | 0.8 | +2.398 | +2.500 | 51
INLINE FASCIA PLATE | C350/1Ctype1 | PL/826 | 0.8 | +2.399 | +2.499 | 3
2 x FASCIA | C300/1Ctype1 | F/31 | 1 | +1.848 | +2.000 | 64
INLINE FASCIA PLATE | C300/1Ctype1 | Z/1896 | 0.8 | +1.874 | +1.974 | 3
2 x FASCIA | C300/1Ctype1 | F/32 | 0.8 | +2.398 | +2.500 | 51
INLINE FASCIA PLATE | C300/1Ctype1 | Z/1896 | 0.8 | +2.399 | +2.499 | 3
2 x FASCIA | C250/1Ctype1 | F/27 | 1 | +1.848 | +2.000 | 64
INLINE FASCIA PLATE | C250/1Ctype1 | Z/1895 | 0.8 | +1.874 | +1.974 | 3
2 x FASCIA | C250/1Ctype1 | F/28 | 0.8 | +2.398 | +2.500 | 51
INLINE FASCIA PLATE | C250/1Ctype1 | Z/1895 | 0.8 | +2.399 | +2.499 | 3
2 x FASCIA | C200/1Ctype1 | F/27 | 1 | +1.848 | +2.000 | 64
INLINE FASCIA PLATE | C200/1Ctype1 | Z/1895 | 0.8 | +1.874 | +1.974 | 3
2 x FASCIA | C200/1Ctype1 | F/28 | 0.8 | +2.398 | +2.500 | 51
INLINE FASCIA PLATE | C200/1Ctype1 | Z/1895 | 0.8 | +2.399 | +2.499 | 3
2 x FASCIA | C150/1Ctype1 | F/23 | 1 | +1.848 | +2.000 | 64
INLINE FASCIA PLATE | C150/1Ctype1 | Z/1633 | 0.8 | +1.874 | +1.974 | 3
2 x FASCIA | C150/1Ctype1 | F/24 | 0.8 | +2.398 | +2.500 | 51
INLINE FASCIA PLATE | C150/1Ctype1 | Z/1633 | 0.8 | +2.399 | +2.499 | 3

# IfcMechanicalFastener: Bolt assembly (320)
In: Undefined
NominalDiameter: 12 mm
Tekla Bolt - Washer diameter: 12 mm; Washer type: FLAT; Washer name: WASHERM12-FLAT; Nut type: 4.6-HEX; Nut name: NUTM12-4.6-HEX; Slotted hole x: 0 mm; Bolt hole diameter: 14 mm; Location: Site; Bolt count: 1
Name | NominalLength (mm) = Bolt length (mm) | Material = Bolt standard | Washer count = Nut count | Slotted hole y (mm) | Bolt size (mm) | Bolt Name
20 x Bolt assembly | 3 | PB1230 | 0 | 316 | 14 | BOLTPB1230
240 x Bolt assembly | 30 | FB1230Z | 1 | 0 | 12 | BOLTFB1230
18 x Bolt assembly | 3 | PB1230 | 0 | 377 | 14 | BOLTPB1230
2 x Bolt assembly | 100 | PB1230 | 0 | 377 | 14
20 x Bolt assembly | 3 | PB1230 | 0 | 186 | 14 | BOLTPB1230
20 x Bolt assembly | 3 | PB1230 | 0 | 246 | 14 | BOLTPB1230

# IfcPlate: PLT3*100 (80)
In: Undefined
Description: PLT3*100; Material: STEEL/250
Tekla Common - Phase: 1; Class: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 100 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 100 mm; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
INLINE FASCIA PLATE | Z/1930 | +1.348 | +1.449 | 0.8 | 88.2 | 0.1 | 350 | 0.0727 | 0.035 | 0.000105
2 x INLINE FASCIA PLATE | Z/1931 | +1.348 | +1.449 | 0.8 | 88.2 | 0.1 | 350 | 0.0727 | 0.035 | 0.000105
INLINE FASCIA PLATE | Z/1940 | +1.348 | +1.449 | 0.8 | 88.2 | 0.1 | 350 | 0.0727 | 0.035 | 0.000105
INLINE FASCIA PLATE | PL/829 | +1.348 | +1.449 | 0.8 | 88.2 | 0.1 | 350 | 0.0727 | 0.035 | 0.000105
INLINE FASCIA PLATE | Z/1909 | +1.348 | +1.449 | 1 | 88.2 | 0.1 | 410 | 0.08506 | 0.041 | 0.000123
2 x INLINE FASCIA PLATE | Z/1928 | +1.348 | +1.449 | 1 | 88.2 | 0.1 | 410 | 0.08506 | 0.041 | 0.000123
INLINE FASCIA PLATE | Z/1929 | +1.348 | +1.449 | 1 | 88.2 | 0.1 | 410 | 0.08506 | 0.041 | 0.000123
INLINE FASCIA PLATE | PL/828 | +1.348 | +1.449 | 1 | 88.2 | 0.1 | 410 | 0.08506 | 0.041 | 0.000123
INLINE FASCIA PLATE | Z/1897 | +1.348 | +1.449 | 0.5 | 88.6 | 0 | 220 | 0.04592 | 0.022 | 0.000066
2 x INLINE FASCIA PLATE | Z/1907 | +1.348 | +1.449 | 0.5 | 88.6 | 0 | 220 | 0.04592 | 0.022 | 0.000066
INLINE FASCIA PLATE | Z/1908 | +1.348 | +1.449 | 0.5 | 88.6 | 0 | 220 | 0.04592 | 0.022 | 0.000066
INLINE FASCIA PLATE | PL/827 | +1.348 | +1.449 | 0.5 | 88.6 | 0 | 220 | 0.04592 | 0.022 | 0.000066
INLINE FASCIA PLATE | PL/826 | +1.348 | +1.449 | 0.8 | 88.4 | 0.1 | 280 | 0.05828 | 0.028 | 0.000084
INLINE FASCIA PLATE | Z/1896 | +1.348 | +1.449 | 0.8 | 88.4 | 0.1 | 280 | 0.05828 | 0.028 | 0.000084
2 x INLINE FASCIA PLATE | Z/1895 | +1.348 | +1.449 | 0.8 | 88.4 | 0.1 | 280 | 0.05828 | 0.028 | 0.000084
INLINE FASCIA PLATE | Z/1633 | +1.348 | +1.449 | 0.8 | 88.4 | 0.1 | 280 | 0.05828 | 0.028 | 0.000084
INLINE FASCIA PLATE | Z/1930 | +0.823 | +0.923 | 0.8 | 88.2 | 0.1 | 350 | 0.0727 | 0.035 | 0.000105
2 x INLINE FASCIA PLATE | Z/1931 | +0.823 | +0.923 | 0.8 | 88.2 | 0.1 | 350 | 0.0727 | 0.035 | 0.000105
INLINE FASCIA PLATE | Z/1940 | +0.823 | +0.923 | 0.8 | 88.2 | 0.1 | 350 | 0.0727 | 0.035 | 0.000105
INLINE FASCIA PLATE | PL/829 | +0.823 | +0.923 | 0.8 | 88.2 | 0.1 | 350 | 0.0727 | 0.035 | 0.000105
INLINE FASCIA PLATE | Z/1909 | +0.823 | +0.923 | 1 | 88.2 | 0.1 | 410 | 0.08506 | 0.041 | 0.000123
2 x INLINE FASCIA PLATE | Z/1928 | +0.823 | +0.923 | 1 | 88.2 | 0.1 | 410 | 0.08506 | 0.041 | 0.000123
INLINE FASCIA PLATE | Z/1929 | +0.823 | +0.923 | 1 | 88.2 | 0.1 | 410 | 0.08506 | 0.041 | 0.000123
INLINE FASCIA PLATE | PL/828 | +0.823 | +0.923 | 1 | 88.2 | 0.1 | 410 | 0.08506 | 0.041 | 0.000123
INLINE FASCIA PLATE | Z/1897 | +0.823 | +0.923 | 0.5 | 88.6 | 0 | 220 | 0.04592 | 0.022 | 0.000066
2 x INLINE FASCIA PLATE | Z/1907 | +0.823 | +0.923 | 0.5 | 88.6 | 0 | 220 | 0.04592 | 0.022 | 0.000066
INLINE FASCIA PLATE | Z/1908 | +0.823 | +0.923 | 0.5 | 88.6 | 0 | 220 | 0.04592 | 0.022 | 0.000066
INLINE FASCIA PLATE | PL/827 | +0.823 | +0.923 | 0.5 | 88.6 | 0 | 220 | 0.04592 | 0.022 | 0.000066
INLINE FASCIA PLATE | PL/826 | +0.823 | +0.923 | 0.8 | 88.4 | 0.1 | 280 | 0.05828 | 0.028 | 0.000084
INLINE FASCIA PLATE | Z/1896 | +0.823 | +0.923 | 0.8 | 88.4 | 0.1 | 280 | 0.05828 | 0.028 | 0.000084
2 x INLINE FASCIA PLATE | Z/1895 | +0.823 | +0.923 | 0.8 | 88.4 | 0.1 | 280 | 0.05828 | 0.028 | 0.000084
INLINE FASCIA PLATE | Z/1633 | +0.823 | +0.923 | 0.8 | 88.4 | 0.1 | 280 | 0.05828 | 0.028 | 0.000084
INLINE FASCIA PLATE | Z/1930 | +1.874 | +1.974 | 0.8 | 88.2 | 0.1 | 350 | 0.0727 | 0.035 | 0.000105
INLINE FASCIA PLATE | Z/1930 | +2.399 | +2.499 | 0.8 | 88.2 | 0.1 | 350 | 0.0727 | 0.035 | 0.000105
2 x INLINE FASCIA PLATE | Z/1931 | +1.874 | +1.974 | 0.8 | 88.2 | 0.1 | 350 | 0.0727 | 0.035 | 0.000105
2 x INLINE FASCIA PLATE | Z/1931 | +2.399 | +2.499 | 0.8 | 88.2 | 0.1 | 350 | 0.0727 | 0.035 | 0.000105
INLINE FASCIA PLATE | Z/1940 | +1.874 | +1.974 | 0.8 | 88.2 | 0.1 | 350 | 0.0727 | 0.035 | 0.000105
INLINE FASCIA PLATE | Z/1940 | +2.399 | +2.499 | 0.8 | 88.2 | 0.1 | 350 | 0.0727 | 0.035 | 0.000105
INLINE FASCIA PLATE | PL/829 | +1.874 | +1.974 | 0.8 | 88.2 | 0.1 | 350 | 0.0727 | 0.035 | 0.000105
INLINE FASCIA PLATE | PL/829 | +2.399 | +2.499 | 0.8 | 88.2 | 0.1 | 350 | 0.0727 | 0.035 | 0.000105
INLINE FASCIA PLATE | Z/1909 | +1.874 | +1.974 | 1 | 88.2 | 0.1 | 410 | 0.08506 | 0.041 | 0.000123
INLINE FASCIA PLATE | Z/1909 | +2.399 | +2.499 | 1 | 88.2 | 0.1 | 410 | 0.08506 | 0.041 | 0.000123
2 x INLINE FASCIA PLATE | Z/1928 | +1.874 | +1.974 | 1 | 88.2 | 0.1 | 410 | 0.08506 | 0.041 | 0.000123
2 x INLINE FASCIA PLATE | Z/1928 | +2.399 | +2.499 | 1 | 88.2 | 0.1 | 410 | 0.08506 | 0.041 | 0.000123
INLINE FASCIA PLATE | Z/1929 | +1.874 | +1.974 | 1 | 88.2 | 0.1 | 410 | 0.08506 | 0.041 | 0.000123
INLINE FASCIA PLATE | Z/1929 | +2.399 | +2.499 | 1 | 88.2 | 0.1 | 410 | 0.08506 | 0.041 | 0.000123
INLINE FASCIA PLATE | PL/828 | +1.874 | +1.974 | 1 | 88.2 | 0.1 | 410 | 0.08506 | 0.041 | 0.000123
INLINE FASCIA PLATE | PL/828 | +2.399 | +2.499 | 1 | 88.2 | 0.1 | 410 | 0.08506 | 0.041 | 0.000123
INLINE FASCIA PLATE | Z/1897 | +1.874 | +1.974 | 0.5 | 88.6 | 0 | 220 | 0.04592 | 0.022 | 0.000066
INLINE FASCIA PLATE | Z/1897 | +2.399 | +2.499 | 0.5 | 88.6 | 0 | 220 | 0.04592 | 0.022 | 0.000066
2 x INLINE FASCIA PLATE | Z/1907 | +1.874 | +1.974 | 0.5 | 88.6 | 0 | 220 | 0.04592 | 0.022 | 0.000066
2 x INLINE FASCIA PLATE | Z/1907 | +2.399 | +2.499 | 0.5 | 88.6 | 0 | 220 | 0.04592 | 0.022 | 0.000066
INLINE FASCIA PLATE | Z/1908 | +1.874 | +1.974 | 0.5 | 88.6 | 0 | 220 | 0.04592 | 0.022 | 0.000066
INLINE FASCIA PLATE | Z/1908 | +2.399 | +2.499 | 0.5 | 88.6 | 0 | 220 | 0.04592 | 0.022 | 0.000066
INLINE FASCIA PLATE | PL/827 | +1.874 | +1.974 | 0.5 | 88.6 | 0 | 220 | 0.04592 | 0.022 | 0.000066
INLINE FASCIA PLATE | PL/827 | +2.399 | +2.499 | 0.5 | 88.6 | 0 | 220 | 0.04592 | 0.022 | 0.000066
INLINE FASCIA PLATE | PL/826 | +1.874 | +1.974 | 0.8 | 88.4 | 0.1 | 280 | 0.05828 | 0.028 | 0.000084
INLINE FASCIA PLATE | PL/826 | +2.399 | +2.499 | 0.8 | 88.4 | 0.1 | 280 | 0.05828 | 0.028 | 0.000084
INLINE FASCIA PLATE | Z/1896 | +1.874 | +1.974 | 0.8 | 88.4 | 0.1 | 280 | 0.05828 | 0.028 | 0.000084
INLINE FASCIA PLATE | Z/1896 | +2.399 | +2.499 | 0.8 | 88.4 | 0.1 | 280 | 0.05828 | 0.028 | 0.000084
2 x INLINE FASCIA PLATE | Z/1895 | +1.874 | +1.974 | 0.8 | 88.4 | 0.1 | 280 | 0.05828 | 0.028 | 0.000084
2 x INLINE FASCIA PLATE | Z/1895 | +2.399 | +2.499 | 0.8 | 88.4 | 0.1 | 280 | 0.05828 | 0.028 | 0.000084
INLINE FASCIA PLATE | Z/1633 | +1.874 | +1.974 | 0.8 | 88.4 | 0.1 | 280 | 0.05828 | 0.028 | 0.000084
INLINE FASCIA PLATE | Z/1633 | +2.399 | +2.499 | 0.8 | 88.4 | 0.1 | 280 | 0.05828 | 0.028 | 0.000084
