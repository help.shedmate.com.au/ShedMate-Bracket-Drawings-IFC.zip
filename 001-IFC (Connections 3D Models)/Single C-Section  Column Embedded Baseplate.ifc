Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView_V2.0, QuantityTakeOffAddOnView], Option [BaseQuantities:On], Option [GridExport:On], Option [Assemblies:On], Option [Bolts:On], Option [Rebars:On], Option [PourObjects:Off], Option [Welds:Off], Option [SurfaceTreatments:Off], Option [LocationBy:0], Option [ViewColors:Off], Option [SectionedSpine:Off], Option [PropertySets:On], Option [Export all:Off]
File name: Single C-Section Column Embedded Baseplate.ifc
Time: 2026-03-26T06:37:15
Author: DESKTOP-BKNQL56\admin
Organization: Structural Designer
Written by: IFC Database Version: Work
Made in: Tekla Structures 2019 Service Pack 13, IFC Export Version: 4.0.0.0 Oct 18 2021

# IfcBuildingStorey, Undefined
In: Undefined
Elevation: 0 mm

# IfcBeam: FL6*75 (2)
In: Undefined
Description: FL6*75; Material: STEEL/450
Tekla Common - Finish: GALVANIZE; Bottom elevation: -0.450; Top elevation: +0.225; Phase: 1; Class: 5
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 46 m2; Net surface area: 0.3 m2; Height: 75 mm; Width: 6 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Weight (kg) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
EMBEDDED BASE PLATE | PL/716 | 5.7 | 1593.7 | 1593.71 | 0.260551 | 0.0007209 | 5.65907
EMBEDDED BASE PLATE | PL/714 | 5.5 | 1542.7 | 1542.71 | 0.252289 | 0.00069795 | 5.47891

# IfcBeam: PLT6*125, EMBEDDED BASE PLATE
In: Undefined
Description: PLT6*125; Material: STEEL/450
Default - ASSEMBLY_POS: PL/720
Tekla Common - Finish: GALVANIZE; Bottom elevation: -0.450; Top elevation: +0.236; Phase: 1; Class: 5
Tekla Quantity - Weight: 10.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 44.7 m2; Net surface area: 0.5 m2; Height: 125 mm; Width: 6 mm; Length: 1711.7 mm
Pset_BeamCommon - LoadBearing: no; Reference: PL/720
BaseQuantities - Length: 1711.71 mm; OuterSurfaceArea: 0.452352 m2; NetVolume: 0.00129 m3; NetWeight: 10.1265 kg

# IfcBeam: PLT6*60, EMBEDDED BASE PLATE
In: Undefined
Description: PLT6*60; Material: STEEL/450
Tekla Common - Finish: GALVANIZE; Bottom elevation: -0.450; Top elevation: +0.225; Phase: 1; Class: 5
Default - ASSEMBLY_POS: PL/712
Tekla Quantity - Weight: 4.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 46.9 m2; Net surface area: 0.2 m2; Height: 60 mm; Width: 6 mm; Length: 1491.7 mm
Pset_BeamCommon - LoadBearing: no; Reference: PL/712
BaseQuantities - Length: 1491.71 mm; OuterSurfaceArea: 0.198822 m2; NetVolume: 0.00054 m3; NetWeight: 4.239 kg

# IfcBeam: PLT6*95, EMBEDDED BASE PLATE
In: Undefined
Description: PLT6*95; Material: STEEL/450
Tekla Common - Finish: GALVANIZE; Bottom elevation: -0.450; Top elevation: +0.236; Phase: 1; Class: 5
Default - ASSEMBLY_POS: PL/718
Tekla Quantity - Weight: 7.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 45.3 m2; Net surface area: 0.3 m2; Height: 95 mm; Width: 6 mm; Length: 1661.7 mm
Pset_BeamCommon - LoadBearing: no; Reference: PL/718
BaseQuantities - Length: 1661.71 mm; OuterSurfaceArea: 0.338641 m2; NetVolume: 0.0009519 m3; NetWeight: 7.47242 kg

# IfcColumn: C:150-24, COLUMN
In: Undefined
Description: C:150-24; Material: STEEL/G450
Tekla Common - Finish: 1mm ggap +4; Bottom elevation: +0.000; Top elevation: +1.500; Phase: 1; Class: 12
Default - ASSEMBLY_POS: Z/12
Tekla Quantity - Weight: 8.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 111.3 m2; Net surface area: 0.9 m2; Height: 152 mm; Width: 64 mm; Length: 1499.6 mm
Pset_ColumnCommon - LoadBearing: no; Reference: Z/12
BaseQuantities - Length: 1499.71 mm; OuterSurfaceArea: 0.930694 m2; NetVolume: 0.00110642 m3; NetWeight: 8.68543 kg

# IfcColumn: C:200-24, COLUMN
In: Undefined
Description: C:200-24; Material: STEEL/G450
Tekla Common - Finish: 1mm ggap +4; Bottom elevation: +0.000; Top elevation: +1.500; Phase: 1; Class: 12
Default - ASSEMBLY_POS: Z/24
Tekla Quantity - Weight: 10.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 110.2 m2; Net surface area: 1.3 m2; Height: 203 mm; Width: 76 mm; Length: 1499.6 mm
Pset_ColumnCommon - LoadBearing: no; Reference: Z/24
BaseQuantities - Length: 1499.71 mm; OuterSurfaceArea: 1.17103 m2; NetVolume: 0.00139437 m3; NetWeight: 10.9458 kg

# IfcColumn: C:250-24, COLUMN
In: Undefined
Description: C:250-24; Material: STEEL/G450
Tekla Common - Finish: 1mm ggap +4; Bottom elevation: +0.000; Top elevation: +1.500; Phase: 1; Class: 12
Default - ASSEMBLY_POS: Z/47
Tekla Quantity - Weight: 12 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 109.8 m2; Net surface area: 1.3 m2; Height: 254 mm; Width: 76 mm; Length: 1499.6 mm
Pset_ColumnCommon - LoadBearing: no; Reference: Z/47
BaseQuantities - Length: 1499.61 mm; OuterSurfaceArea: 1.32115 m2; NetVolume: 0.00157423 m3; NetWeight: 12.3577 kg

# IfcColumn: C:300-30, COLUMN
In: Undefined
Description: C:300-30; Material: STEEL/G450
Tekla Common - Finish: 1mm ggap +4; Bottom elevation: +0.000; Top elevation: +1.500; Phase: 1; Class: 12
Default - ASSEMBLY_POS: Z/183
Tekla Quantity - Weight: 18.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.5 m2; Net surface area: 1.6 m2; Height: 300 mm; Width: 96 mm; Length: 1500 mm
Pset_ColumnCommon - LoadBearing: no; Reference: Z/183
BaseQuantities - Length: 1500 mm; OuterSurfaceArea: 1.64125 m2; NetVolume: 0.0024435 m3; NetWeight: 19.1814 kg

# IfcColumn: C:350-30, COLUMN
In: Undefined
Description: C:350-30; Material: STEEL/G450
Default - ASSEMBLY_POS: Z/193
Tekla Common - Finish: 1mm ggap +4; Bottom elevation: +0.000; Top elevation: +1.500; Phase: 1; Class: 12
Tekla Quantity - Weight: 22.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.2 m2; Net surface area: 2 m2; Height: 350 mm; Width: 125 mm; Length: 1500 mm
Pset_ColumnCommon - LoadBearing: no; Reference: Z/193
BaseQuantities - Length: 1500 mm; OuterSurfaceArea: 1.95688 m2; NetVolume: 0.00291599 m3; NetWeight: 22.8906 kg

# IfcElementAssembly (10)
In: Undefined
PredefinedType: RIGID_FRAME
Name | ASSEMBLY_POSITION_CODE = Assembly/Cast unit position code | ASSEMBLY_POS = Assembly/Cast unit Mark | Assembly/Cast unit weight (kg) | Assembly/Cast unit bottom elevation | Assembly/Cast unit top elevation | Width (mm)
EMBEDDED BASE PLATE | C350SD/2 | PL/720 | 10.1 | -0.450 | +0.236 | 368
EMBEDDED BASE PLATE | C300SD/2 | PL/718 | 7.5 | -0.450 | +0.236 | 318
COLUMN | C350SD/2 | Z/193 | 22.4 | +0.000 | +1.500 | 125
COLUMN | C300SD/2 | Z/183 | 18.8 | +0.000 | +1.500 | 96
COLUMN | C250SD/2 | Z/47 | 12 | +0.000 | +1.500 | 76
EMBEDDED BASE PLATE | C250SD/2 | PL/716 | 5.7 | -0.450 | +0.225 | 272
EMBEDDED BASE PLATE | C200SD/2 | PL/714 | 5.5 | -0.450 | +0.225 | 221
COLUMN | C200SD/2 | Z/24 | 10.6 | +0.000 | +1.500 | 76
EMBEDDED BASE PLATE | C150SD/2 | PL/712 | 4.2 | -0.450 | +0.225 | 170
COLUMN | C150SD/2 | Z/12 | 8.4 | +0.000 | +1.500 | 64

# IfcMechanicalFastener: Bolt assembly (17)
In: Undefined
Material: 8.8S
Tekla Bolt - Washer type: HARD; Nut type: 8.8-HEX; Slotted hole y: 0 mm; Slotted hole x: 0 mm; Location: Site; Bolt standard: 8.8S
Name | NominalDiameter (mm) = Washer diameter (mm) = Bolt size (mm) | NominalLength (mm) = Bolt length (mm) | Washer count = Nut count | Washer name | Nut name | Bolt hole diameter (mm) | Bolt count | Bolt Name
7 x Bolt assembly | 20 | 16 | 0 | WASHERM20-HARD | NUTM20-8.8-HEX | 20 | 2 | BOLTM20*25
6 x Bolt assembly | 16 | 45 | 3 | WASHERM16-HARD | NUTM16-8.8-HEX | 18 | 3 | BOLTM16*45
2 x Bolt assembly | 12 | 30 | 3 | WASHERM12-HARD | NUTM12-8.8-HEX | 14 | 3 | BOLTM12*30
2 x Bolt assembly | 12 | 35 | 3 | WASHERM12-HARD | NUTM12-8.8-HEX | 14 | 3 | BOLTM12*35
