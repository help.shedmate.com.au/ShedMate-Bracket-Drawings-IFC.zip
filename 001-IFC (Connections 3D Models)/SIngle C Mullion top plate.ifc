Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView_V2.0, QuantityTakeOffAddOnView], Option [BaseQuantities:On], Option [GridExport:On], Option [Assemblies:On], Option [Bolts:On], Option [Rebars:On], Option [PourObjects:Off], Option [Welds:Off], Option [SurfaceTreatments:Off], Option [LocationBy:0], Option [ViewColors:Off], Option [SectionedSpine:Off], Option [PropertySets:On], Option [Export all:Off]
File name: SIngle C Mullion top plate.ifc
Time: 2026-10-08T08:43:09
Author: DESKTOP-BKNQL56\admin
Organization: Structural Designer
Written by: IFC Database Version: Work
Made in: Tekla Structures 2019 Service Pack 13, IFC Export Version: 4.0.0.0 Oct 18 2021

# IfcBuildingStorey, Undefined
In: Undefined
Elevation: 0 mm

# IfcBeam: C:150-24 (104)
In: Undefined
Description: C:150-24; Material: STEEL/G450
Tekla Common - Phase: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 152 mm; Width: 64 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Finish | Bottom elevation | Top elevation | Class | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
4 x RAFTER | Z/2346 | 12 deg | +3.151 | +3.561 | 1 | 8.4 | 111.3 | 0.8 | 1500 | 1500 | 0.930876 | 0.00110664 | 8.68713
4 x RAFTER | Z/3248 | 12 deg | +3.151 | +3.561 | 1 | 8.4 | 111.3 | 0.8 | 1500 | 1500 | 0.930876 | 0.00110664 | 8.68713
MULLION | Z/2384 |  | +0.000 | +3.180 | 9 | 17.7 | 111.3 | 1.9 | 3179.7 | 3179.7 | 1.97162 | 0.00234586 | 18.415
4 x COLUMN | Z/6 | 12 deg | +0.000 | +3.400 | 10 | 18.9 | 111.2 | 2.1 | 3400 | 3400 | 2.10812 | 0.00250838 | 19.6908
4 x COLUMN | Z/3247 | 12 deg | +0.000 | +3.400 | 10 | 18.9 | 111.2 | 2.1 | 3400 | 3400 | 2.10812 | 0.00250838 | 19.6908
MULLION | Z/3259 |  | +0.000 | +3.180 | 9 | 17.7 | 111.3 | 1.9 | 3179.7 | 3179.7 | 1.97162 | 0.00234586 | 18.415
2 x COLUMN | Z/8 | 25 deg | +0.000 | +3.400 | 10 | 18.9 | 111.2 | 2.1 | 3400 | 3400 | 2.10812 | 0.00250838 | 19.6908
MULLION | Z/2355 |  | +0.000 | +3.263 | 9 | 18.2 | 111.3 | 1.9 | 3263.2 | 3263.18 | 2.02334 | 0.00240744 | 18.8984
2 x COLUMN | Z/3256 | 25 deg | +0.000 | +3.400 | 10 | 18.9 | 111.2 | 2.1 | 3400 | 3400 | 2.10812 | 0.00250838 | 19.6908
4 x RAFTER | Z/2352 | 18 deg | +3.155 | +3.764 | 1 | 8.4 | 111.3 | 0.8 | 1500 | 1500 | 0.930876 | 0.00110664 | 8.68713
2 x COLUMN | Z/2351 | 18 deg | +0.000 | +3.400 | 10 | 18.9 | 111.2 | 2.1 | 3400 | 3400 | 2.10812 | 0.00250838 | 19.6908
4 x RAFTER | Z/3254 | 18 deg | +3.155 | +3.764 | 1 | 8.4 | 111.3 | 0.8 | 1500 | 1500 | 0.930876 | 0.00110664 | 8.68713
MULLION | Z/2353 |  | +0.000 | +3.224 | 9 | 18 | 111.3 | 1.9 | 3223.8 | 3223.81 | 1.99895 | 0.0023784 | 18.6704
2 x COLUMN | Z/3253 | 18 deg | +0.000 | +3.400 | 10 | 18.9 | 111.2 | 2.1 | 3400 | 3400 | 2.10812 | 0.00250838 | 19.6908
4 x RAFTER | Z/2349 | 15 deg | +3.153 | +3.688 | 1 | 8.4 | 111.3 | 0.8 | 1500 | 1500 | 0.930876 | 0.00110664 | 8.68713
2 x COLUMN | Z/2348 | 15 deg | +0.000 | +3.400 | 10 | 18.9 | 111.2 | 2.1 | 3400 | 3400 | 2.10812 | 0.00250838 | 19.6908
4 x RAFTER | Z/3251 | 15 deg | +3.153 | +3.688 | 1 | 8.4 | 111.3 | 0.8 | 1500 | 1500 | 0.930876 | 0.00110664 | 8.68713
MULLION | Z/2350 |  | +0.000 | +3.207 | 9 | 18 | 111.3 | 1.9 | 3207.2 | 3207.22 | 1.98867 | 0.00236616 | 18.5743
2 x COLUMN | Z/3250 | 15 deg | +0.000 | +3.400 | 10 | 18.9 | 111.2 | 2.1 | 3400 | 3400 | 2.10812 | 0.00250838 | 19.6908
4 x RAFTER | Z/2346 | 12 deg | +3.151 | +3.612 | 1 | 8.4 | 111.3 | 0.8 | 1500 | 1500 | 0.930876 | 0.00110664 | 8.68713
4 x RAFTER | Z/3248 | 12 deg | +3.151 | +3.612 | 1 | 8.4 | 111.3 | 0.8 | 1500 | 1500 | 0.930876 | 0.00110664 | 8.68713
MULLION | Z/2347 |  | +0.000 | +3.191 | 9 | 17.8 | 111.3 | 1.9 | 3190.7 | 3190.67 | 1.97841 | 0.00235395 | 18.4785
4 x RAFTER | Z/2344 | 9 deg | +3.150 | +3.535 | 1 | 8.4 | 111.3 | 0.8 | 1500 | 1500 | 0.930876 | 0.00110664 | 8.68713
2 x COLUMN | Z/2343 | 9 deg | +0.000 | +3.400 | 10 | 18.9 | 111.2 | 2.1 | 3400 | 3400 | 2.10812 | 0.00250838 | 19.6908
4 x RAFTER | Z/3245 | 9 deg | +3.150 | +3.535 | 1 | 8.4 | 111.3 | 0.8 | 1500 | 1500 | 0.930876 | 0.00110664 | 8.68713
MULLION | Z/2345 |  | +0.000 | +3.174 | 9 | 17.7 | 111.3 | 1.9 | 3174.1 | 3174.06 | 1.96812 | 0.00234169 | 18.3823
2 x COLUMN | Z/3244 | 9 deg | +0.000 | +3.400 | 10 | 18.9 | 111.2 | 2.1 | 3400 | 3400 | 2.10812 | 0.00250838 | 19.6908
4 x RAFTER | Z/2341 | 5 deg | +3.149 | +3.431 | 1 | 8.4 | 111.3 | 0.8 | 1500 | 1500 | 0.930876 | 0.00110664 | 8.68713
2 x COLUMN | Z/2340 | 5 deg | +0.000 | +3.400 | 10 | 18.9 | 111.2 | 2.1 | 3400 | 3400 | 2.10812 | 0.00250838 | 19.6908
4 x RAFTER | Z/3242 | 5 deg | +3.149 | +3.431 | 1 | 8.4 | 111.3 | 0.8 | 1500 | 1500 | 0.930876 | 0.00110664 | 8.68713
MULLION | Z/2342 |  | +0.000 | +3.152 | 9 | 17.7 | 111.3 | 1.9 | 3151.7 | 3151.67 | 1.95425 | 0.00232518 | 18.2526
2 x COLUMN | Z/3241 | 5 deg | +0.000 | +3.400 | 10 | 18.9 | 111.2 | 2.1 | 3400 | 3400 | 2.10812 | 0.00250838 | 19.6908
4 x RAFTER | Z/2338 | 3 deg | +3.148 | +3.379 | 1 | 8.4 | 111.3 | 0.8 | 1500 | 1500 | 0.930876 | 0.00110664 | 8.68712
2 x COLUMN | Z/2337 | 3 deg | +0.000 | +3.400 | 10 | 18.9 | 111.2 | 2.1 | 3400 | 3400 | 2.10812 | 0.00250838 | 19.6908
4 x RAFTER | Z/3239 | 3 deg | +3.148 | +3.379 | 1 | 8.4 | 111.3 | 0.8 | 1500 | 1500 | 0.930876 | 0.00110664 | 8.68712
MULLION | Z/2339 |  | +0.000 | +3.140 | 9 | 17.5 | 111.3 | 1.9 | 3140.3 | 3140.31 | 1.94721 | 0.0023168 | 18.1868
2 x COLUMN | Z/3238 | 3 deg | +0.000 | +3.400 | 10 | 18.9 | 111.2 | 2.1 | 3400 | 3400 | 2.10812 | 0.00250838 | 19.6908
MULLION | Z/3258 |  | +0.000 | +3.263 | 9 | 18.2 | 111.3 | 1.9 | 3263.2 | 3263.18 | 2.02334 | 0.00240744 | 18.8984
MULLION | Z/3255 |  | +0.000 | +3.224 | 9 | 18 | 111.3 | 1.9 | 3223.8 | 3223.81 | 1.99895 | 0.0023784 | 18.6704
MULLION | Z/3252 |  | +0.000 | +3.207 | 9 | 18 | 111.3 | 1.9 | 3207.2 | 3207.22 | 1.98867 | 0.00236616 | 18.5743
MULLION | Z/3249 |  | +0.000 | +3.191 | 9 | 17.8 | 111.3 | 1.9 | 3190.7 | 3190.67 | 1.97841 | 0.00235395 | 18.4785
MULLION | Z/3246 |  | +0.000 | +3.174 | 9 | 17.7 | 111.3 | 1.9 | 3174.1 | 3174.06 | 1.96812 | 0.00234169 | 18.3823
MULLION | Z/3243 |  | +0.000 | +3.152 | 9 | 17.7 | 111.3 | 1.9 | 3151.7 | 3151.67 | 1.95425 | 0.00232518 | 18.2526
MULLION | Z/3240 |  | +0.000 | +3.140 | 9 | 17.5 | 111.3 | 1.9 | 3140.3 | 3140.31 | 1.94721 | 0.0023168 | 18.1868

# IfcBeam: C:200-24 (6)
In: Undefined
Description: C:200-24; Material: STEEL/G450
Tekla Common - Finish: 15 deg; Bottom elevation: +2.901; Top elevation: +3.356; Phase: 1; Class: 1
Tekla Quantity - Weight: 7.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 110.2 m2; Net surface area: 0.8 m2; Height: 203 mm; Width: 76 mm; Length: 1000 mm
Pset_BeamCommon - LoadBearing: no
BaseQuantities - Length: 1000 mm; OuterSurfaceArea: 0.78146 m2; NetVolume: 0.00092976 m3; NetWeight: 7.29862 kg
Name | ASSEMBLY_POS = Reference
3 x RAFTER | Z/108(?)
3 x RAFTER | Z/107(?)

# IfcBeam: TH:120-75 (8)
In: Undefined
Description: TH:120-75; Material: STEEL/G450
Default - ASSEMBLY_POS: Z/2333
Tekla Common - Finish: 0; Bottom elevation: +1.768; Top elevation: +1.933; Phase: 1; Class: 4
Tekla Quantity - Weight: 2.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 0 m2; Net surface area: 1.1 m2; Height: 120 mm; Width: 165 mm; Length: 1500 mm
Pset_BeamCommon - LoadBearing: no; Reference: Z/2333
BaseQuantities - Length: 1500 mm; OuterSurfaceArea: 6.8403e-07 m2; NetVolume: 0.000421911 m3; NetWeight: 3.312 kg

# IfcBeam: TH:64-75 (8)
In: Undefined
Description: TH:64-75; Material: STEEL/G450
Default - ASSEMBLY_POS: Z/2330
Tekla Common - Finish: 0; Bottom elevation: +0.285; Top elevation: +0.415; Phase: 1; Class: 4
Tekla Quantity - Weight: 2.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 0 m2; Net surface area: 0.8 m2; Height: 64 mm; Width: 130 mm; Length: 1500 mm
Pset_BeamCommon - LoadBearing: no; Reference: Z/2330
BaseQuantities - Length: 1500 mm; OuterSurfaceArea: 6.8403e-07 m2; NetVolume: 0.000259116 m3; NetWeight: 2.03406 kg

# IfcBeam: TH:75-75 (8)
In: Undefined
Description: TH:75-75; Material: STEEL/G450
Default - ASSEMBLY_POS: Z/2331
Tekla Common - Finish: 0; Bottom elevation: +0.787; Top elevation: +0.912; Phase: 1; Class: 4
Tekla Quantity - Weight: 2.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 0 m2; Net surface area: 0.8 m2; Height: 75 mm; Width: 125 mm; Length: 1500 mm
Pset_BeamCommon - LoadBearing: no; Reference: Z/2331
BaseQuantities - Length: 1500 mm; OuterSurfaceArea: 6.8403e-07 m2; NetVolume: 0.000278736 m3; NetWeight: 2.18808 kg

# IfcBeam: TH:96-75 (8)
In: Undefined
Description: TH:96-75; Material: STEEL/G450
Default - ASSEMBLY_POS: Z/2332
Tekla Common - Finish: 0; Bottom elevation: +1.275; Top elevation: +1.425; Phase: 1; Class: 4
Tekla Quantity - Weight: 2.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 0 m2; Net surface area: 0.8 m2; Height: 96 mm; Width: 150 mm; Length: 1500 mm
Pset_BeamCommon - LoadBearing: no; Reference: Z/2332
BaseQuantities - Length: 1500 mm; OuterSurfaceArea: 6.8403e-07 m2; NetVolume: 0.000345063 m3; NetWeight: 2.70874 kg

# IfcBeam: Z10015 (8)
In: Undefined
Description: Z10015; Material: STEEL/G450
Default - ASSEMBLY_POS: Z/2334
Tekla Common - Finish: 0; Bottom elevation: +2.048; Top elevation: +2.148; Phase: 1; Class: 4
Tekla Quantity - Weight: 3.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 179.1 m2; Net surface area: 0.8 m2; Height: 102 mm; Width: 100.5 mm; Length: 1500 mm
Pset_BeamCommon - LoadBearing: no; Reference: Z/2334
BaseQuantities - Length: 1500 mm; OuterSurfaceArea: 0.680175 m2; NetVolume: 0.00050625 m3; NetWeight: 3.97406 kg

# IfcBeam: Z15015 (8)
In: Undefined
Description: Z15015; Material: STEEL/G450
Default - ASSEMBLY_POS: Z/2335
Tekla Common - Finish: 0; Bottom elevation: +2.216; Top elevation: +2.340; Phase: 1; Class: 4
Tekla Quantity - Weight: 5.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 176.6 m2; Net surface area: 0.8 m2; Height: 152 mm; Width: 124.5 mm; Length: 1500 mm
Pset_BeamCommon - LoadBearing: no; Reference: Z/2335
BaseQuantities - Length: 1500 mm; OuterSurfaceArea: 0.920415 m2; NetVolume: 0.00068625 m3; NetWeight: 5.38706 kg

# IfcBeam: Z20015 (8)
In: Undefined
Description: Z20015; Material: STEEL/G450
Default - ASSEMBLY_POS: Z/2336
Tekla Common - Finish: 0; Bottom elevation: +2.382; Top elevation: +2.533; Phase: 1; Class: 4
Tekla Quantity - Weight: 6.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 175.3 m2; Net surface area: 1.1 m2; Height: 203 mm; Width: 151.5 mm; Length: 1500 mm
Pset_BeamCommon - LoadBearing: no; Reference: Z/2336
BaseQuantities - Length: 1500 mm; OuterSurfaceArea: 1.14564 m2; NetVolume: 0.000855 m3; NetWeight: 6.71175 kg

# IfcColumn: C:150-24 (50)
In: Undefined
Description: C:150-24; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Phase: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 152 mm; Width: 64 mm
Pset_ColumnCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Top elevation | Class | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg) | Finish
2 x MULLION | Z/3742 | +3.075 | 9 | 17.1 | 111.3 | 1.9 | 3074.8 | 3074.83 | 1.90664 | 0.00226849 | 17.8076
MULLION | Z/3259 | +3.180 | 9 | 17.7 | 111.3 | 1.9 | 3179.7 | 3179.7 | 1.97162 | 0.00234586 | 18.415
4 x COLUMN | Z/3247 | +3.400 | 10 | 18.9 | 111.2 | 2.1 | 3400 | 3400 | 2.10812 | 0.00250838 | 19.6908 | 12 deg
4 x COLUMN | Z/6 | +3.400 | 10 | 18.9 | 111.2 | 2.1 | 3400 | 3400 | 2.10812 | 0.00250838 | 19.6908 | 12 deg
MULLION | Z/2384 | +3.180 | 9 | 17.7 | 111.3 | 1.9 | 3179.7 | 3179.7 | 1.97162 | 0.00234586 | 18.415
MULLION | Z/3258 | +3.263 | 9 | 18.2 | 111.3 | 1.9 | 3263.2 | 3263.18 | 2.02334 | 0.00240744 | 18.8984
2 x COLUMN | Z/3256 | +3.400 | 10 | 18.9 | 111.2 | 2.1 | 3400 | 3400 | 2.10812 | 0.00250838 | 19.6908 | 25 deg
2 x COLUMN | Z/8 | +3.400 | 10 | 18.9 | 111.2 | 2.1 | 3400 | 3400 | 2.10812 | 0.00250838 | 19.6908 | 25 deg
MULLION | Z/3255 | +3.224 | 9 | 18 | 111.3 | 1.9 | 3223.8 | 3223.81 | 1.99895 | 0.0023784 | 18.6704
2 x COLUMN | Z/3253 | +3.400 | 10 | 18.9 | 111.2 | 2.1 | 3400 | 3400 | 2.10812 | 0.00250838 | 19.6908 | 18 deg
2 x COLUMN | Z/2351 | +3.400 | 10 | 18.9 | 111.2 | 2.1 | 3400 | 3400 | 2.10812 | 0.00250838 | 19.6908 | 18 deg
MULLION | Z/3252 | +3.207 | 9 | 18 | 111.3 | 1.9 | 3207.2 | 3207.22 | 1.98867 | 0.00236616 | 18.5743
2 x COLUMN | Z/3250 | +3.400 | 10 | 18.9 | 111.2 | 2.1 | 3400 | 3400 | 2.10812 | 0.00250838 | 19.6908 | 15 deg
2 x COLUMN | Z/2348 | +3.400 | 10 | 18.9 | 111.2 | 2.1 | 3400 | 3400 | 2.10812 | 0.00250838 | 19.6908 | 15 deg
MULLION | Z/3249 | +3.191 | 9 | 17.8 | 111.3 | 1.9 | 3190.7 | 3190.67 | 1.97841 | 0.00235395 | 18.4785
MULLION | Z/3246 | +3.174 | 9 | 17.7 | 111.3 | 1.9 | 3174.1 | 3174.06 | 1.96812 | 0.00234169 | 18.3823
2 x COLUMN | Z/3244 | +3.400 | 10 | 18.9 | 111.2 | 2.1 | 3400 | 3400 | 2.10812 | 0.00250838 | 19.6908 | 9 deg
2 x COLUMN | Z/2343 | +3.400 | 10 | 18.9 | 111.2 | 2.1 | 3400 | 3400 | 2.10812 | 0.00250838 | 19.6908 | 9 deg
MULLION | Z/3243 | +3.152 | 9 | 17.7 | 111.3 | 1.9 | 3151.7 | 3151.67 | 1.95425 | 0.00232518 | 18.2526
2 x COLUMN | Z/3241 | +3.400 | 10 | 18.9 | 111.2 | 2.1 | 3400 | 3400 | 2.10812 | 0.00250838 | 19.6908 | 5 deg
2 x COLUMN | Z/2340 | +3.400 | 10 | 18.9 | 111.2 | 2.1 | 3400 | 3400 | 2.10812 | 0.00250838 | 19.6908 | 5 deg
MULLION | Z/3240 | +3.140 | 9 | 17.5 | 111.3 | 1.9 | 3140.3 | 3140.31 | 1.94721 | 0.0023168 | 18.1868
2 x COLUMN | Z/3238 | +3.400 | 10 | 18.9 | 111.2 | 2.1 | 3400 | 3400 | 2.10812 | 0.00250838 | 19.6908 | 3 deg
2 x COLUMN | Z/2337 | +3.400 | 10 | 18.9 | 111.2 | 2.1 | 3400 | 3400 | 2.10812 | 0.00250838 | 19.6908 | 3 deg
MULLION | Z/2353 | +3.224 | 9 | 18 | 111.3 | 1.9 | 3223.8 | 3223.81 | 1.99895 | 0.0023784 | 18.6704
MULLION | Z/2350 | +3.207 | 9 | 18 | 111.3 | 1.9 | 3207.2 | 3207.22 | 1.98867 | 0.00236616 | 18.5743
MULLION | Z/2347 | +3.191 | 9 | 17.8 | 111.3 | 1.9 | 3190.7 | 3190.67 | 1.97841 | 0.00235395 | 18.4785
MULLION | Z/2345 | +3.174 | 9 | 17.7 | 111.3 | 1.9 | 3174.1 | 3174.06 | 1.96812 | 0.00234169 | 18.3823
MULLION | Z/2342 | +3.152 | 9 | 17.7 | 111.3 | 1.9 | 3151.7 | 3151.67 | 1.95425 | 0.00232518 | 18.2526
MULLION | Z/2355 | +3.263 | 9 | 18.2 | 111.3 | 1.9 | 3263.2 | 3263.18 | 2.02334 | 0.00240744 | 18.8984
MULLION | Z/2339 | +3.140 | 9 | 17.5 | 111.3 | 1.9 | 3140.3 | 3140.31 | 1.94721 | 0.0023168 | 18.1868

# IfcElementAssembly (261)
In: Undefined
PredefinedType: RIGID_FRAME
Name | ASSEMBLY_POS = Assembly/Cast unit Mark | Assembly/Cast unit weight (kg) | Assembly/Cast unit bottom elevation | Assembly/Cast unit top elevation | Width (mm) | ASSEMBLY_POSITION_CODE = Assembly/Cast unit position code
3 x RAFTER | Z/108(?) | 7.1 | +2.901 | +3.356 | 76
3 x RAFTER | Z/107(?) | 7.1 | +2.901 | +3.356 | 76
3 x PLATE | PL/44(?) | 3.6 | +3.095 | +3.372 | 79
MULLION TOP PLATE | Z/3743 | 1.2 | +2.995 | +3.095 | 100.002
2 x MULLION | Z/3742 | 17.1 | +0.000 | +3.075 | 64
MULLION TOP PLATE | PL/2597 | 1.2 | +2.995 | +3.095 | 100.002
MULLION TOP PLATE | PL/2158 | 1.2 | +3.100 | +3.203 | 87.6104 | 10deg>/1
MULLION TOP PLATE | PL/2158 | 1.2 | +3.100 | +3.203 | 87.6104 | 10deg/1
MULLION TOP PLATE | PL/1678 | 1.2 | +3.100 | +3.203 | 87.6104 | 10deg/2
MULLION TOP PLATE | PL/1678 | 1.2 | +3.100 | +3.203 | 87.6104 | 10deg>/2
2 x RAFTER | Z/2346 | 8.4 | +3.151 | +3.561 | 64 | 10deg>/1-2
MULLION | Z/3259 | 17.7 | +0.000 | +3.180 | 64 | 10deg>/2
2 x RAFTER | Z/3248 | 8.4 | +3.151 | +3.561 | 64 | 10deg>/1-2
MULLION | Z/2384 | 17.7 | +0.000 | +3.180 | 64 | 10deg>/1
COLUMN | Z/6 | 18.9 | +0.000 | +3.400 | 64 | 10deg>/2
COLUMN | Z/3247 | 18.9 | +0.000 | +3.400 | 64 | 10deg>/2
COLUMN | Z/6 | 18.9 | +0.000 | +3.400 | 64 | 10deg>/1
COLUMN | Z/3247 | 18.9 | +0.000 | +3.400 | 64 | 10deg>/1
2 x RAFTER | Z/3248 | 8.4 | +3.151 | +3.561 | 64 | 10deg/1-2
COLUMN | Z/3247 | 18.9 | +0.000 | +3.400 | 64 | 10deg/2
MULLION | Z/3259 | 17.7 | +0.000 | +3.180 | 64 | 10deg/2
2 x RAFTER | Z/2346 | 8.4 | +3.151 | +3.561 | 64 | 10deg/1-2
COLUMN | Z/6 | 18.9 | +0.000 | +3.400 | 64 | 10deg/2
GIRT | Z/2336 | 6.5 | +2.382 | +2.533 | 151.5 | 10deg/1-2
GIRT | Z/2335 | 5.2 | +2.216 | +2.340 | 124.5 | 10deg/1-2
GIRT | Z/2334 | 3.8 | +2.048 | +2.148 | 100.5 | 10deg/1-2
COLUMN | Z/3247 | 18.9 | +0.000 | +3.400 | 64 | 10deg/1
GIRT | Z/2333 | 2.7 | +1.768 | +1.933 | 165 | 10deg/1-2
GIRT | Z/2332 | 2.7 | +1.275 | +1.425 | 150 | 10deg/1-2
GIRT | Z/2331 | 2.7 | +0.787 | +0.912 | 125 | 10deg/1-2
GIRT | Z/2330 | 2.7 | +0.285 | +0.415 | 130 | 10deg/1-2
MULLION | Z/2384 | 17.7 | +0.000 | +3.180 | 64 | 10deg/1
COLUMN | Z/6 | 18.9 | +0.000 | +3.400 | 64 | 10deg/1
MULLION TOP PLATE | PL/2157 | 1.2 | +3.183 | +3.284 | 95.1626 | 25deg-10deg/2
MULLION TOP PLATE | PL/2156 | 1.2 | +3.144 | +3.246 | 99.8563 | 18deg-25deg/2
MULLION TOP PLATE | PL/2155 | 1.2 | +3.127 | +3.230 | 101.422 | 15deg-18deg/2
MULLION TOP PLATE | PL/2154 | 1.2 | +3.111 | +3.214 | 102.7 | 12deg-15deg/2
MULLION TOP PLATE | PL/2153 | 1.2 | +3.094 | +3.198 | 103.709 | 9deg-12deg/2
MULLION TOP PLATE | PL/2152 | 1.2 | +3.072 | +3.176 | 104.599 | 5deg-9deg/2
MULLION TOP PLATE | PL/2151 | 1.2 | +3.060 | +3.165 | 104.858 | 3deg-5deg/2
MULLION TOP PLATE | PL/2156 | 1.2 | +3.144 | +3.246 | 99.8563 | 18deg/2
MULLION TOP PLATE | PL/2155 | 1.2 | +3.127 | +3.230 | 101.422 | 15deg/2
MULLION TOP PLATE | PL/2154 | 1.2 | +3.111 | +3.214 | 102.7 | 12deg/2
MULLION TOP PLATE | PL/2153 | 1.2 | +3.094 | +3.198 | 103.709 | 9deg/2
MULLION TOP PLATE | PL/2152 | 1.2 | +3.072 | +3.176 | 104.599 | 5deg/2
MULLION TOP PLATE | PL/2157 | 1.2 | +3.183 | +3.284 | 95.1626 | 25deg/2
MULLION TOP PLATE | PL/2151 | 1.2 | +3.060 | +3.165 | 104.858 | 3deg/2
MULLION TOP PLATE | PL/1637 | 1.2 | +3.183 | +3.284 | 95.1626 | 25deg-10deg/1
MULLION TOP PLATE | PL/1636 | 1.2 | +3.144 | +3.246 | 99.8563 | 18deg-25deg/1
MULLION TOP PLATE | PL/1635 | 1.2 | +3.127 | +3.230 | 101.422 | 15deg-18deg/1
MULLION TOP PLATE | PL/1634 | 1.2 | +3.111 | +3.214 | 102.7 | 12deg-15deg/1
MULLION TOP PLATE | PL/1633 | 1.2 | +3.094 | +3.198 | 103.709 | 9deg-12deg/1
MULLION TOP PLATE | PL/1632 | 1.2 | +3.072 | +3.176 | 104.599 | 5deg-9deg/1
MULLION TOP PLATE | PL/1631 | 1.2 | +3.060 | +3.165 | 104.858 | 3deg-5deg/1
MULLION TOP PLATE | PL/1636 | 1.2 | +3.144 | +3.246 | 99.8563 | 18deg/1
MULLION TOP PLATE | PL/1635 | 1.2 | +3.127 | +3.230 | 101.422 | 15deg/1
MULLION TOP PLATE | PL/1634 | 1.2 | +3.111 | +3.214 | 102.7 | 12deg/1
MULLION TOP PLATE | PL/1633 | 1.2 | +3.094 | +3.198 | 103.709 | 9deg/1
MULLION TOP PLATE | PL/1632 | 1.2 | +3.072 | +3.176 | 104.599 | 5deg/1
MULLION TOP PLATE | PL/1637 | 1.2 | +3.183 | +3.284 | 95.1626 | 25deg/1
MULLION TOP PLATE | PL/1631 | 1.2 | +3.060 | +3.165 | 104.858 | 3deg/1
2 x RAFTER | Z/2354 | 8.4 | +3.162 | +3.934 | 64 | 25deg-10deg/1-2
COLUMN | Z/8 | 18.9 | +0.000 | +3.400 | 64 | 25deg-10deg/2
MULLION | Z/3258 | 18.2 | +0.000 | +3.263 | 64 | 25deg-10deg/2
2 x RAFTER | Z/3257 | 8.4 | +3.162 | +3.934 | 64 | 25deg-10deg/1-2
COLUMN | Z/3256 | 18.9 | +0.000 | +3.400 | 64 | 25deg-10deg/2
COLUMN | Z/8 | 18.9 | +0.000 | +3.400 | 64 | 25deg-10deg/1
MULLION | Z/2355 | 18.2 | +0.000 | +3.263 | 64 | 25deg-10deg/1
COLUMN | Z/3256 | 18.9 | +0.000 | +3.400 | 64 | 25deg-10deg/1
2 x RAFTER | Z/2352 | 8.4 | +3.155 | +3.764 | 64 | 18deg-25deg/1-2
COLUMN | Z/2351 | 18.9 | +0.000 | +3.400 | 64 | 18deg-25deg/2
MULLION | Z/3255 | 18 | +0.000 | +3.224 | 64 | 18deg-25deg/2
2 x RAFTER | Z/3254 | 8.4 | +3.155 | +3.764 | 64 | 18deg-25deg/1-2
COLUMN | Z/3253 | 18.9 | +0.000 | +3.400 | 64 | 18deg-25deg/2
COLUMN | Z/2351 | 18.9 | +0.000 | +3.400 | 64 | 18deg-25deg/1
MULLION | Z/2353 | 18 | +0.000 | +3.224 | 64 | 18deg-25deg/1
COLUMN | Z/3253 | 18.9 | +0.000 | +3.400 | 64 | 18deg-25deg/1
2 x RAFTER | Z/2349 | 8.4 | +3.153 | +3.688 | 64 | 15deg-18deg/1-2
COLUMN | Z/2348 | 18.9 | +0.000 | +3.400 | 64 | 15deg-18deg/2
MULLION | Z/3252 | 18 | +0.000 | +3.207 | 64 | 15deg-18deg/2
2 x RAFTER | Z/3251 | 8.4 | +3.153 | +3.688 | 64 | 15deg-18deg/1-2
COLUMN | Z/3250 | 18.9 | +0.000 | +3.400 | 64 | 15deg-18deg/2
COLUMN | Z/2348 | 18.9 | +0.000 | +3.400 | 64 | 15deg-18deg/1
MULLION | Z/2350 | 18 | +0.000 | +3.207 | 64 | 15deg-18deg/1
COLUMN | Z/3250 | 18.9 | +0.000 | +3.400 | 64 | 15deg-18deg/1
2 x RAFTER | Z/2346 | 8.4 | +3.151 | +3.612 | 64 | 12deg-15deg/1-2
COLUMN | Z/6 | 18.9 | +0.000 | +3.400 | 64 | 12deg-15deg/2
MULLION | Z/3249 | 17.8 | +0.000 | +3.191 | 64 | 12deg-15deg/2
2 x RAFTER | Z/3248 | 8.4 | +3.151 | +3.612 | 64 | 12deg-15deg/1-2
COLUMN | Z/3247 | 18.9 | +0.000 | +3.400 | 64 | 12deg-15deg/2
COLUMN | Z/6 | 18.9 | +0.000 | +3.400 | 64 | 12deg-15deg/1
MULLION | Z/2347 | 17.8 | +0.000 | +3.191 | 64 | 12deg-15deg/1
COLUMN | Z/3247 | 18.9 | +0.000 | +3.400 | 64 | 12deg-15deg/1
2 x RAFTER | Z/2344 | 8.4 | +3.150 | +3.535 | 64 | 9deg-12deg/1-2
COLUMN | Z/2343 | 18.9 | +0.000 | +3.400 | 64 | 9deg-12deg/2
MULLION | Z/3246 | 17.7 | +0.000 | +3.174 | 64 | 9deg-12deg/2
2 x RAFTER | Z/3245 | 8.4 | +3.150 | +3.535 | 64 | 9deg-12deg/1-2
COLUMN | Z/3244 | 18.9 | +0.000 | +3.400 | 64 | 9deg-12deg/2
COLUMN | Z/2343 | 18.9 | +0.000 | +3.400 | 64 | 9deg-12deg/1
MULLION | Z/2345 | 17.7 | +0.000 | +3.174 | 64 | 9deg-12deg/1
COLUMN | Z/3244 | 18.9 | +0.000 | +3.400 | 64 | 9deg-12deg/1
2 x RAFTER | Z/2341 | 8.4 | +3.149 | +3.431 | 64 | 5deg-9deg/1-2
COLUMN | Z/2340 | 18.9 | +0.000 | +3.400 | 64 | 5deg-9deg/2
MULLION | Z/3243 | 17.7 | +0.000 | +3.152 | 64 | 5deg-9deg/2
2 x RAFTER | Z/3242 | 8.4 | +3.149 | +3.431 | 64 | 5deg-9deg/1-2
COLUMN | Z/3241 | 18.9 | +0.000 | +3.400 | 64 | 5deg-9deg/2
COLUMN | Z/2340 | 18.9 | +0.000 | +3.400 | 64 | 5deg-9deg/1
MULLION | Z/2342 | 17.7 | +0.000 | +3.152 | 64 | 5deg-9deg/1
COLUMN | Z/3241 | 18.9 | +0.000 | +3.400 | 64 | 5deg-9deg/1
2 x RAFTER | Z/2338 | 8.4 | +3.148 | +3.379 | 64 | 3deg-5deg/1-2
COLUMN | Z/2337 | 18.9 | +0.000 | +3.400 | 64 | 3deg-5deg/2
MULLION | Z/3240 | 17.5 | +0.000 | +3.140 | 64 | 3deg-5deg/2
2 x RAFTER | Z/3239 | 8.4 | +3.148 | +3.379 | 64 | 3deg-5deg/1-2
COLUMN | Z/3238 | 18.9 | +0.000 | +3.400 | 64 | 3deg-5deg/2
COLUMN | Z/2337 | 18.9 | +0.000 | +3.400 | 64 | 3deg-5deg/1
MULLION | Z/2339 | 17.5 | +0.000 | +3.140 | 64 | 3deg-5deg/1
COLUMN | Z/3238 | 18.9 | +0.000 | +3.400 | 64 | 3deg-5deg/1
2 x RAFTER | Z/3257 | 8.4 | +3.162 | +3.934 | 64 | 25deg/1-2
COLUMN | Z/3256 | 18.9 | +0.000 | +3.400 | 64 | 25deg/2
MULLION | Z/3258 | 18.2 | +0.000 | +3.263 | 64 | 25deg/2
2 x RAFTER | Z/2354 | 8.4 | +3.162 | +3.934 | 64 | 25deg/1-2
COLUMN | Z/8 | 18.9 | +0.000 | +3.400 | 64 | 25deg/2
2 x RAFTER | Z/3254 | 8.4 | +3.155 | +3.764 | 64 | 18deg/1-2
COLUMN | Z/3253 | 18.9 | +0.000 | +3.400 | 64 | 18deg/2
MULLION | Z/3255 | 18 | +0.000 | +3.224 | 64 | 18deg/2
2 x RAFTER | Z/2352 | 8.4 | +3.155 | +3.764 | 64 | 18deg/1-2
COLUMN | Z/2351 | 18.9 | +0.000 | +3.400 | 64 | 18deg/2
2 x RAFTER | Z/3251 | 8.4 | +3.153 | +3.688 | 64 | 15deg/1-2
COLUMN | Z/3250 | 18.9 | +0.000 | +3.400 | 64 | 15deg/2
MULLION | Z/3252 | 18 | +0.000 | +3.207 | 64 | 15deg/2
2 x RAFTER | Z/2349 | 8.4 | +3.153 | +3.688 | 64 | 15deg/1-2
COLUMN | Z/2348 | 18.9 | +0.000 | +3.400 | 64 | 15deg/2
2 x RAFTER | Z/3248 | 8.4 | +3.151 | +3.612 | 64 | 12deg/1-2
COLUMN | Z/3247 | 18.9 | +0.000 | +3.400 | 64 | 12deg/2
MULLION | Z/3249 | 17.8 | +0.000 | +3.191 | 64 | 12deg/2
2 x RAFTER | Z/2346 | 8.4 | +3.151 | +3.612 | 64 | 12deg/1-2
COLUMN | Z/6 | 18.9 | +0.000 | +3.400 | 64 | 12deg/2
2 x RAFTER | Z/3245 | 8.4 | +3.150 | +3.535 | 64 | 9deg/1-2
COLUMN | Z/3244 | 18.9 | +0.000 | +3.400 | 64 | 9deg/2
MULLION | Z/3246 | 17.7 | +0.000 | +3.174 | 64 | 9deg/2
2 x RAFTER | Z/2344 | 8.4 | +3.150 | +3.535 | 64 | 9deg/1-2
COLUMN | Z/2343 | 18.9 | +0.000 | +3.400 | 64 | 9deg/2
2 x RAFTER | Z/3242 | 8.4 | +3.149 | +3.431 | 64 | 5deg/1-2
COLUMN | Z/3241 | 18.9 | +0.000 | +3.400 | 64 | 5deg/2
MULLION | Z/3243 | 17.7 | +0.000 | +3.152 | 64 | 5deg/2
2 x RAFTER | Z/2341 | 8.4 | +3.149 | +3.431 | 64 | 5deg/1-2
COLUMN | Z/2340 | 18.9 | +0.000 | +3.400 | 64 | 5deg/2
2 x RAFTER | Z/3239 | 8.4 | +3.148 | +3.379 | 64 | 3deg/1-2
COLUMN | Z/3238 | 18.9 | +0.000 | +3.400 | 64 | 3deg/2
MULLION | Z/3240 | 17.5 | +0.000 | +3.140 | 64 | 3deg/2
2 x RAFTER | Z/2338 | 8.4 | +3.148 | +3.379 | 64 | 3deg/1-2
COLUMN | Z/2337 | 18.9 | +0.000 | +3.400 | 64 | 3deg/2
GIRT | Z/2336 | 6.5 | +2.382 | +2.533 | 151.5 | 18deg/1-2
GIRT | Z/2335 | 5.2 | +2.216 | +2.340 | 124.5 | 18deg/1-2
GIRT | Z/2334 | 3.8 | +2.048 | +2.148 | 100.5 | 18deg/1-2
COLUMN | Z/3253 | 18.9 | +0.000 | +3.400 | 64 | 18deg/1
GIRT | Z/2333 | 2.7 | +1.768 | +1.933 | 165 | 18deg/1-2
GIRT | Z/2332 | 2.7 | +1.275 | +1.425 | 150 | 18deg/1-2
GIRT | Z/2331 | 2.7 | +0.787 | +0.912 | 125 | 18deg/1-2
GIRT | Z/2330 | 2.7 | +0.285 | +0.415 | 130 | 18deg/1-2
MULLION | Z/2353 | 18 | +0.000 | +3.224 | 64 | 18deg/1
COLUMN | Z/2351 | 18.9 | +0.000 | +3.400 | 64 | 18deg/1
GIRT | Z/2336 | 6.5 | +2.382 | +2.533 | 151.5 | 15deg/1-2
GIRT | Z/2335 | 5.2 | +2.216 | +2.340 | 124.5 | 15deg/1-2
GIRT | Z/2334 | 3.8 | +2.048 | +2.148 | 100.5 | 15deg/1-2
COLUMN | Z/3250 | 18.9 | +0.000 | +3.400 | 64 | 15deg/1
GIRT | Z/2333 | 2.7 | +1.768 | +1.933 | 165 | 15deg/1-2
GIRT | Z/2332 | 2.7 | +1.275 | +1.425 | 150 | 15deg/1-2
GIRT | Z/2331 | 2.7 | +0.787 | +0.912 | 125 | 15deg/1-2
GIRT | Z/2330 | 2.7 | +0.285 | +0.415 | 130 | 15deg/1-2
MULLION | Z/2350 | 18 | +0.000 | +3.207 | 64 | 15deg/1
COLUMN | Z/2348 | 18.9 | +0.000 | +3.400 | 64 | 15deg/1
GIRT | Z/2336 | 6.5 | +2.382 | +2.533 | 151.5 | 12deg/1-2
GIRT | Z/2335 | 5.2 | +2.216 | +2.340 | 124.5 | 12deg/1-2
GIRT | Z/2334 | 3.8 | +2.048 | +2.148 | 100.5 | 12deg/1-2
COLUMN | Z/3247 | 18.9 | +0.000 | +3.400 | 64 | 12deg/1
GIRT | Z/2333 | 2.7 | +1.768 | +1.933 | 165 | 12deg/1-2
GIRT | Z/2332 | 2.7 | +1.275 | +1.425 | 150 | 12deg/1-2
GIRT | Z/2331 | 2.7 | +0.787 | +0.912 | 125 | 12deg/1-2
GIRT | Z/2330 | 2.7 | +0.285 | +0.415 | 130 | 12deg/1-2
MULLION | Z/2347 | 17.8 | +0.000 | +3.191 | 64 | 12deg/1
COLUMN | Z/6 | 18.9 | +0.000 | +3.400 | 64 | 12deg/1
GIRT | Z/2336 | 6.5 | +2.382 | +2.533 | 151.5 | 9deg/1-2
GIRT | Z/2335 | 5.2 | +2.216 | +2.340 | 124.5 | 9deg/1-2
GIRT | Z/2334 | 3.8 | +2.048 | +2.148 | 100.5 | 9deg/1-2
COLUMN | Z/3244 | 18.9 | +0.000 | +3.400 | 64 | 9deg/1
GIRT | Z/2333 | 2.7 | +1.768 | +1.933 | 165 | 9deg/1-2
GIRT | Z/2332 | 2.7 | +1.275 | +1.425 | 150 | 9deg/1-2
GIRT | Z/2331 | 2.7 | +0.787 | +0.912 | 125 | 9deg/1-2
GIRT | Z/2330 | 2.7 | +0.285 | +0.415 | 130 | 9deg/1-2
MULLION | Z/2345 | 17.7 | +0.000 | +3.174 | 64 | 9deg/1
COLUMN | Z/2343 | 18.9 | +0.000 | +3.400 | 64 | 9deg/1
GIRT | Z/2336 | 6.5 | +2.382 | +2.533 | 151.5 | 5deg/1-2
GIRT | Z/2335 | 5.2 | +2.216 | +2.340 | 124.5 | 5deg/1-2
GIRT | Z/2334 | 3.8 | +2.048 | +2.148 | 100.5 | 5deg/1-2
COLUMN | Z/3241 | 18.9 | +0.000 | +3.400 | 64 | 5deg/1
GIRT | Z/2333 | 2.7 | +1.768 | +1.933 | 165 | 5deg/1-2
GIRT | Z/2332 | 2.7 | +1.275 | +1.425 | 150 | 5deg/1-2
GIRT | Z/2331 | 2.7 | +0.787 | +0.912 | 125 | 5deg/1-2
GIRT | Z/2330 | 2.7 | +0.285 | +0.415 | 130 | 5deg/1-2
MULLION | Z/2342 | 17.7 | +0.000 | +3.152 | 64 | 5deg/1
COLUMN | Z/2340 | 18.9 | +0.000 | +3.400 | 64 | 5deg/1
GIRT | Z/2336 | 6.5 | +2.382 | +2.533 | 151.5 | 25deg/1-2
GIRT | Z/2335 | 5.2 | +2.216 | +2.340 | 124.5 | 25deg/1-2
GIRT | Z/2334 | 3.8 | +2.048 | +2.148 | 100.5 | 25deg/1-2
COLUMN | Z/3256 | 18.9 | +0.000 | +3.400 | 64 | 25deg/1
GIRT | Z/2333 | 2.7 | +1.768 | +1.933 | 165 | 25deg/1-2
GIRT | Z/2332 | 2.7 | +1.275 | +1.425 | 150 | 25deg/1-2
GIRT | Z/2331 | 2.7 | +0.787 | +0.912 | 125 | 25deg/1-2
GIRT | Z/2330 | 2.7 | +0.285 | +0.415 | 130 | 25deg/1-2
MULLION | Z/2355 | 18.2 | +0.000 | +3.263 | 64 | 25deg/1
COLUMN | Z/8 | 18.9 | +0.000 | +3.400 | 64 | 25deg/1
GIRT | Z/2336 | 6.5 | +2.382 | +2.533 | 151.5 | 3deg/1-2
GIRT | Z/2335 | 5.2 | +2.216 | +2.340 | 124.5 | 3deg/1-2
GIRT | Z/2334 | 3.8 | +2.048 | +2.148 | 100.5 | 3deg/1-2
COLUMN | Z/3238 | 18.9 | +0.000 | +3.400 | 64 | 3deg/1
GIRT | Z/2333 | 2.7 | +1.768 | +1.933 | 165 | 3deg/1-2
GIRT | Z/2332 | 2.7 | +1.275 | +1.425 | 150 | 3deg/1-2
GIRT | Z/2331 | 2.7 | +0.787 | +0.912 | 125 | 3deg/1-2
GIRT | Z/2330 | 2.7 | +0.285 | +0.415 | 130 | 3deg/1-2
MULLION | Z/2339 | 17.5 | +0.000 | +3.140 | 64 | 3deg/1
COLUMN | Z/2337 | 18.9 | +0.000 | +3.400 | 64 | 3deg/1

# IfcMechanicalFastener: Bolt assembly (108)
In: Undefined
Tekla Bolt - Location: Site
Name | NominalDiameter (mm) = Washer diameter (mm) | NominalLength (mm) = Bolt length (mm) | Material = Bolt standard | Washer count = Nut count = Slotted hole x (mm) | Washer type | Washer name | Nut type | Nut name | Slotted hole y (mm) | Bolt hole diameter (mm) | Bolt count | Bolt size (mm) | Bolt Name
6 x Bolt assembly | 12 | 30 | 8.8S | 4 | HARD | WASHERM12-HARD | 8.8-HEX | NUTM12-8.8-HEX | 8 | 14 | 4 | 12 | BOLTM12*30
68 x Bolt assembly | 5 | 13 | TEK_16TPIM | 0 | UNDEF_WASH | UNDEFINED_WASHER5 | UNDEF_NUT | UNDEFINED_NUTM5 | 0 | 7 | 4 | 7 | TEKSCREW_M5*25
34 x Bolt assembly | 5 | 13 | TEK_16TPIM | 0 | UNDEF_WASH | UNDEFINED_WASHER5 | UNDEF_NUT | UNDEFINED_NUTM5 | 0 | 7 | 18 | 7 | TEKSCREW_M5*25

# IfcMember: C:150-24 (8)
In: Undefined
Description: C:150-24; Material: STEEL/G450
Tekla Quantity - Weight: 8.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 111.3 m2; Net surface area: 0.8 m2; Height: 152 mm; Width: 64 mm; Length: 1500 mm
Tekla Common - Finish: 25 deg; Bottom elevation: +3.162; Top elevation: +3.934; Phase: 1; Class: 1
Pset_MemberCommon - LoadBearing: no
BaseQuantities - Length: 1500 mm; OuterSurfaceArea: 0.930876 m2; GrossSurfaceArea: 0 m2; CrossSectionArea: 0.00071 m2; NetVolume: 0.00110664 m3; GrossVolume: 0.001065 m3; NetWeight: 8.68712 kg; GrossWeight: 8.36025 kg
Name | Reference
4 x RAFTER | Z/2354
4 x RAFTER | Z/3257

# IfcPlate: PLT3*181.6 (2)
In: Undefined
Description: PLT3*181.6; Material: STEEL/250
Tekla Common - Bottom elevation: +2.995; Top elevation: +3.095; Phase: 1; Class: 5
Tekla Quantity - Weight: 1.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.6 m2; Net surface area: 0.1 m2; Height: 181.6 mm; Width: 3 mm; Length: 280 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 181.638 mm; NetArea: 0.105657 m2; GrossArea: 0.0508585 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000153634 m3; GrossVolume: 0.000153634 m3
Name | ASSEMBLY_POS = Reference
MULLION TOP PLATE | Z/3743
MULLION TOP PLATE | PL/2597

# IfcPlate: PLT3*181.8 (4)
In: Undefined
Description: PLT3*181.8; Material: STEEL/250
Tekla Common - Bottom elevation: +3.183; Top elevation: +3.284; Phase: 1; Class: 5
Tekla Quantity - Weight: 1.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.8 m2; Net surface area: 0.1 m2; Height: 181.8 mm; Width: 3 mm; Length: 280 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 181.822 mm; NetArea: 0.106053 m2; GrossArea: 0.0509102 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000153914 m3; GrossVolume: 0.000153914 m3
Name | ASSEMBLY_POS = Reference
2 x MULLION TOP PLATE | PL/2157
2 x MULLION TOP PLATE | PL/1637

# IfcPlate: PLT3*182.9 (4)
In: Undefined
Description: PLT3*182.9; Material: STEEL/250
Tekla Common - Bottom elevation: +3.144; Top elevation: +3.246; Phase: 1; Class: 5
Tekla Quantity - Weight: 1.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.6 m2; Net surface area: 0.1 m2; Height: 183 mm; Width: 3 mm; Length: 280 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 182.866 mm; NetArea: 0.106564 m2; GrossArea: 0.0512025 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000154764 m3; GrossVolume: 0.000154764 m3
Name | ASSEMBLY_POS = Reference
2 x MULLION TOP PLATE | PL/2156
2 x MULLION TOP PLATE | PL/1636

# IfcPlate: PLT3*183 (4)
In: Undefined
Description: PLT3*183; Material: STEEL/250
Tekla Common - Bottom elevation: +3.100; Top elevation: +3.203; Phase: 1; Class: 5
Tekla Quantity - Weight: 1.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.8 m2; Net surface area: 0.1 m2; Height: 183 mm; Width: 3 mm; Length: 280 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 182.982 mm; NetArea: 0.10649 m2; GrossArea: 0.051235 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000154561 m3; GrossVolume: 0.000154561 m3
Name | ASSEMBLY_POS = Reference
2 x MULLION TOP PLATE | PL/2158
2 x MULLION TOP PLATE | PL/1678

# IfcPlate: PLT3*183.3 (4)
In: Undefined
Description: PLT3*183.3; Material: STEEL/250
Tekla Common - Bottom elevation: +3.127; Top elevation: +3.230; Phase: 1; Class: 5
Tekla Quantity - Weight: 1.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.6 m2; Net surface area: 0.1 m2; Height: 183.3 mm; Width: 3 mm; Length: 280 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 183.287 mm; NetArea: 0.106767 m2; GrossArea: 0.0513204 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000155103 m3; GrossVolume: 0.000155103 m3
Name | ASSEMBLY_POS = Reference
2 x MULLION TOP PLATE | PL/2155
2 x MULLION TOP PLATE | PL/1635

# IfcPlate: PLT3*183.7 (4)
In: Undefined
Description: PLT3*183.7; Material: STEEL/250
Tekla Common - Bottom elevation: +3.111; Top elevation: +3.214; Phase: 1; Class: 5
Tekla Quantity - Weight: 1.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.6 m2; Net surface area: 0.1 m2; Height: 183.7 mm; Width: 3 mm; Length: 280 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 183.682 mm; NetArea: 0.106955 m2; GrossArea: 0.0514309 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000155418 m3; GrossVolume: 0.000155418 m3
Name | ASSEMBLY_POS = Reference
2 x MULLION TOP PLATE | PL/2154
2 x MULLION TOP PLATE | PL/1634

# IfcPlate: PLT3*184.1 (4)
In: Undefined
Description: PLT3*184.1; Material: STEEL/250
Tekla Common - Bottom elevation: +3.094; Top elevation: +3.198; Phase: 1; Class: 5
Tekla Quantity - Weight: 1.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.6 m2; Net surface area: 0.1 m2; Height: 184.1 mm; Width: 3 mm; Length: 280 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 184.08 mm; NetArea: 0.107145 m2; GrossArea: 0.0515423 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000155734 m3; GrossVolume: 0.000155734 m3
Name | ASSEMBLY_POS = Reference
2 x MULLION TOP PLATE | PL/2153
2 x MULLION TOP PLATE | PL/1633

# IfcPlate: PLT3*184.6 (4)
In: Undefined
Description: PLT3*184.6; Material: STEEL/250
Tekla Common - Bottom elevation: +3.072; Top elevation: +3.176; Phase: 1; Class: 5
Tekla Quantity - Weight: 1.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.6 m2; Net surface area: 0.1 m2; Height: 184.6 mm; Width: 3 mm; Length: 280 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 184.582 mm; NetArea: 0.107381 m2; GrossArea: 0.051683 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00015613 m3; GrossVolume: 0.00015613 m3
Name | ASSEMBLY_POS = Reference
2 x MULLION TOP PLATE | PL/2152
2 x MULLION TOP PLATE | PL/1632

# IfcPlate: PLT3*184.8 (4)
In: Undefined
Description: PLT3*184.8; Material: STEEL/250
Tekla Common - Bottom elevation: +3.060; Top elevation: +3.165; Phase: 1; Class: 5
Tekla Quantity - Weight: 1.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.6 m2; Net surface area: 0.1 m2; Height: 184.8 mm; Width: 3 mm; Length: 280 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 184.835 mm; NetArea: 0.107501 m2; GrossArea: 0.0517539 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000156328 m3; GrossVolume: 0.000156328 m3
Name | ASSEMBLY_POS = Reference
2 x MULLION TOP PLATE | PL/2151
2 x MULLION TOP PLATE | PL/1631

# IfcPlate: PLT3*393.6 (3)
In: Undefined
Description: PLT3*393.6; Material: STEEL/450
Default - ASSEMBLY_POS: PL/44(?)
Tekla Common - Bottom elevation: +3.095; Top elevation: +3.372; Phase: 1; Class: 11
Tekla Quantity - Weight: 3.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.3 m2; Height: 393.6 mm; Width: 3 mm; Length: 541.3 mm
Pset_PlateCommon - LoadBearing: no; Reference: PL/44(?)
BaseQuantities - Width: 393.583 mm; NetArea: 0.307078 m2; GrossArea: 0.213063 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000453276 m3; GrossVolume: 0.000453276 m3
