Properties of the parts of a building model (IFC2X3), part 1 of 3

# File
Description: ViewDefinition[CoordinationView_V2.0, QuantityTakeOffAddOnView], Option [BaseQuantities:On], Option [GridExport:On], Option [Assemblies:On], Option [Bolts:On], Option [Rebars:On], Option [PourObjects:Off], Option [Welds:Off], Option [SurfaceTreatments:Off], Option [LocationBy:0], Option [ViewColors:Off], Option [SectionedSpine:Off], Option [PropertySets:On], Option [Export all:Off]
File name: B.ifc
Time: 2026-08-05T01:10:23
Author: LAPTOP-2P0BGI6B\lablab
Organization: Structural Designer
Written by: IFC Database Version: Work
Made in: Tekla Structures 2019 Service Pack 13, IFC Export Version: 4.0.0.0 Oct 18 2021

# IfcBuildingStorey, Undefined
In: Undefined
Elevation: 0 mm

# IfcBeam: C:150-15 (50)
In: Undefined
Description: C:150-15; Material: STEEL/300PLUS
Tekla Common - Phase: 1; Class: 13
Tekla Quantity - Weight: 3.4 kg; Volume: 0 m3; Gross footprint area: 0.1 m2; Area per tons: 176.5 m2; Net surface area: 0.7 m2; Height: 152 mm; Width: 64 mm; Length: 1000 mm
Pset_BeamCommon - LoadBearing: no
BaseQuantities - Length: 1000 mm; OuterSurfaceArea: 0.613915 m2; NetVolume: 0.0004575 m3; NetWeight: 3.59138 kg
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation
6 x FASCIA | F/10 | +4.909 | +5.061
4 x FASCIA | F/10 | +4.908 | +5.060
4 x FASCIA | Z/561 | +4.896 | +5.048
6 x FASCIA | Z/561 | +4.895 | +5.047
10 x FASCIA | Z/561 | +4.902 | +5.054
4 x FASCIA | Z/561 | +4.906 | +5.058
6 x FASCIA | Z/561 | +4.905 | +5.057
6 x FASCIA | Z/561 | +4.909 | +5.061
4 x FASCIA | Z/561 | +4.908 | +5.060

# IfcBeam: C:150-19 (50)
In: Undefined
Description: C:150-19; Material: STEEL/G450
Tekla Common - Phase: 1; Class: 5
Tekla Quantity - Volume: 0 m3; Height: 152 mm; Width: 64 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
BA-12-150 | Z/2470 | +5.322 | +5.474 | 12.8 | 0.2 | 139.7 | 1.8 | 2904.6 | 2904.57 | 1.78631 | 0.00168541 | 13.2304
BA-12-200 | Z/2529 | +5.267 | +5.419 | 14.4 | 0.2 | 139.6 | 2 | 3277 | 3277.03 | 2.01522 | 0.00190153 | 14.927
BA-12-250 | Z/2542 | +5.220 | +5.372 | 15.7 | 0.2 | 139.6 | 2.2 | 3570.8 | 3570.78 | 2.19576 | 0.00207198 | 16.2651
BA-12-300 | Z/2552 | +5.143 | +5.295 | 18.6 | 0.3 | 139.6 | 2.6 | 4229.6 | 4229.57 | 2.60065 | 0.00245425 | 19.2658
BA-12-350 | Z/2567 | +5.097 | +5.249 | 19.9 | 0.3 | 139.6 | 2.8 | 4517.5 | 4517.55 | 2.77764 | 0.00262135 | 20.5776
BA-12-350 | Z/2560 | +5.097 | +5.249 | 19.9 | 0.3 | 139.6 | 2.8 | 4517.5 | 4517.55 | 2.77764 | 0.00262135 | 20.5776
BA-12-300 | Z/2545 | +5.143 | +5.295 | 18.6 | 0.3 | 139.6 | 2.6 | 4229.6 | 4229.57 | 2.60065 | 0.00245425 | 19.2658
BA-12-250 | Z/2535 | +5.220 | +5.372 | 15.7 | 0.2 | 139.6 | 2.2 | 3570.8 | 3570.78 | 2.19576 | 0.00207198 | 16.2651
BA-12-200 | Z/2522 | +5.267 | +5.419 | 14.4 | 0.2 | 139.6 | 2 | 3277 | 3277.03 | 2.01522 | 0.00190153 | 14.927
BA-12-150 | Z/2435 | +5.322 | +5.474 | 12.8 | 0.2 | 139.7 | 1.8 | 2904.6 | 2904.57 | 1.78631 | 0.00168541 | 13.2304
BA-25-350 | Z/1425 | +5.856 | +6.008 | 16.3 | 0.2 | 120.8 | 2 | 3700 | 3700.01 | 1.96828 | 0.00185465 | 14.559
BA-18-350 | Z/1422 | +5.531 | +5.683 | 16.3 | 0.1 | 114.3 | 2 | 3700 | 3700.01 | 1.86217 | 0.00175337 | 13.7639
BA-15-350 | Z/1419 | +5.391 | +5.543 | 16.3 | 0.1 | 110.8 | 1.8 | 3700 | 3700.01 | 1.80469 | 0.00169841 | 13.3326
BA-12-350 | Z/1098 | +5.231 | +5.383 | 16.3 | 0.1 | 109.7 | 1.8 | 3700 | 3700.01 | 1.7854 | 0.00167956 | 13.1845
BA-25-300 | Z/1352 | +5.917 | +6.069 | 15.4 | 0.1 | 122.2 | 2 | 3500 | 3500 | 1.88398 | 0.00177529 | 13.936
BA-18-300 | Z/1349 | +5.577 | +5.729 | 15.4 | 0.1 | 116.7 | 1.8 | 3500 | 3500 | 1.79807 | 0.00169319 | 13.2915
BA-15-300 | Z/1346 | +5.427 | +5.579 | 15.4 | 0.1 | 114.5 | 1.8 | 3500 | 3500 | 1.76436 | 0.00166082 | 13.0375
BA-12-300 | Z/621 | +5.277 | +5.429 | 15.4 | 0.1 | 111.8 | 1.8 | 3500 | 3500 | 1.72383 | 0.0016218 | 12.7311
BA-25-250 | Z/1285 | +5.924 | +6.076 | 15.4 | 0.2 | 125 | 2 | 3500 | 3500 | 1.92593 | 0.00181514 | 14.2488
BA-18-250 | Z/1282 | +5.586 | +5.738 | 15.4 | 0.1 | 120.4 | 2 | 3500 | 3500 | 1.85614 | 0.00174836 | 13.7246
BA-15-250 | Z/1279 | +5.451 | +5.603 | 15.4 | 0.1 | 116.9 | 1.8 | 3500 | 3500 | 1.80173 | 0.00169632 | 13.3161
BA-12-250 | Z/582 | +5.318 | +5.470 | 15.4 | 0.1 | 111.8 | 1.8 | 3500 | 3500 | 1.72383 | 0.00162179 | 12.7311
BA-25-200 | Z/1219 | +5.984 | +6.136 | 14.4 | 0.2 | 126.9 | 1.8 | 3300 | 3300 | 1.8442 | 0.00173822 | 13.645
BA-18-200 | Z/1216 | +5.642 | +5.794 | 14.4 | 0.1 | 122.2 | 1.8 | 3300 | 3300 | 1.77498 | 0.00167198 | 13.125
BA-15-200 | Z/1213 | +5.495 | +5.647 | 14.4 | 0.1 | 120.1 | 1.8 | 3300 | 3300 | 1.7453 | 0.00164344 | 12.901
BA-12-200 | Z/539 | +5.365 | +5.517 | 14.4 | 0.1 | 114.3 | 1.8 | 3300 | 3300 | 1.66227 | 0.00156403 | 12.2776
BA-25-150 | Z/1158 | +6.051 | +6.203 | 13.7 | 0.1 | 128.4 | 1.8 | 3100 | 3100 | 1.75286 | 0.00165217 | 12.9695
BA-18-150 | Z/1155 | +5.687 | +5.839 | 13.7 | 0.1 | 125.6 | 1.8 | 3100 | 3100 | 1.71403 | 0.0016148 | 12.6762
BA-15-150 | Z/1152 | +5.539 | +5.691 | 13.7 | 0.1 | 123.7 | 1.8 | 3100 | 3100 | 1.68824 | 0.00158995 | 12.4811
BA-12-150 | Z/1143 | +5.400 | +5.552 | 13.7 | 0.1 | 119.8 | 1.6 | 3100 | 3100 | 1.63613 | 0.00153992 | 12.0884
BA-25-350 | Z/1107 | +5.856 | +6.008 | 16.3 | 0.2 | 120.8 | 2 | 3700 | 3700 | 1.96828 | 0.00185465 | 14.559
BA-25-300 | Z/1080 | +5.917 | +6.069 | 15.4 | 0.1 | 122.2 | 2 | 3500 | 3500 | 1.88398 | 0.00177529 | 13.936
BA-25-250 | Z/1049 | +5.924 | +6.076 | 15.4 | 0.2 | 125 | 2 | 3500 | 3500 | 1.92593 | 0.00181514 | 14.2488
BA-25-200 | Z/1022 | +5.984 | +6.136 | 14.4 | 0.2 | 126.9 | 1.8 | 3300 | 3300 | 1.8442 | 0.00173822 | 13.645
BA-25-150 | Z/307 | +6.051 | +6.203 | 13.7 | 0.1 | 128.4 | 1.8 | 3100 | 3100 | 1.75286 | 0.00165217 | 12.9695
BA-18-350 | Z/1104 | +5.531 | +5.683 | 16.3 | 0.1 | 114.3 | 2 | 3700 | 3700 | 1.86217 | 0.00175337 | 13.7639
BA-18-300 | Z/1077 | +5.577 | +5.729 | 15.4 | 0.1 | 116.7 | 1.8 | 3500 | 3500 | 1.79807 | 0.00169319 | 13.2915
BA-18-250 | Z/1046 | +5.586 | +5.738 | 15.4 | 0.1 | 120.4 | 2 | 3500 | 3500 | 1.85614 | 0.00174836 | 13.7246
BA-18-200 | Z/1019 | +5.642 | +5.794 | 14.4 | 0.1 | 122.2 | 1.8 | 3300 | 3300 | 1.77498 | 0.00167198 | 13.125
BA-18-150 | Z/206 | +5.687 | +5.839 | 13.7 | 0.1 | 125.6 | 1.8 | 3100 | 3100 | 1.71403 | 0.0016148 | 12.6762
BA-15-350 | Z/1101 | +5.391 | +5.543 | 16.3 | 0.1 | 110.8 | 1.8 | 3700 | 3700 | 1.80469 | 0.00169841 | 13.3326
BA-15-300 | Z/1074 | +5.427 | +5.579 | 15.4 | 0.1 | 114.5 | 1.8 | 3500 | 3500 | 1.76436 | 0.00166082 | 13.0375
BA-15-250 | Z/1043 | +5.451 | +5.603 | 15.4 | 0.1 | 116.9 | 1.8 | 3500 | 3500 | 1.80173 | 0.00169632 | 13.3161
BA-15-200 | Z/1016 | +5.495 | +5.647 | 14.4 | 0.1 | 120.1 | 1.8 | 3300 | 3300 | 1.7453 | 0.00164344 | 12.901
BA-15-150 | Z/190 | +5.539 | +5.691 | 13.7 | 0.1 | 123.7 | 1.8 | 3100 | 3100 | 1.68824 | 0.00158995 | 12.4811
BA-12-350 | Z/1098 | +5.231 | +5.383 | 16.3 | 0.1 | 109.7 | 1.8 | 3700 | 3700 | 1.7854 | 0.00167956 | 13.1845
BA-12-300 | Z/1071 | +5.277 | +5.429 | 15.4 | 0.1 | 111.8 | 1.8 | 3500 | 3500 | 1.72384 | 0.0016218 | 12.7311
BA-12-250 | Z/1040 | +5.318 | +5.470 | 15.4 | 0.1 | 111.8 | 1.8 | 3500 | 3500 | 1.72383 | 0.00162179 | 12.7311
BA-12-200 | Z/1013 | +5.365 | +5.517 | 14.4 | 0.1 | 114.3 | 1.8 | 3300 | 3300 | 1.66227 | 0.00156403 | 12.2776
BA-12-150 | Z/23 | +5.400 | +5.552 | 13.7 | 0.1 | 119.8 | 1.6 | 3100 | 3100 | 1.63613 | 0.00153992 | 12.0884

# IfcBeam: C:150-24 (26)
In: Undefined
Description: C:150-24; Material: STEEL/G450
Tekla Common - Phase: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 111.2 m2; Height: 152 mm; Width: 64 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Finish | Bottom elevation | Top elevation | Class | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x COLUMN | Z/2356 | 12 deg | +0.000 | +5.063 | 10 | 28.2 | 3.1 | 5063.1 | 5063.14 | 3.1386 | 0.00373538 | 29.3228
RAFTER | Z/2357 | 12 deg | +4.879 | +5.713 | 1 | 22 | 2.4 | 3942.5 | 3942.51 | 2.44426 | 0.00290863 | 22.8327
RAFTER | Z/2357 | 12 deg | +4.879 | +5.713 | 1 | 22 | 2.4 | 3942.5 | 3942.5 | 2.44425 | 0.00290862 | 22.8327
RAFTER | Z/2358 | 12 deg | +4.879 | +5.713 | 1 | 22 | 2.4 | 3942.5 | 3942.51 | 2.44426 | 0.00290863 | 22.8327
RAFTER | Z/2358 | 12 deg | +4.879 | +5.713 | 1 | 22 | 2.4 | 3942.5 | 3942.5 | 2.44425 | 0.00290862 | 22.8327
COLUMN | Z/1020 | 25 deg | +0.000 | +5.050 | 10 | 28.1 | 3.1 | 5050.1 | 5050.09 | 3.13051 | 0.00372575 | 29.2472
2 x RAFTER | Z/1017 | 18 deg | +4.908 | +6.307 | 1 | 22.6 | 2.4 | 4060.8 | 4060.78 | 2.51754 | 0.00299588 | 23.5177
COLUMN | Z/1014 | 18 deg | +0.000 | +5.057 | 10 | 28.2 | 3.1 | 5056.8 | 5056.79 | 3.13466 | 0.0037307 | 29.286
2 x RAFTER | Z/308 | 15 deg | +4.896 | +6.080 | 1 | 22.3 | 2.4 | 4006.2 | 4006.17 | 2.4837 | 0.00295559 | 23.2014
COLUMN | Z/207 | 15 deg | +0.000 | +5.060 | 10 | 28.2 | 3.1 | 5059.9 | 5059.86 | 3.13656 | 0.00373296 | 29.3038
RAFTER | Z/1140 | 12 deg | +4.886 | +5.858 | 1 | 22.1 | 2.4 | 3964 | 3964.01 | 2.45758 | 0.00292449 | 22.9572
RAFTER | Z/1139 | 12 deg | +4.886 | +5.858 | 1 | 22.1 | 2.4 | 3964 | 3964.01 | 2.45758 | 0.00292449 | 22.9572
COLUMN | Z/51 | 12 deg | +0.000 | +5.063 | 10 | 28.2 | 3.1 | 5063.1 | 5063.14 | 3.1386 | 0.00373538 | 29.3228
COLUMN | Z/92 | 25 deg | +0.000 | +5.050 | 10 | 28.1 | 3.1 | 5050.1 | 5050.09 | 3.13051 | 0.00372575 | 29.2472
COLUMN | Z/89 | 18 deg | +0.000 | +5.057 | 10 | 28.2 | 3.1 | 5056.8 | 5056.79 | 3.13466 | 0.0037307 | 29.286
2 x RAFTER | Z/90 | 18 deg | +4.908 | +6.307 | 1 | 22.6 | 2.4 | 4060.8 | 4060.78 | 2.51754 | 0.00299588 | 23.5177
COLUMN | Z/86 | 15 deg | +0.000 | +5.060 | 10 | 28.2 | 3.1 | 5059.9 | 5059.86 | 3.13656 | 0.00373296 | 29.3038
2 x RAFTER | Z/87 | 15 deg | +4.896 | +6.080 | 1 | 22.3 | 2.4 | 4006.2 | 4006.17 | 2.4837 | 0.00295559 | 23.2014
COLUMN | Z/1181 | 12 deg | +0.000 | +5.063 | 10 | 28.2 | 3.1 | 5063.1 | 5063.14 | 3.1386 | 0.00373538 | 29.3228
RAFTER | Z/1180 | 12 deg | +4.886 | +5.858 | 1 | 22.1 | 2.4 | 3964 | 3964.01 | 2.45758 | 0.00292449 | 22.9572
RAFTER | Z/1179 | 12 deg | +4.886 | +5.858 | 1 | 22.1 | 2.4 | 3964 | 3964.01 | 2.45758 | 0.00292449 | 22.9572

# IfcBeam: C:200-24 (26)
In: Undefined
Description: C:200-24; Material: STEEL/G450
Tekla Common - Phase: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 110 m2; Height: 203 mm; Width: 76 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Finish | Bottom elevation | Top elevation | Class | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
4 x RAFTER | Z/2360 | 12 deg | +4.837 | +5.716 | 1 | 27.7 | 3 | 3907.6 | 3907.62 | 3.04824 | 0.00363314 | 28.5202
2 x COLUMN | Z/2359 | 12 deg | +0.000 | +5.063 | 10 | 35.9 | 3.9 | 5063.3 | 5063.16 | 3.9491 | 0.00470752 | 36.9541
COLUMN | Z/1198 | 25 deg | +0.000 | +5.050 | 10 | 35.9 | 3.9 | 5050.1 | 5050.09 | 3.93891 | 0.00469537 | 36.8587
2 x RAFTER | Z/1197 | 18 deg | +4.876 | +6.310 | 1 | 28.5 | 3.1 | 4017.4 | 4017.4 | 3.13382 | 0.00373522 | 29.3215
COLUMN | Z/1196 | 18 deg | +0.000 | +5.057 | 10 | 35.9 | 3.9 | 5056.8 | 5056.8 | 3.94414 | 0.00470161 | 36.9076
2 x RAFTER | Z/1195 | 15 deg | +4.861 | +6.083 | 1 | 28.1 | 3.1 | 3966.1 | 3966.1 | 3.09383 | 0.00368752 | 28.947
COLUMN | Z/1194 | 15 deg | +0.000 | +5.060 | 10 | 35.9 | 3.9 | 5059.9 | 5059.86 | 3.94653 | 0.00470446 | 36.93
RAFTER | Z/553 | 12 deg | +4.846 | +5.861 | 1 | 27.7 | 3.1 | 3927.1 | 3927.11 | 3.06344 | 0.00365127 | 28.6625
RAFTER | Z/554 | 12 deg | +4.846 | +5.861 | 1 | 27.7 | 3.1 | 3927.1 | 3927.11 | 3.06343 | 0.00365127 | 28.6625
COLUMN | Z/1192 | 12 deg | +0.000 | +5.063 | 10 | 35.9 | 3.9 | 5063.3 | 5063.16 | 3.9491 | 0.00470752 | 36.9541
COLUMN | Z/111 | 25 deg | +0.000 | +5.050 | 10 | 35.9 | 3.9 | 5050.1 | 5050.09 | 3.93891 | 0.00469537 | 36.8587
COLUMN | Z/109 | 18 deg | +0.000 | +5.057 | 10 | 35.9 | 3.9 | 5056.8 | 5056.8 | 3.94414 | 0.00470161 | 36.9076
2 x RAFTER | Z/4 | 18 deg | +4.876 | +6.310 | 1 | 28.5 | 3.1 | 4017.4 | 4017.4 | 3.13382 | 0.00373522 | 29.3215
COLUMN | Z/106 | 15 deg | +0.000 | +5.060 | 10 | 35.9 | 3.9 | 5059.9 | 5059.86 | 3.94653 | 0.00470446 | 36.93
2 x RAFTER | Z/107 | 15 deg | +4.861 | +6.083 | 1 | 28.1 | 3.1 | 3966.1 | 3966.1 | 3.09383 | 0.00368752 | 28.947
COLUMN | Z/1246 | 12 deg | +0.000 | +5.063 | 10 | 35.9 | 3.9 | 5063.3 | 5063.16 | 3.9491 | 0.00470752 | 36.9541
RAFTER | Z/1245 | 12 deg | +4.846 | +5.861 | 1 | 27.7 | 3.1 | 3927.1 | 3927.11 | 3.06344 | 0.00365127 | 28.6625
RAFTER | Z/1244 | 12 deg | +4.846 | +5.861 | 1 | 27.7 | 3.1 | 3927.1 | 3927.11 | 3.06343 | 0.00365127 | 28.6625

# IfcBeam: C:250-24 (26)
In: Undefined
Description: C:250-24; Material: STEEL/G450
Tekla Common - Phase: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 109.7 m2; Height: 254 mm; Width: 76 mm
Pset_BeamCommon - LoadBearing: no
Name | Finish | Bottom elevation | Top elevation | Class | ASSEMBLY_POS = Reference | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x COLUMN | 12 deg | +0.000 | +5.063 | 10 | Z/2361 | 40.6 | 4.5 | 5063.3 | 5063.25 | 4.45573 | 0.0053152 | 41.7243
2 x RAFTER | 12 deg | +4.796 | +5.719 | 1 | Z/2362 | 31.1 | 3.4 | 3872.7 | 3872.72 | 3.40855 | 0.00406543 | 31.9136
2 x RAFTER | 12 deg | +4.796 | +5.719 | 1 | Z/2362 | 31.1 | 3.4 | 3872.7 | 3872.73 | 3.40855 | 0.00406544 | 31.9137
COLUMN | 25 deg | +0.000 | +5.050 | 10 | Z/1265 | 40.5 | 4.5 | 5050.1 | 5050.08 | 4.44415 | 0.00530137 | 41.6158
2 x RAFTER | 18 deg | +4.844 | +6.313 | 1 | Z/1264 | 31.9 | 3.4 | 3974 | 3974.01 | 3.49764 | 0.00417175 | 32.7483
COLUMN | 18 deg | +0.000 | +5.057 | 10 | Z/1263 | 40.6 | 4.5 | 5056.8 | 5056.79 | 4.45005 | 0.00530842 | 41.6711
2 x RAFTER | 15 deg | +4.825 | +6.086 | 1 | Z/1262 | 31.5 | 3.4 | 3926 | 3926.04 | 3.45544 | 0.0041214 | 32.353
COLUMN | 15 deg | +0.000 | +5.060 | 10 | Z/1261 | 40.6 | 4.5 | 5059.9 | 5059.86 | 4.45275 | 0.00531164 | 41.6964
RAFTER | 12 deg | +4.807 | +5.865 | 1 | Z/1259 | 31.2 | 3.4 | 3890.2 | 3890.2 | 3.42392 | 0.00408378 | 32.0576
RAFTER | 12 deg | +4.807 | +5.865 | 1 | Z/1258 | 31.2 | 3.4 | 3890.2 | 3890.2 | 3.42392 | 0.00408377 | 32.0576
COLUMN | 12 deg | +0.000 | +5.063 | 10 | Z/1257 | 40.6 | 4.5 | 5063.3 | 5063.25 | 4.45573 | 0.0053152 | 41.7243
COLUMN | 25 deg | +0.000 | +5.050 | 10 | Z/130 | 40.5 | 4.5 | 5050.1 | 5050.08 | 4.44415 | 0.00530137 | 41.6158
COLUMN | 18 deg | +0.000 | +5.057 | 10 | Z/127 | 40.6 | 4.5 | 5056.8 | 5056.79 | 4.45005 | 0.00530842 | 41.6711
2 x RAFTER | 18 deg | +4.844 | +6.313 | 1 | Z/128 | 31.9 | 3.4 | 3974 | 3974.01 | 3.49764 | 0.00417175 | 32.7483
COLUMN | 15 deg | +0.000 | +5.060 | 10 | Z/124 | 40.6 | 4.5 | 5059.9 | 5059.86 | 4.45275 | 0.00531164 | 41.6964
2 x RAFTER | 15 deg | +4.825 | +6.086 | 1 | Z/125 | 31.5 | 3.4 | 3926 | 3926.04 | 3.45544 | 0.0041214 | 32.353
COLUMN | 12 deg | +0.000 | +5.063 | 10 | Z/1314 | 40.6 | 4.5 | 5063.3 | 5063.25 | 4.45573 | 0.0053152 | 41.7243
RAFTER | 12 deg | +4.807 | +5.865 | 1 | Z/1313 | 31.2 | 3.4 | 3890.2 | 3890.2 | 3.42392 | 0.00408378 | 32.0576
RAFTER | 12 deg | +4.807 | +5.865 | 1 | Z/1312 | 31.2 | 3.4 | 3890.2 | 3890.2 | 3.42392 | 0.00408377 | 32.0576

# IfcBeam: C:300-30 (26)
In: Undefined
Description: C:300-30; Material: STEEL/G450
Tekla Common - Phase: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.4 m2; Height: 300 mm; Width: 96 mm
Pset_BeamCommon - LoadBearing: no
Name | Finish | Bottom elevation | Top elevation | Class | ASSEMBLY_POS = Reference | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x COLUMN | 12 deg | +0.000 | +5.063 | 10 | Z/2363 | 63.3 | 5.5 | 5062.8 | 5062.81 | 5.53185 | 0.00824732 | 64.7414
2 x RAFTER | 12 deg | +4.759 | +5.722 | 1 | Z/2364 | 48 | 4.2 | 3841.3 | 3841.25 | 4.19791 | 0.0062574 | 49.1206
2 x RAFTER | 12 deg | +4.759 | +5.722 | 1 | Z/2364 | 48 | 4.2 | 3841.3 | 3841.26 | 4.19792 | 0.00625742 | 49.1207
COLUMN | 25 deg | +0.000 | +5.050 | 10 | Z/1332 | 63.2 | 5.5 | 5050.1 | 5050.09 | 5.51796 | 0.0082266 | 64.5788
2 x RAFTER | 18 deg | +4.815 | +6.317 | 1 | Z/1331 | 49.2 | 4.2 | 3934.9 | 3934.88 | 4.30015 | 0.00640992 | 50.3179
COLUMN | 18 deg | +0.000 | +5.057 | 10 | Z/1330 | 63.2 | 5.5 | 5056.8 | 5056.79 | 5.52527 | 0.00823751 | 64.6645
2 x RAFTER | 15 deg | +4.793 | +6.090 | 1 | Z/1329 | 48.6 | 4.2 | 3889.9 | 3889.9 | 4.25103 | 0.00633665 | 49.7427
COLUMN | 15 deg | +0.000 | +5.060 | 10 | Z/1328 | 63.3 | 5.5 | 5059.9 | 5059.86 | 5.52863 | 0.00824251 | 64.7037
RAFTER | 12 deg | +4.772 | +5.868 | 1 | Z/1326 | 48.2 | 4.2 | 3856.9 | 3856.9 | 4.215 | 0.00628289 | 49.3207
RAFTER | 12 deg | +4.772 | +5.868 | 1 | Z/1325 | 48.2 | 4.2 | 3856.9 | 3856.9 | 4.21499 | 0.00628289 | 49.3207
COLUMN | 12 deg | +0.000 | +5.063 | 10 | Z/1324 | 63.3 | 5.5 | 5062.8 | 5062.81 | 5.53185 | 0.00824732 | 64.7414
COLUMN | 25 deg | +0.000 | +5.050 | 10 | Z/149 | 63.2 | 5.5 | 5050.1 | 5050.09 | 5.51796 | 0.0082266 | 64.5788
COLUMN | 18 deg | +0.000 | +5.057 | 10 | Z/146 | 63.2 | 5.5 | 5056.8 | 5056.79 | 5.52527 | 0.00823751 | 64.6645
2 x RAFTER | 18 deg | +4.815 | +6.317 | 1 | Z/147 | 49.2 | 4.2 | 3934.9 | 3934.88 | 4.30015 | 0.00640992 | 50.3179
COLUMN | 15 deg | +0.000 | +5.060 | 10 | Z/143 | 63.3 | 5.5 | 5059.9 | 5059.86 | 5.52863 | 0.00824251 | 64.7037
2 x RAFTER | 15 deg | +4.793 | +6.090 | 1 | Z/144 | 48.6 | 4.2 | 3889.9 | 3889.9 | 4.25103 | 0.00633665 | 49.7427
COLUMN | 12 deg | +0.000 | +5.063 | 10 | Z/1385 | 63.3 | 5.5 | 5062.8 | 5062.81 | 5.53185 | 0.00824732 | 64.7414
RAFTER | 12 deg | +4.772 | +5.868 | 1 | Z/1384 | 48.2 | 4.2 | 3856.9 | 3856.9 | 4.215 | 0.00628289 | 49.3207
RAFTER | 12 deg | +4.772 | +5.868 | 1 | Z/1383 | 48.2 | 4.2 | 3856.9 | 3856.9 | 4.21499 | 0.00628289 | 49.3207

# IfcBeam: C:350-30 (26)
In: Undefined
Description: C:350-30; Material: STEEL/G450
Tekla Common - Phase: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.1 m2; Height: 350 mm; Width: 125 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Finish | Bottom elevation | Top elevation | Class | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
3 x RAFTER | Z/2366 | 12 deg | +4.719 | +5.725 | 1 | 56.9 | 5 | 3807.1 | 3807.06 | 4.96068 | 0.00740093 | 58.0973
2 x COLUMN | Z/2365 | 12 deg | +0.000 | +5.063 | 10 | 75.7 | 6.6 | 5063 | 5063.04 | 6.59596 | 0.00984254 | 77.264
RAFTER | Z/2367 | 12 deg | +4.719 | +5.725 | 1 | 56.9 | 5 | 3807.1 | 3807.06 | 4.96068 | 0.00740093 | 58.0973
COLUMN | Z/1403 | 25 deg | +0.000 | +5.050 | 10 | 75.5 | 6.6 | 5050.1 | 5050.09 | 6.5791 | 0.00981737 | 77.0663
2 x RAFTER | Z/1402 | 18 deg | +4.784 | +6.320 | 1 | 58.2 | 5.1 | 3892.4 | 3892.35 | 5.07173 | 0.00756673 | 59.3988
COLUMN | Z/1401 | 18 deg | +0.000 | +5.057 | 10 | 75.7 | 6.6 | 5056.8 | 5056.8 | 6.58784 | 0.00983041 | 77.1687
2 x RAFTER | Z/1400 | 15 deg | +4.758 | +6.093 | 1 | 57.6 | 5 | 3850.6 | 3850.62 | 5.0174 | 0.00748561 | 58.762
COLUMN | Z/1399 | 15 deg | +0.000 | +5.060 | 10 | 75.7 | 6.6 | 5059.9 | 5059.86 | 6.59182 | 0.00983636 | 77.2154
RAFTER | Z/1397 | 12 deg | +4.734 | +5.871 | 1 | 57.1 | 5 | 3820.7 | 3820.71 | 4.97845 | 0.00742746 | 58.3056
RAFTER | Z/1396 | 12 deg | +4.734 | +5.871 | 1 | 57.1 | 5 | 3820.7 | 3820.71 | 4.97845 | 0.00742746 | 58.3056
COLUMN | Z/1395 | 12 deg | +0.000 | +5.063 | 10 | 75.7 | 6.6 | 5063 | 5063.04 | 6.59596 | 0.00984254 | 77.264
COLUMN | Z/169 | 25 deg | +0.000 | +5.050 | 10 | 75.5 | 6.6 | 5050.1 | 5050.09 | 6.5791 | 0.00981737 | 77.0663
COLUMN | Z/166 | 18 deg | +0.000 | +5.057 | 10 | 75.7 | 6.6 | 5056.8 | 5056.8 | 6.58784 | 0.00983041 | 77.1687
2 x RAFTER | Z/167 | 18 deg | +4.784 | +6.320 | 1 | 58.2 | 5.1 | 3892.4 | 3892.35 | 5.07173 | 0.00756673 | 59.3988
COLUMN | Z/163 | 15 deg | +0.000 | +5.060 | 10 | 75.7 | 6.6 | 5059.9 | 5059.86 | 6.59182 | 0.00983636 | 77.2154
2 x RAFTER | Z/164 | 15 deg | +4.758 | +6.093 | 1 | 57.6 | 5 | 3850.6 | 3850.62 | 5.0174 | 0.00748561 | 58.762
COLUMN | Z/1458 | 12 deg | +0.000 | +5.063 | 10 | 75.7 | 6.6 | 5063 | 5063.04 | 6.59596 | 0.00984254 | 77.264
RAFTER | Z/1457 | 12 deg | +4.734 | +5.871 | 1 | 57.1 | 5 | 3820.7 | 3820.71 | 4.97845 | 0.00742746 | 58.3056
RAFTER | Z/1456 | 12 deg | +4.734 | +5.871 | 1 | 57.1 | 5 | 3820.7 | 3820.71 | 4.97845 | 0.00742746 | 58.3056

# IfcBeam: PLT1.6*60 (100)
In: Undefined
Description: PLT1.6*60; Material: STEEL/250
Default - ASSEMBLY_POS: Z/52
Tekla Common - Phase: 1; Class: 12
Tekla Quantity - Weight: 0.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 164.6 m2; Net surface area: 0 m2; Height: 60 mm; Width: 1.6 mm; Length: 297.9 mm
Pset_BeamCommon - LoadBearing: no; Reference: Z/52
BaseQuantities - Length: 297.881 mm; OuterSurfaceArea: 0.0371807 m2; NetVolume: 0.0000287808 m3; NetWeight: 0.225929 kg
Name | Bottom elevation | Top elevation
40 x FASCIA BRACKET | +4.906 | +5.063
20 x FASCIA BRACKET | +4.893 | +5.050
20 x FASCIA BRACKET | +4.900 | +5.057
20 x FASCIA BRACKET | +4.903 | +5.060

# IfcBeam: TH:75-95 (100)
In: Undefined
Description: TH:75-95; Material: STEEL/300PLUS
Tekla Common - Phase: 1; Class: 4
Tekla Quantity - Weight: 1.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 0 m2; Net surface area: 0.5 m2; Height: 75 mm; Width: 125 mm; Length: 1000 mm
Pset_BeamCommon - LoadBearing: no
BaseQuantities - Length: 1000 mm; OuterSurfaceArea: 4.5602e-07 m2; NetVolume: 0.000231901 m3; NetWeight: 1.82042 kg
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation
10 x TH | B/5 | +4.562 | +4.687
TH | B/5 | +5.306 | +5.394
TH | B/5 | +5.302 | +5.389
TH | B/5 | +5.296 | +5.384
2 x TH | B/5 | +5.292 | +5.380
2 x TH | B/5 | +5.288 | +5.375
TH | B/5 | +5.305 | +5.392
TH | B/5 | +5.300 | +5.388
TH | B/5 | +5.294 | +5.382
8 x TH | Z/562 | +4.549 | +4.674
2 x TH | Z/562 | +4.550 | +4.675
2 x TH | Z/562 | +5.732 | +5.834
2 x TH | Z/562 | +5.722 | +5.824
2 x TH | Z/562 | +5.713 | +5.815
2 x TH | Z/562 | +5.704 | +5.806
2 x TH | Z/562 | +5.694 | +5.796
10 x TH | Z/562 | +4.556 | +4.681
2 x TH | Z/562 | +5.541 | +5.637
2 x TH | Z/562 | +5.537 | +5.633
2 x TH | Z/562 | +5.526 | +5.622
2 x TH | Z/562 | +5.519 | +5.615
2 x TH | Z/562 | +5.511 | +5.607
10 x TH | Z/562 | +4.559 | +4.684
2 x TH | Z/562 | +5.453 | +5.547
2 x TH | Z/562 | +5.447 | +5.540
2 x TH | Z/562 | +5.441 | +5.534
2 x TH | Z/562 | +5.435 | +5.528
2 x TH | Z/562 | +5.428 | +5.522
10 x TH | Z/562 | +4.562 | +4.687
2 x TH | Z/562 | +5.365 | +5.455
2 x TH | Z/562 | +5.360 | +5.450
2 x TH | Z/562 | +5.355 | +5.445
2 x TH | Z/562 | +5.349 | +5.440
2 x TH | Z/562 | +5.344 | +5.435

# IfcColumn: C:150-24 (10)
In: Undefined
Description: C:150-24; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Phase: 1; Class: 10
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 111.2 m2; Net surface area: 3.1 m2; Height: 152 mm; Width: 64 mm
Pset_ColumnCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Finish | Top elevation | Weight (kg) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x COLUMN | Z/2356 | 12 deg | +5.063 | 28.2 | 5063.1 | 5063.14 | 3.1386 | 0.00373538 | 29.3228
COLUMN | Z/1020 | 25 deg | +5.050 | 28.1 | 5050.1 | 5050.09 | 3.13051 | 0.00372575 | 29.2472
COLUMN | Z/1014 | 18 deg | +5.057 | 28.2 | 5056.8 | 5056.79 | 3.13466 | 0.0037307 | 29.286
COLUMN | Z/207 | 15 deg | +5.060 | 28.2 | 5059.9 | 5059.86 | 3.13656 | 0.00373296 | 29.3038
COLUMN | Z/191 | 12 deg | +5.063 | 28.2 | 5063.1 | 5063.14 | 3.1386 | 0.00373538 | 29.3228
COLUMN | Z/92 | 25 deg | +5.050 | 28.1 | 5050.1 | 5050.09 | 3.13051 | 0.00372575 | 29.2472
COLUMN | Z/89 | 18 deg | +5.057 | 28.2 | 5056.8 | 5056.79 | 3.13466 | 0.0037307 | 29.286
COLUMN | Z/86 | 15 deg | +5.060 | 28.2 | 5059.9 | 5059.86 | 3.13656 | 0.00373296 | 29.3038
COLUMN | Z/1178 | 12 deg | +5.063 | 28.2 | 5063.1 | 5063.14 | 3.1386 | 0.00373538 | 29.3228

# IfcColumn: C:200-24 (10)
In: Undefined
Description: C:200-24; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Phase: 1; Class: 10
Tekla Quantity - Weight: 35.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 110 m2; Net surface area: 3.9 m2; Height: 203 mm; Width: 76 mm
Pset_ColumnCommon - LoadBearing: no
Name | Finish | Top elevation | ASSEMBLY_POS = Reference | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x COLUMN | 12 deg | +5.063 | Z/2359 | 5063.3 | 5063.16 | 3.9491 | 0.00470752 | 36.9541
COLUMN | 25 deg | +5.050 | Z/1198 | 5050.1 | 5050.09 | 3.93891 | 0.00469537 | 36.8587
COLUMN | 18 deg | +5.057 | Z/1196 | 5056.8 | 5056.8 | 3.94414 | 0.00470161 | 36.9076
COLUMN | 15 deg | +5.060 | Z/1194 | 5059.9 | 5059.86 | 3.94653 | 0.00470446 | 36.93
COLUMN | 12 deg | +5.063 | Z/1193 | 5063.3 | 5063.16 | 3.9491 | 0.00470752 | 36.9541
COLUMN | 25 deg | +5.050 | Z/111 | 5050.1 | 5050.09 | 3.93891 | 0.00469537 | 36.8587
COLUMN | 18 deg | +5.057 | Z/109 | 5056.8 | 5056.8 | 3.94414 | 0.00470161 | 36.9076
COLUMN | 15 deg | +5.060 | Z/106 | 5059.9 | 5059.86 | 3.94653 | 0.00470446 | 36.93
COLUMN | 12 deg | +5.063 | Z/1243 | 5063.3 | 5063.16 | 3.9491 | 0.00470752 | 36.9541

# IfcColumn: C:250-24 (10)
In: Undefined
Description: C:250-24; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Phase: 1; Class: 10
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 109.7 m2; Net surface area: 4.5 m2; Height: 254 mm; Width: 76 mm
Pset_ColumnCommon - LoadBearing: no
Name | Finish | Top elevation | ASSEMBLY_POS = Reference | Weight (kg) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x COLUMN | 12 deg | +5.063 | Z/2361 | 40.6 | 5063.3 | 5063.25 | 4.45573 | 0.0053152 | 41.7243
COLUMN | 25 deg | +5.050 | Z/1265 | 40.5 | 5050.1 | 5050.08 | 4.44415 | 0.00530137 | 41.6158
COLUMN | 18 deg | +5.057 | Z/1263 | 40.6 | 5056.8 | 5056.79 | 4.45005 | 0.00530842 | 41.6711
COLUMN | 15 deg | +5.060 | Z/1261 | 40.6 | 5059.9 | 5059.86 | 4.45275 | 0.00531164 | 41.6964
COLUMN | 12 deg | +5.063 | Z/1260 | 40.6 | 5063.3 | 5063.25 | 4.45573 | 0.0053152 | 41.7243
COLUMN | 25 deg | +5.050 | Z/130 | 40.5 | 5050.1 | 5050.08 | 4.44415 | 0.00530137 | 41.6158
COLUMN | 18 deg | +5.057 | Z/127 | 40.6 | 5056.8 | 5056.79 | 4.45005 | 0.00530842 | 41.6711
COLUMN | 15 deg | +5.060 | Z/124 | 40.6 | 5059.9 | 5059.86 | 4.45275 | 0.00531164 | 41.6964
COLUMN | 12 deg | +5.063 | Z/1311 | 40.6 | 5063.3 | 5063.25 | 4.45573 | 0.0053152 | 41.7243

# IfcColumn: C:300-30 (10)
In: Undefined
Description: C:300-30; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Phase: 1; Class: 10
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.4 m2; Net surface area: 5.5 m2; Height: 300 mm; Width: 96 mm
Pset_ColumnCommon - LoadBearing: no
Name | Finish | Top elevation | ASSEMBLY_POS = Reference | Weight (kg) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x COLUMN | 12 deg | +5.063 | Z/2363 | 63.3 | 5062.8 | 5062.81 | 5.53185 | 0.00824732 | 64.7414
COLUMN | 25 deg | +5.050 | Z/1332 | 63.2 | 5050.1 | 5050.09 | 5.51796 | 0.0082266 | 64.5788
COLUMN | 18 deg | +5.057 | Z/1330 | 63.2 | 5056.8 | 5056.79 | 5.52527 | 0.00823751 | 64.6645
COLUMN | 15 deg | +5.060 | Z/1328 | 63.3 | 5059.9 | 5059.86 | 5.52863 | 0.00824251 | 64.7037
COLUMN | 12 deg | +5.063 | Z/1327 | 63.3 | 5062.8 | 5062.81 | 5.53185 | 0.00824732 | 64.7414
COLUMN | 25 deg | +5.050 | Z/149 | 63.2 | 5050.1 | 5050.09 | 5.51796 | 0.0082266 | 64.5788
COLUMN | 18 deg | +5.057 | Z/146 | 63.2 | 5056.8 | 5056.79 | 5.52527 | 0.00823751 | 64.6645
COLUMN | 15 deg | +5.060 | Z/143 | 63.3 | 5059.9 | 5059.86 | 5.52863 | 0.00824251 | 64.7037
COLUMN | 12 deg | +5.063 | Z/1382 | 63.3 | 5062.8 | 5062.81 | 5.53185 | 0.00824732 | 64.7414

# IfcColumn: C:350-30 (10)
In: Undefined
Description: C:350-30; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Phase: 1; Class: 10
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.1 m2; Net surface area: 6.6 m2; Height: 350 mm; Width: 125 mm
Pset_ColumnCommon - LoadBearing: no
Name | Finish | Top elevation | ASSEMBLY_POS = Reference | Weight (kg) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x COLUMN | 12 deg | +5.063 | Z/2365 | 75.7 | 5063 | 5063.04 | 6.59596 | 0.00984254 | 77.264
COLUMN | 25 deg | +5.050 | Z/1403 | 75.5 | 5050.1 | 5050.09 | 6.5791 | 0.00981737 | 77.0663
COLUMN | 18 deg | +5.057 | Z/1401 | 75.7 | 5056.8 | 5056.8 | 6.58784 | 0.00983041 | 77.1687
COLUMN | 15 deg | +5.060 | Z/1399 | 75.7 | 5059.9 | 5059.86 | 6.59182 | 0.00983636 | 77.2154
COLUMN | 12 deg | +5.063 | Z/1398 | 75.7 | 5063 | 5063.04 | 6.59596 | 0.00984254 | 77.264
COLUMN | 25 deg | +5.050 | Z/169 | 75.5 | 5050.1 | 5050.09 | 6.5791 | 0.00981737 | 77.0663
COLUMN | 18 deg | +5.057 | Z/166 | 75.7 | 5056.8 | 5056.8 | 6.58784 | 0.00983041 | 77.1687
COLUMN | 15 deg | +5.060 | Z/163 | 75.7 | 5059.9 | 5059.86 | 6.59182 | 0.00983636 | 77.2154
COLUMN | 12 deg | +5.063 | Z/1455 | 75.7 | 5063 | 5063.04 | 6.59596 | 0.00984254 | 77.264

# IfcElementAssembly (830)
In: Undefined
PredefinedType: RIGID_FRAME
Name | ASSEMBLY_POSITION_CODE = Assembly/Cast unit position code | ASSEMBLY_POS = Assembly/Cast unit Mark | Assembly/Cast unit weight (kg) | Assembly/Cast unit bottom elevation | Assembly/Cast unit top elevation | Width (mm)
PLATE | C150SD/3 | Z/2460 | 2.5 | +4.772 | +5.067 | 72.5
2 x COLUMN | C150SD/3 | Z/2356 | 28.2 | +0.000 | +5.063 | 64
PLATE | C150SD/3 | Z/2453 | 2.5 | +4.772 | +5.067 | 72.5
PLATE | C150SD/1 | Z/2459 | 2.5 | +4.772 | +5.067 | 72.5
PLATE | C150SD/1 | Z/2449 | 2.5 | +4.772 | +5.067 | 72.5
PLATE | C200SD/3 | Z/2527 | 3 | +4.771 | +5.075 | 80
PLATE | C200SD/3 | Z/2525 | 3 | +4.771 | +5.075 | 80
PLATE | C200SD/1 | Z/2526 | 3 | +4.771 | +5.075 | 80
PLATE | C200SD/1 | Z/2524 | 3 | +4.771 | +5.075 | 80
PLATE | C250SD/3 | Z/2540 | 5.2 | +4.686 | +5.099 | 84.5
2 x COLUMN | C250SD/3 | Z/2361 | 40.6 | +0.000 | +5.063 | 76
PLATE | C250SD/3 | Z/2538 | 5.2 | +4.686 | +5.099 | 84.5
PLATE | C250SD/1 | Z/2539 | 5.2 | +4.686 | +5.099 | 84.5
PLATE | C250SD/1 | Z/2537 | 5.2 | +4.686 | +5.099 | 84.5
PLATE | C300SD/2-3 | Z/2550 | 8.7 | +4.572 | +5.128 | 104.5
PLATE | C300SD/2-3 | Z/2548 | 8.7 | +4.572 | +5.128 | 104.5
2 x COLUMN | C300SD/3 | Z/2363 | 63.3 | +0.000 | +5.063 | 96
PLATE | C300SD/1-2 | Z/2549 | 8.7 | +4.572 | +5.128 | 104.5
PLATE | C300SD/1-2 | Z/2547 | 8.7 | +4.572 | +5.128 | 104.5
PLATE | C350SD/2-3 | Z/2565 | 9.9 | +4.572 | +5.136 | 133.5
PLATE | C350SD/2-3 | Z/2563 | 9.9 | +4.572 | +5.136 | 133.5
PLATE | C350SD/1-2 | Z/2564 | 9.9 | +4.572 | +5.136 | 133.5
PLATE | C350SD/1-2 | Z/2562 | 9.9 | +4.572 | +5.136 | 133.5
RAFTER | C150SD/2-3 | Z/2357 | 22 | +4.879 | +5.713 | 64
RAFTER | C150SD/1-2 | Z/2357 | 22 | +4.879 | +5.713 | 64
2 x COLUMN | C150SD/1 | Z/2356 | 28.2 | +0.000 | +5.063 | 64
4 x FASCIA BRACKET | C150SD/3 | Z/52 | 0.2 | +4.906 | +5.063 | 157.2
4 x FASCIA BRACKET | C150SD/1 | Z/52 | 0.2 | +4.906 | +5.063 | 157.2
BHR-12-150 | C150SD/2-3 | Z/2448 | 6.2 | +4.093 | +5.198 | 64
BHL-12-150 | C150SD/1-2 | Z/2434 | 6.2 | +4.093 | +5.198 | 64
BA-12-150 | C150SD/1-3 | Z/2435 | 12.8 | +5.322 | +5.474 | 64
2 x STIFFINER SLEEVE | C150SD/2-3 | PL/147 | 2.3 | +4.979 | +5.192 | 54.2
2 x STIFFINER SLEEVE | C150SD/3 | PL/1638 | 2.3 | +4.073 | +4.473 | 54.2
2 x STIFFINER SLEEVE | C150SD/1-2 | PL/147 | 2.3 | +4.979 | +5.192 | 54.2
2 x STIFFINER SLEEVE | C150SD/1 | PL/147 | 2.3 | +4.073 | +4.473 | 54.2
BHR-12-150 | C150SD/2-3 | Z/2471 | 6.2 | +4.093 | +5.198 | 64
BHL-12-150 | C150SD/1-2 | Z/2464 | 6.2 | +4.093 | +5.198 | 64
BA-12-150 | C150SD/1-3 | Z/2470 | 12.8 | +5.322 | +5.474 | 64
PLATE | C150SD/2 | PL/1645 | 2.2 | +5.524 | +5.719 | 67
2 x RAFTER | C200SD/2-3 | Z/2360 | 27.7 | +4.837 | +5.716 | 76
2 x COLUMN | C200SD/3 | Z/2359 | 35.9 | +0.000 | +5.063 | 76
2 x RAFTER | C200SD/1-2 | Z/2360 | 27.7 | +4.837 | +5.716 | 76
2 x COLUMN | C200SD/1 | Z/2359 | 35.9 | +0.000 | +5.063 | 76
4 x FASCIA BRACKET | C200SD/3 | Z/52 | 0.2 | +4.906 | +5.063 | 157.2
4 x FASCIA BRACKET | C200SD/1 | Z/52 | 0.2 | +4.906 | +5.063 | 157.2
BHR-12-200 | C200SD/2-3 | Z/2523 | 6.5 | +4.034 | +5.186 | 64
BHL-12-200 | C200SD/1-2 | Z/2521 | 6.5 | +4.034 | +5.186 | 64
BA-12-200 | C200SD/1-3 | Z/2522 | 14.4 | +5.267 | +5.419 | 64
2 x STIFFINER SLEEVE | C200SD/2-3 | PL/148 | 3 | +4.940 | +5.203 | 66.2
2 x STIFFINER SLEEVE | C200SD/3 | PL/148 | 3 | +4.023 | +4.423 | 66.2
2 x STIFFINER SLEEVE | C200SD/1-2 | PL/148 | 3 | +4.940 | +5.203 | 66.2
2 x STIFFINER SLEEVE | C200SD/1 | PL/148 | 3 | +4.023 | +4.423 | 66.2
BHR-12-200 | C200SD/2-3 | Z/2530 | 6.5 | +4.034 | +5.186 | 64
BHL-12-200 | C200SD/1-2 | Z/2528 | 6.5 | +4.034 | +5.186 | 64
BA-12-200 | C200SD/1-3 | Z/2529 | 14.4 | +5.267 | +5.419 | 64
PLATE | C200SD/2 | PL/1651 | 3.4 | +5.469 | +5.723 | 79
2 x RAFTER | C250SD/2-3 | Z/2362 | 31.1 | +4.796 | +5.719 | 76
2 x RAFTER | C250SD/1-2 | Z/2362 | 31.1 | +4.796 | +5.719 | 76
2 x COLUMN | C250SD/1 | Z/2361 | 40.6 | +0.000 | +5.063 | 76
4 x FASCIA BRACKET | C250SD/3 | Z/52 | 0.2 | +4.906 | +5.063 | 157.2
4 x FASCIA BRACKET | C250SD/1 | Z/52 | 0.2 | +4.906 | +5.063 | 157.2
BHR-12-250 | C250SD/2-3 | Z/2536 | 6.9 | +3.964 | +5.174 | 64
BHL-12-250 | C250SD/1-2 | Z/2534 | 6.9 | +3.964 | +5.174 | 64
BA-12-250 | C250SD/1-3 | Z/2535 | 15.7 | +5.220 | +5.372 | 64
2 x STIFFINER SLEEVE | C250SD/2-3 | PL/149 | 3.4 | +4.903 | +5.216 | 66.2
2 x STIFFINER SLEEVE | C250SD/3 | PL/1648 | 3.4 | +3.983 | +4.383 | 66.2
2 x STIFFINER SLEEVE | C250SD/1-2 | PL/149 | 3.4 | +4.903 | +5.216 | 66.2
2 x STIFFINER SLEEVE | C250SD/1 | PL/149 | 3.4 | +3.983 | +4.383 | 66.2
BHR-12-250 | C250SD/2-3 | Z/2543 | 6.9 | +3.964 | +5.174 | 64
BHL-12-250 | C250SD/1-2 | Z/2541 | 6.9 | +3.964 | +5.174 | 64
BA-12-250 | C250SD/1-3 | Z/2542 | 15.7 | +5.220 | +5.372 | 64
2 x PLATE | C250SD/2 | PL/1657 | 4 | +5.422 | +5.727 | 79
2 x RAFTER | C300SD/2-3 | Z/2364 | 48 | +4.759 | +5.722 | 96
2 x RAFTER | C300SD/1-2 | Z/2364 | 48 | +4.759 | +5.722 | 96
2 x COLUMN | C300SD/1 | Z/2363 | 63.3 | +0.000 | +5.063 | 96
4 x FASCIA BRACKET | C300SD/3 | Z/52 | 0.2 | +4.906 | +5.063 | 157.2
4 x FASCIA BRACKET | C300SD/1 | Z/52 | 0.2 | +4.906 | +5.063 | 157.2
BHR-12-300 | C300SD/2-3 | Z/2546 | 7.3 | +3.892 | +5.164 | 64
BHL-12-300 | C300SD/1-2 | Z/2544 | 7.3 | +3.892 | +5.164 | 64
BA-12-300 | C300SD/1-3 | Z/2545 | 18.6 | +5.143 | +5.295 | 64
2 x STIFFINER SLEEVE | C300SD/2-3 | PL/150 | 4.2 | +4.873 | +5.230 | 85
2 x STIFFINER SLEEVE | C300SD/3 | PL/1655 | 4.2 | +3.888 | +4.288 | 85
2 x STIFFINER SLEEVE | C300SD/1-2 | PL/150 | 4.2 | +4.873 | +5.230 | 85
2 x STIFFINER SLEEVE | C300SD/1 | PL/150 | 4.2 | +3.888 | +4.288 | 85
BHR-12-300 | C300SD/2-3 | Z/2558 | 7.3 | +3.892 | +5.164 | 64
BHL-12-300 | C300SD/1-2 | Z/2551 | 7.3 | +3.892 | +5.164 | 64
BA-12-300 | C300SD/1-3 | Z/2552 | 18.6 | +5.143 | +5.295 | 64
PLATE | C300SD/2 | PL/1662 | 9.1 | +5.345 | +5.732 | 99
2 x RAFTER | C350SD/2-3 | Z/2366 | 56.9 | +4.719 | +5.725 | 125
2 x COLUMN | C350SD/3 | Z/2365 | 75.7 | +0.000 | +5.063 | 125
RAFTER | C350SD/1-2 | Z/2366 | 56.9 | +4.719 | +5.725 | 125
2 x COLUMN | C350SD/1 | Z/2365 | 75.7 | +0.000 | +5.063 | 125
4 x FASCIA BRACKET | C350SD/3 | Z/52 | 0.2 | +4.906 | +5.063 | 157.2
4 x FASCIA BRACKET | C350SD/1 | Z/52 | 0.2 | +4.906 | +5.063 | 157.2
2 x BHR-12-350 | C350SD/2-3 | Z/2561 | 7.8 | +3.816 | +5.174 | 64
BHL-12-350 | C350SD/1-2 | Z/2559 | 7.8 | +3.816 | +5.174 | 64
BA-12-350 | C350SD/1-3 | Z/2560 | 19.9 | +5.097 | +5.249 | 64
BA-12-350 | C350SD/1-3 | Z/2567 | 19.9 | +5.097 | +5.249 | 64
PLATE | C350SD/2 | PL/1673 | 10.8 | +5.299 | +5.736 | 128
2 x STIFFINER SLEEVE | C350SD/2-3 | PL/151 | 5.3 | +4.838 | +5.244 | 114
2 x STIFFINER SLEEVE | C350SD/3 | PL/151 | 5.3 | +3.808 | +4.208 | 114
2 x STIFFINER SLEEVE | C350SD/1-2 | PL/151 | 5.3 | +4.838 | +5.244 | 114
2 x STIFFINER SLEEVE | C350SD/1 | PL/151 | 5.3 | +3.808 | +4.208 | 114
BHL-12-350 | C350SD/1-2 | Z/2566 | 7.8 | +3.816 | +5.174 | 64
PLATE | C350SD/2 | PL/1668 | 10.8 | +5.299 | +5.736 | 128
RAFTER | C350SD/1-2 | Z/2367 | 56.9 | +4.719 | +5.725 | 125
RAFTER | C150SD/2-3 | Z/2358 | 22 | +4.879 | +5.713 | 64
RAFTER | C150SD/1-2 | Z/2358 | 22 | +4.879 | +5.713 | 64
FASCIA | C350SD>/3 | F/10 | 3.4 | +4.909 | +5.061 | 64
TH | C350SD>/3 | B/5 | 1.8 | +4.562 | +4.687 | 125
FASCIA | C300SD-C350SD/3 | F/10 | 3.4 | +4.908 | +5.060 | 64
TH | C300SD-C350SD/3 | B/5 | 1.8 | +4.562 | +4.687 | 125
FASCIA | C250SD-C300SD/3 | F/10 | 3.4 | +4.908 | +5.060 | 64
TH | C250SD-C300SD/3 | B/5 | 1.8 | +4.562 | +4.687 | 125
FASCIA | C200SD-C250SD/3 | F/10 | 3.4 | +4.909 | +5.061 | 64
TH | C200SD-C250SD/3 | B/5 | 1.8 | +4.562 | +4.687 | 125
TH | C350SD>/2-3 | B/5 | 1.8 | +5.306 | +5.394 | 125
TH | C300SD-C350SD/2-3 | B/5 | 1.8 | +5.302 | +5.389 | 125
TH | C250SD-C300SD/2-3 | B/5 | 1.8 | +5.296 | +5.384 | 125
TH | C200SD-C250SD/2-3 | B/5 | 1.8 | +5.292 | +5.380 | 125
TH | C150SD-C200SD/2-3 | B/5 | 1.8 | +5.288 | +5.375 | 125
FASCIA | C150SD-C200SD/3 | F/10 | 3.4 | +4.909 | +5.061 | 64
TH | C150SD-C200SD/3 | B/5 | 1.8 | +4.562 | +4.687 | 125
FASCIA | C350SD>/1 | F/10 | 3.4 | +4.909 | +5.061 | 64
TH | C350SD>/1 | B/5 | 1.8 | +4.562 | +4.687 | 125
FASCIA | C300SD-C350SD/1 | F/10 | 3.4 | +4.908 | +5.060 | 64
TH | C300SD-C350SD/1 | B/5 | 1.8 | +4.562 | +4.687 | 125
FASCIA | C250SD-C300SD/1 | F/10 | 3.4 | +4.908 | +5.060 | 64
TH | C250SD-C300SD/1 | B/5 | 1.8 | +4.562 | +4.687 | 125
FASCIA | C200SD-C250SD/1 | F/10 | 3.4 | +4.909 | +5.061 | 64
TH | C200SD-C250SD/1 | B/5 | 1.8 | +4.562 | +4.687 | 125
TH | C350SD>/1-2 | B/5 | 1.8 | +5.305 | +5.392 | 125
TH | C300SD-C350SD/1-2 | B/5 | 1.8 | +5.300 | +5.388 | 125
TH | C250SD-C300SD/1-2 | B/5 | 1.8 | +5.294 | +5.382 | 125
TH | C200SD-C250SD/1-2 | B/5 | 1.8 | +5.292 | +5.380 | 125
TH | C150SD-C200SD/1-2 | B/5 | 1.8 | +5.288 | +5.375 | 125
FASCIA | C150SD-C200SD/1 | F/10 | 3.4 | +4.909 | +5.061 | 64
TH | C150SD-C200SD/1 | B/5 | 1.8 | +4.562 | +4.687 | 125
PLATE | C300SD/2 | PL/1667 | 9.1 | +5.345 | +5.732 | 99
PLATE | C200SD/2 | PL/1656 | 3.4 | +5.469 | +5.723 | 79
PLATE | C150SD/2 | PL/1650 | 2.2 | +5.524 | +5.719 | 67
2 x FASCIA BRACKET | C350SD/3 | Z/52 | 0.2 | +4.893 | +5.050 | 157.2
2 x FASCIA BRACKET | C350SD/1 | Z/52 | 0.2 | +4.893 | +5.050 | 157.2
2 x FASCIA BRACKET | C350SD/3 | Z/52 | 0.2 | +4.900 | +5.057 | 157.2
2 x FASCIA BRACKET | C350SD/1 | Z/52 | 0.2 | +4.900 | +5.057 | 157.2
2 x FASCIA BRACKET | C350SD/3 | Z/52 | 0.2 | +4.903 | +5.060 | 157.2
2 x FASCIA BRACKET | C350SD/1 | Z/52 | 0.2 | +4.903 | +5.060 | 157.2
COLUMN | C350SD/3 | Z/1398 | 75.7 | +0.000 | +5.063 | 125
RAFTER | C350SD/2-3 | Z/1397 | 57.1 | +4.734 | +5.871 | 125
RAFTER | C350SD/1-2 | Z/1396 | 57.1 | +4.734 | +5.871 | 125
COLUMN | C350SD/1 | Z/1395 | 75.7 | +0.000 | +5.063 | 125
BHL-25-350 | C350SD/2-3 | Z/1426 | 10.6 | +3.886 | +5.691 | 64
BHL-18-350 | C350SD/2-3 | Z/1423 | 8.4 | +3.886 | +5.337 | 64
BHL-15-350 | C350SD/2-3 | Z/1420 | 7.8 | +3.886 | +5.266 | 64
BHL-12-350 | C350SD/2-3 | Z/1417 | 7.8 | +3.816 | +5.196 | 64
BHL-25-350 | C350SD/1-2 | Z/1424 | 10.6 | +3.886 | +5.691 | 64
BA-25-350 | C350SD/1-3 | Z/1425 | 16.3 | +5.856 | +6.008 | 64
PLATE | C350SD/2-3 | Z/1439 | 11.8 | +4.577 | +5.345 | 128
COLUMN | C350SD/3 | Z/1403 | 75.5 | +0.000 | +5.050 | 125
RAFTER | C350SD/2-3 | Z/1404 | 60.4 | +4.851 | +6.876 | 125
PLATE | C350SD/1-2 | Z/1438 | 11.8 | +4.577 | +5.345 | 128
PLATE | C350SD/1-3 | Z/1430 | 12.4 | +6.373 | +6.947 | 128
RAFTER | C350SD/1-2 | Z/1404 | 60.4 | +4.851 | +6.876 | 125
COLUMN | C350SD/1 | Z/1403 | 75.5 | +0.000 | +5.050 | 125
BHL-18-350 | C350SD/1-2 | Z/1421 | 8.4 | +3.886 | +5.337 | 64
BA-18-350 | C350SD/1-3 | Z/1422 | 16.3 | +5.531 | +5.683 | 64
PLATE | C350SD/2-3 | Z/1437 | 10.8 | +4.577 | +5.247 | 128
COLUMN | C350SD/3 | Z/1401 | 75.7 | +0.000 | +5.057 | 125
RAFTER | C350SD/2-3 | Z/1402 | 58.2 | +4.784 | +6.320 | 125
PLATE | C350SD/1-2 | Z/1436 | 10.8 | +4.577 | +5.247 | 128
PLATE | C350SD/1-3 | Z/1429 | 11.8 | +5.849 | +6.357 | 128
RAFTER | C350SD/1-2 | Z/1402 | 58.2 | +4.784 | +6.320 | 125
COLUMN | C350SD/1 | Z/1401 | 75.7 | +0.000 | +5.057 | 125
BHL-15-350 | C350SD/1-2 | Z/1418 | 7.8 | +3.886 | +5.266 | 64
BA-15-350 | C350SD/1-3 | Z/1419 | 16.3 | +5.391 | +5.543 | 64
PLATE | C350SD/2-3 | Z/1435 | 10.5 | +4.577 | +5.205 | 128
COLUMN | C350SD/3 | Z/1399 | 75.7 | +0.000 | +5.060 | 125
RAFTER | C350SD/2-3 | Z/1400 | 57.6 | +4.758 | +6.093 | 125
PLATE | C350SD/1-2 | Z/1434 | 10.5 | +4.577 | +5.205 | 128
PLATE | C350SD/1-3 | Z/1428 | 11.4 | +5.638 | +6.119 | 128
RAFTER | C350SD/1-2 | Z/1400 | 57.6 | +4.758 | +6.093 | 125
COLUMN | C350SD/1 | Z/1399 | 75.7 | +0.000 | +5.060 | 125
2 x STIFFINER SLEEVE | C350SD/2-3 | Z/643 | 5.3 | +4.875 | +5.293 | 114
2 x STIFFINER SLEEVE | C350SD/3 | Z/643 | 5.3 | +3.808 | +4.208 | 114
2 x STIFFINER SLEEVE | C350SD/1-2 | Z/643 | 5.3 | +4.875 | +5.293 | 114
2 x STIFFINER SLEEVE | C350SD/1 | Z/643 | 5.3 | +3.808 | +4.208 | 114
BHL-12-350 | C350SD/1-2 | Z/1416 | 7.8 | +3.816 | +5.196 | 64
2 x BA-12-350 | C350SD/1-3 | Z/1098 | 16.3 | +5.231 | +5.383 | 64
PLATE | C350SD/2-3 | Z/1432 | 10.1 | +4.577 | +5.164 | 128
PLATE | C350SD/1-2 | Z/1431 | 10.1 | +4.577 | +5.164 | 128
2 x PLATE | C350SD/2 | Z/1427 | 11.1 | +5.433 | +5.887 | 128
2 x FASCIA BRACKET | C300SD/3 | Z/52 | 0.2 | +4.893 | +5.050 | 157.2
2 x FASCIA BRACKET | C300SD/1 | Z/52 | 0.2 | +4.893 | +5.050 | 157.2
2 x FASCIA BRACKET | C300SD/3 | Z/52 | 0.2 | +4.900 | +5.057 | 157.2
2 x FASCIA BRACKET | C300SD/1 | Z/52 | 0.2 | +4.900 | +5.057 | 157.2
2 x FASCIA BRACKET | C300SD/3 | Z/52 | 0.2 | +4.903 | +5.060 | 157.2
2 x FASCIA BRACKET | C300SD/1 | Z/52 | 0.2 | +4.903 | +5.060 | 157.2
COLUMN | C300SD/3 | Z/1327 | 63.3 | +0.000 | +5.063 | 96
RAFTER | C300SD/2-3 | Z/1326 | 48.2 | +4.772 | +5.868 | 96
RAFTER | C300SD/1-2 | Z/1325 | 48.2 | +4.772 | +5.868 | 96
COLUMN | C300SD/1 | Z/1324 | 63.3 | +0.000 | +5.063 | 96
BHL-25-300 | C300SD/2-3 | Z/1353 | 9.7 | +3.999 | +5.662 | 64
BHL-18-300 | C300SD/2-3 | Z/1350 | 7.8 | +3.969 | +5.349 | 64
BHL-15-300 | C300SD/2-3 | Z/1347 | 7.5 | +3.962 | +5.272 | 64
BHL-12-300 | C300SD/2-3 | Z/630 | 7.5 | +3.892 | +5.202 | 64
BHL-25-300 | C300SD/1-2 | Z/1351 | 9.7 | +3.999 | +5.662 | 64
BA-25-300 | C300SD/1-3 | Z/1352 | 15.4 | +5.917 | +6.069 | 64
PLATE | C300SD/2-3 | Z/1368 | 10.1 | +4.578 | +5.322 | 99
COLUMN | C300SD/3 | Z/1332 | 63.2 | +0.000 | +5.050 | 96
RAFTER | C300SD/2-3 | Z/1333 | 51.2 | +4.873 | +6.874 | 96
PLATE | C300SD/1-2 | Z/1367 | 10.1 | +4.578 | +5.322 | 99
PLATE | C300SD/1-3 | Z/1357 | 10.5 | +6.416 | +6.935 | 99
RAFTER | C300SD/1-2 | Z/1333 | 51.2 | +4.873 | +6.874 | 96
COLUMN | C300SD/1 | Z/1332 | 63.2 | +0.000 | +5.050 | 96
BHL-18-300 | C300SD/1-2 | Z/1348 | 7.8 | +3.969 | +5.349 | 64
BA-18-300 | C300SD/1-3 | Z/1349 | 15.4 | +5.577 | +5.729 | 64
PLATE | C300SD/2-3 | Z/1366 | 9.4 | +4.577 | +5.231 | 99
COLUMN | C300SD/3 | Z/1330 | 63.2 | +0.000 | +5.057 | 96
RAFTER | C300SD/2-3 | Z/1331 | 49.2 | +4.815 | +6.317 | 96
PLATE | C300SD/1-2 | Z/1365 | 9.4 | +4.577 | +5.231 | 99
PLATE | C300SD/2 | Z/1356 | 9.9 | +5.893 | +6.348 | 99
RAFTER | C300SD/1-2 | Z/1331 | 49.2 | +4.815 | +6.317 | 96
COLUMN | C300SD/1 | Z/1330 | 63.2 | +0.000 | +5.057 | 96
BHL-15-300 | C300SD/1-2 | Z/1345 | 7.5 | +3.962 | +5.272 | 64
BA-15-300 | C300SD/1-3 | Z/1346 | 15.4 | +5.427 | +5.579 | 64
PLATE | C300SD/2-3 | Z/1364 | 9.1 | +4.577 | +5.192 | 99
COLUMN | C300SD/3 | Z/1328 | 63.3 | +0.000 | +5.060 | 96
RAFTER | C300SD/2-3 | Z/1329 | 48.6 | +4.793 | +6.090 | 96
PLATE | C300SD/1-2 | Z/1363 | 9.1 | +4.577 | +5.192 | 99
PLATE | C300SD/2 | Z/1355 | 9.7 | +5.683 | +6.112 | 99
RAFTER | C300SD/1-2 | Z/1329 | 48.6 | +4.793 | +6.090 | 96
COLUMN | C300SD/1 | Z/1328 | 63.3 | +0.000 | +5.060 | 96
2 x STIFFINER SLEEVE | C300SD/2-3 | Z/608 | 4.2 | +4.907 | +5.276 | 85
2 x STIFFINER SLEEVE | C300SD/3 | Z/608 | 4.2 | +3.888 | +4.288 | 85
2 x STIFFINER SLEEVE | C300SD/1-2 | Z/608 | 4.2 | +4.907 | +5.276 | 85
2 x STIFFINER SLEEVE | C300SD/1 | Z/608 | 4.2 | +3.888 | +4.288 | 85
BHL-12-300 | C300SD/1-2 | Z/620 | 7.5 | +3.892 | +5.202 | 64
BA-12-300 | C300SD/1-3 | Z/621 | 15.4 | +5.277 | +5.429 | 64
PLATE | C300SD/2-3 | Z/1359 | 8.7 | +4.577 | +5.153 | 99
PLATE | C300SD/1-2 | Z/1358 | 8.7 | +4.577 | +5.153 | 99
2 x PLATE | C300SD/2 | Z/1354 | 9.4 | +5.479 | +5.882 | 99
2 x FASCIA BRACKET | C250SD/3 | Z/52 | 0.2 | +4.893 | +5.050 | 157.2
2 x FASCIA BRACKET | C250SD/1 | Z/52 | 0.2 | +4.893 | +5.050 | 157.2
2 x FASCIA BRACKET | C250SD/3 | Z/52 | 0.2 | +4.900 | +5.057 | 157.2
2 x FASCIA BRACKET | C250SD/1 | Z/52 | 0.2 | +4.900 | +5.057 | 157.2
2 x FASCIA BRACKET | C250SD/3 | Z/52 | 0.2 | +4.903 | +5.060 | 157.2
2 x FASCIA BRACKET | C250SD/1 | Z/52 | 0.2 | +4.903 | +5.060 | 157.2
COLUMN | C250SD/3 | Z/1260 | 40.6 | +0.000 | +5.063 | 76
RAFTER | C250SD/2-3 | Z/1259 | 31.2 | +4.807 | +5.865 | 76
RAFTER | C250SD/1-2 | Z/1258 | 31.2 | +4.807 | +5.865 | 76
COLUMN | C250SD/1 | Z/1257 | 40.6 | +0.000 | +5.063 | 76
BHL-25-250 | C250SD/2-3 | Z/1286 | 8.4 | +4.151 | +5.602 | 64
BHL-18-250 | C250SD/2-3 | Z/1283 | 6.9 | +4.111 | +5.350 | 64
BHL-15-250 | C250SD/2-3 | Z/1280 | 6.9 | +4.044 | +5.283 | 64
BHL-12-250 | C250SD/2-3 | Z/592 | 6.9 | +3.964 | +5.203 | 64
BHL-25-250 | C250SD/1-2 | Z/1284 | 8.4 | +4.151 | +5.602 | 64
BA-25-250 | C250SD/1-3 | Z/1285 | 15.4 | +5.924 | +6.076 | 64
PLATE | C250SD/2-3 | Z/1299 | 6.2 | +4.692 | +5.252 | 79
COLUMN | C250SD/3 | Z/1265 | 40.5 | +0.000 | +5.050 | 76
RAFTER | C250SD/2-3 | Z/1266 | 33.2 | +4.892 | +6.872 | 76
PLATE | C250SD/1-2 | Z/1298 | 6.2 | +4.692 | +5.252 | 79
PLATE | C250SD/2 | Z/1292 | 4.7 | +6.540 | +6.924 | 79
RAFTER | C250SD/1-2 | Z/1266 | 33.2 | +4.892 | +6.872 | 76
COLUMN | C250SD/1 | Z/1265 | 40.5 | +0.000 | +5.050 | 76
BHL-18-250 | C250SD/1-2 | Z/1281 | 6.9 | +4.111 | +5.350 | 64
BA-18-250 | C250SD/1-3 | Z/1282 | 15.4 | +5.586 | +5.738 | 64
PLATE | C250SD/2-3 | Z/1297 | 5.6 | +4.692 | +5.180 | 79
COLUMN | C250SD/3 | Z/1263 | 40.6 | +0.000 | +5.057 | 76
RAFTER | C250SD/2-3 | Z/1264 | 31.9 | +4.844 | +6.313 | 76
PLATE | C250SD/1-2 | Z/1296 | 5.6 | +4.692 | +5.180 | 79
PLATE | C250SD/2 | Z/1291 | 4.4 | +5.996 | +6.341 | 79
RAFTER | C250SD/1-2 | Z/1264 | 31.9 | +4.844 | +6.313 | 76
COLUMN | C250SD/1 | Z/1263 | 40.6 | +0.000 | +5.057 | 76
BHL-15-250 | C250SD/1-2 | Z/1278 | 6.9 | +4.044 | +5.283 | 64
BA-15-250 | C250SD/1-3 | Z/1279 | 15.4 | +5.451 | +5.603 | 64
PLATE | C250SD/2-3 | Z/1295 | 5.3 | +4.692 | +5.149 | 79
COLUMN | C250SD/3 | Z/1261 | 40.6 | +0.000 | +5.060 | 76
RAFTER | C250SD/2-3 | Z/1262 | 31.5 | +4.825 | +6.086 | 76
PLATE | C250SD/1-2 | Z/1294 | 5.3 | +4.692 | +5.149 | 79
PLATE | C250SD/2 | Z/1290 | 4.2 | +5.776 | +6.105 | 79
RAFTER | C250SD/1-2 | Z/1262 | 31.5 | +4.825 | +6.086 | 76
COLUMN | C250SD/1 | Z/1261 | 40.6 | +0.000 | +5.060 | 76
2 x STIFFINER SLEEVE | C250SD/2-3 | Z/566 | 3.4 | +4.934 | +5.259 | 66.2
STIFFINER SLEEVE | C250SD/3 | Z/1256 | 3.4 | +3.983 | +4.383 | 66.2
2 x STIFFINER SLEEVE | C250SD/1-2 | Z/566 | 3.4 | +4.934 | +5.259 | 66.2
2 x STIFFINER SLEEVE | C250SD/1 | Z/566 | 3.4 | +3.983 | +4.383 | 66.2
BHL-12-250 | C250SD/1-2 | Z/581 | 6.9 | +3.964 | +5.203 | 64
BA-12-250 | C250SD/1-3 | Z/582 | 15.4 | +5.318 | +5.470 | 64
PLATE | C250SD/3 | Z/1289 | 5.2 | +4.692 | +5.119 | 79
PLATE | C250SD/1 | Z/1287 | 5.2 | +4.692 | +5.119 | 79
2 x PLATE | C250SD/2 | Z/1288 | 4.2 | +5.562 | +5.877 | 79
2 x FASCIA BRACKET | C200SD/3 | Z/52 | 0.2 | +4.893 | +5.050 | 157.2
2 x FASCIA BRACKET | C200SD/1 | Z/52 | 0.2 | +4.893 | +5.050 | 157.2
2 x FASCIA BRACKET | C200SD/3 | Z/52 | 0.2 | +4.900 | +5.057 | 157.2
2 x FASCIA BRACKET | C200SD/1 | Z/52 | 0.2 | +4.900 | +5.057 | 157.2
2 x FASCIA BRACKET | C200SD/3 | Z/52 | 0.2 | +4.903 | +5.060 | 157.2
2 x FASCIA BRACKET | C200SD/1 | Z/52 | 0.2 | +4.903 | +5.060 | 157.2
RAFTER | C200SD/2-3 | Z/553 | 27.7 | +4.846 | +5.861 | 76
RAFTER | C200SD/1-2 | Z/554 | 27.7 | +4.846 | +5.861 | 76
COLUMN | C200SD/1 | Z/1192 | 35.9 | +0.000 | +5.063 | 76
BHL-25-200 | C200SD/2-3 | Z/1220 | 7.5 | +4.247 | +5.556 | 64
BHL-18-200 | C200SD/2-3 | Z/1217 | 6.7 | +4.167 | +5.349 | 64
BHL-15-200 | C200SD/2-3 | Z/1214 | 6.7 | +4.104 | +5.286 | 64
BHL-12-200 | C200SD/2-3 | Z/1012 | 6.7 | +4.034 | +5.216 | 64
PLATE | C200SD/3 | Z/1233 | 3.7 | +4.775 | +5.192 | 79
BHL-25-200 | C200SD/1-2 | Z/1218 | 7.5 | +4.247 | +5.556 | 64
BA-25-200 | C200SD/1-3 | Z/1219 | 14.4 | +5.984 | +6.136 | 64
COLUMN | C200SD/3 | Z/1198 | 35.9 | +0.000 | +5.050 | 76
RAFTER | C200SD/2-3 | Z/1199 | 29.7 | +4.915 | +6.870 | 76
PLATE | C200SD/1 | Z/1232 | 3.7 | +4.775 | +5.192 | 79
PLATE | C200SD/2 | Z/1223 | 4 | +6.585 | +6.912 | 79
RAFTER | C200SD/1-2 | Z/1199 | 29.7 | +4.915 | +6.870 | 76
COLUMN | C200SD/1 | Z/1198 | 35.9 | +0.000 | +5.050 | 76
BHL-18-200 | C200SD/1-2 | Z/1215 | 6.7 | +4.167 | +5.349 | 64
BA-18-200 | C200SD/1-3 | Z/1216 | 14.4 | +5.642 | +5.794 | 64
PLATE | C200SD/3 | Z/1225 | 3.3 | +4.777 | +5.137 | 79
COLUMN | C200SD/3 | Z/1196 | 35.9 | +0.000 | +5.057 | 76
RAFTER | C200SD/2-3 | Z/1197 | 28.5 | +4.876 | +6.310 | 76
PLATE | C200SD/1 | Z/1224 | 3.3 | +4.777 | +5.137 | 79
PLATE | C200SD/2 | Z/1222 | 3.7 | +6.041 | +6.332 | 79
RAFTER | C200SD/1-2 | Z/1197 | 28.5 | +4.876 | +6.310 | 76
COLUMN | C200SD/1 | Z/1196 | 35.9 | +0.000 | +5.057 | 76
BHL-15-200 | C200SD/1-2 | Z/1212 | 6.7 | +4.104 | +5.286 | 64
BA-15-200 | C200SD/1-3 | Z/1213 | 14.4 | +5.495 | +5.647 | 64
PLATE | C200SD/3 | Z/1227 | 3.2 | +4.777 | +5.114 | 79
COLUMN | C200SD/3 | Z/1194 | 35.9 | +0.000 | +5.060 | 76
RAFTER | C200SD/2-3 | Z/1195 | 28.1 | +4.861 | +6.083 | 76
PLATE | C200SD/1 | Z/1226 | 3.2 | +4.777 | +5.114 | 79
PLATE | C200SD/2 | Z/1221 | 3.6 | +5.822 | +6.099 | 79
RAFTER | C200SD/1-2 | Z/1195 | 28.1 | +4.861 | +6.083 | 76
COLUMN | C200SD/1 | Z/1194 | 35.9 | +0.000 | +5.060 | 76
2 x STIFFINER SLEEVE | C200SD/2-3 | Z/527 | 3 | +4.968 | +5.243 | 66.2
STIFFINER SLEEVE | C200SD/3 | Z/1191 | 3 | +4.023 | +4.423 | 66.2
2 x STIFFINER SLEEVE | C200SD/1-2 | Z/527 | 3 | +4.968 | +5.243 | 66.2
2 x STIFFINER SLEEVE | C200SD/1 | Z/527 | 3 | +4.023 | +4.423 | 66.2
BHL-12-200 | C200SD/1-2 | Z/1211 | 6.7 | +4.034 | +5.216 | 64
BA-12-200 | C200SD/1-3 | Z/539 | 14.4 | +5.365 | +5.517 | 64
PLATE | C200SD/3 | Z/227 | 3.1 | +4.777 | +5.091 | 79
COLUMN | C200SD/3 | Z/1193 | 35.9 | +0.000 | +5.063 | 76
PLATE | C200SD/1 | Z/548 | 3.1 | +4.777 | +5.091 | 79
2 x PLATE | C200SD/2 | Z/187 | 3.4 | +5.609 | +5.872 | 79
2 x FASCIA BRACKET | C150SD/3 | Z/52 | 0.2 | +4.893 | +5.050 | 157.2
2 x FASCIA BRACKET | C150SD/1 | Z/52 | 0.2 | +4.893 | +5.050 | 157.2
BHL-25-150 | C150SD/2-3 | Z/1159 | 6.9 | +4.297 | +5.536 | 64
BHL-25-150 | C150SD/1-2 | Z/1157 | 6.9 | +4.297 | +5.536 | 64
BA-25-150 | C150SD/1-3 | Z/1158 | 13.7 | +6.051 | +6.203 | 64
PLATE | C150SD/3 | Z/1168 | 3 | +4.777 | +5.168 | 67
COLUMN | C150SD/3 | Z/1020 | 28.1 | +0.000 | +5.050 | 64
RAFTER | C150SD/2-3 | Z/1023 | 23.6 | +4.937 | +6.868 | 64
PLATE | C150SD/1 | Z/1167 | 3 | +4.777 | +5.168 | 67
PLATE | C150SD/2 | Z/1162 | 2.5 | +6.646 | +6.900 | 67
RAFTER | C150SD/1-2 | Z/1023 | 23.6 | +4.937 | +6.868 | 64
COLUMN | C150SD/1 | Z/1020 | 28.1 | +0.000 | +5.050 | 64
2 x FASCIA BRACKET | C150SD/3 | Z/52 | 0.2 | +4.900 | +5.057 | 157.2
2 x FASCIA BRACKET | C150SD/1 | Z/52 | 0.2 | +4.900 | +5.057 | 157.2
BHL-18-150 | C150SD/2-3 | Z/1156 | 6.5 | +4.207 | +5.354 | 64
BHL-18-150 | C150SD/1-2 | Z/1154 | 6.5 | +4.207 | +5.354 | 64
BA-18-150 | C150SD/1-3 | Z/1155 | 13.7 | +5.687 | +5.839 | 64
PLATE | C150SD/3 | Z/1166 | 2.7 | +4.777 | +5.120 | 67
COLUMN | C150SD/3 | Z/1014 | 28.2 | +0.000 | +5.057 | 64
RAFTER | C150SD/2-3 | Z/1017 | 22.6 | +4.908 | +6.307 | 64
PLATE | C150SD/1 | Z/1165 | 2.7 | +4.777 | +5.120 | 67
PLATE | C150SD/2 | Z/1161 | 2.3 | +6.099 | +6.324 | 67
RAFTER | C150SD/1-2 | Z/1017 | 22.6 | +4.908 | +6.307 | 64
COLUMN | C150SD/1 | Z/1014 | 28.2 | +0.000 | +5.057 | 64
2 x FASCIA BRACKET | C150SD/3 | Z/52 | 0.2 | +4.903 | +5.060 | 157.2
2 x FASCIA BRACKET | C150SD/1 | Z/52 | 0.2 | +4.903 | +5.060 | 157.2
BHL-15-150 | C150SD/2-3 | Z/1153 | 6.5 | +4.150 | +5.297 | 64
BHL-15-150 | C150SD/1-2 | Z/1108 | 6.5 | +4.150 | +5.297 | 64
BA-15-150 | C150SD/1-3 | Z/1152 | 13.7 | +5.539 | +5.691 | 64
PLATE | C150SD/3 | Z/1164 | 2.6 | +4.777 | +5.100 | 67
COLUMN | C150SD/3 | Z/207 | 28.2 | +0.000 | +5.060 | 64
RAFTER | C150SD/2-3 | Z/308 | 22.3 | +4.896 | +6.080 | 64
PLATE | C150SD/1 | Z/1163 | 2.6 | +4.777 | +5.100 | 67
PLATE | C150SD/2 | Z/1160 | 2.3 | +5.878 | +6.092 | 67
RAFTER | C150SD/1-2 | Z/308 | 22.3 | +4.896 | +6.080 | 64
COLUMN | C150SD/1 | Z/207 | 28.2 | +0.000 | +5.060 | 64
RAFTER | C150SD/2-3 | Z/1140 | 22.1 | +4.886 | +5.858 | 64
COLUMN | C150SD/3 | Z/191 | 28.2 | +0.000 | +5.063 | 64
RAFTER | C150SD/1-2 | Z/1139 | 22.1 | +4.886 | +5.858 | 64
COLUMN | C150SD/1 | Z/51 | 28.2 | +0.000 | +5.063 | 64
BHL-12-150 | C150SD/2-3 | Z/1144 | 6.5 | +4.093 | +5.240 | 64
2 x STIFFINER SLEEVE | C150SD/2-3 | Z/1004 | 2.3 | +5.005 | +5.231 | 54.2
2 x STIFFINER SLEEVE | C150SD/3 | Z/1004 | 2.3 | +4.073 | +4.473 | 54.2
2 x STIFFINER SLEEVE | C150SD/1-2 | Z/1004 | 2.3 | +5.005 | +5.231 | 54.2
2 x STIFFINER SLEEVE | C150SD/1 | Z/1004 | 2.3 | +4.073 | +4.473 | 54.2
BHL-12-150 | C150SD/1-2 | Z/1142 | 6.5 | +4.093 | +5.240 | 64
BA-12-150 | C150SD/1-3 | Z/1143 | 13.7 | +5.400 | +5.552 | 64
PLATE | C150SD/3 | Z/220 | 2.5 | +4.777 | +5.080 | 67
PLATE | C150SD/1 | Z/1000 | 2.5 | +4.777 | +5.080 | 67
2 x PLATE | C150SD/2 | Z/182 | 2.2 | +5.664 | +5.866 | 67
BHL-25-350 | C350SD/2-3 | Z/1454 | 10.6 | +3.886 | +5.691 | 64
BHL-18-350 | C350SD/2-3 | Z/1453 | 8.4 | +3.886 | +5.337 | 64
BHL-15-350 | C350SD/2-3 | Z/1452 | 7.8 | +3.886 | +5.266 | 64
BHL-12-350 | C350SD/2-3 | Z/1416 | 7.8 | +3.816 | +5.196 | 64
BHL-25-300 | C300SD/2-3 | Z/1381 | 9.7 | +3.999 | +5.662 | 64
BHL-18-300 | C300SD/2-3 | Z/1380 | 7.8 | +3.969 | +5.349 | 64
BHL-15-300 | C300SD/2-3 | Z/1379 | 7.5 | +3.962 | +5.272 | 64
BHL-12-300 | C300SD/2-3 | Z/620 | 7.5 | +3.892 | +5.202 | 64
BHL-25-250 | C250SD/2-3 | Z/1310 | 8.4 | +4.151 | +5.602 | 64
BHL-18-250 | C250SD/2-3 | Z/1309 | 6.9 | +4.111 | +5.350 | 64
BHL-15-250 | C250SD/2-3 | Z/1308 | 6.9 | +4.044 | +5.283 | 64
BHL-12-250 | C250SD/2-3 | Z/581 | 6.9 | +3.964 | +5.203 | 64
BHL-25-200 | C200SD/2-3 | Z/1242 | 7.5 | +4.247 | +5.556 | 64
BHL-18-200 | C200SD/2-3 | Z/1241 | 6.7 | +4.167 | +5.349 | 64
BHL-15-200 | C200SD/2-3 | Z/1240 | 6.7 | +4.104 | +5.286 | 64
BHL-12-200 | C200SD/2-3 | Z/1211 | 6.7 | +4.034 | +5.216 | 64
BHL-25-150 | C150SD/2-3 | Z/1177 | 6.9 | +4.297 | +5.536 | 64
BHL-18-150 | C150SD/2-3 | Z/1176 | 6.5 | +4.207 | +5.354 | 64
BHL-15-150 | C150SD/2-3 | Z/1175 | 6.5 | +4.150 | +5.297 | 64
BHL-12-150 | C150SD/2-3 | Z/1142 | 6.5 | +4.093 | +5.240 | 64
RAFTER | C200SD/2-3 | Z/5 | 29.7 | +4.915 | +6.870 | 76
COLUMN | C200SD/3 | Z/111 | 35.9 | +0.000 | +5.050 | 76
BHL-25-350 | C350SD/1-2 | Z/1106 | 10.6 | +3.886 | +5.691 | 64
BA-25-350 | C350SD/1-3 | Z/1107 | 16.3 | +5.856 | +6.008 | 64
BHL-25-300 | C300SD/1-2 | Z/1079 | 9.7 | +3.999 | +5.662 | 64
BA-25-300 | C300SD/1-3 | Z/1080 | 15.4 | +5.917 | +6.069 | 64
BHL-25-250 | C250SD/1-2 | Z/1048 | 8.4 | +4.151 | +5.602 | 64
BA-25-250 | C250SD/1-3 | Z/1049 | 15.4 | +5.924 | +6.076 | 64
BHL-25-200 | C200SD/1-2 | Z/1021 | 7.5 | +4.247 | +5.556 | 64
BA-25-200 | C200SD/1-3 | Z/1022 | 14.4 | +5.984 | +6.136 | 64
BHL-25-150 | C150SD/1-2 | Z/280 | 6.9 | +4.297 | +5.536 | 64
BA-25-150 | C150SD/1-3 | Z/307 | 13.7 | +6.051 | +6.203 | 64
RAFTER | C350SD/2-3 | Z/170 | 60.4 | +4.851 | +6.876 | 125
COLUMN | C350SD/3 | Z/169 | 75.5 | +0.000 | +5.050 | 125
RAFTER | C300SD/2-3 | Z/150 | 51.2 | +4.873 | +6.874 | 96
COLUMN | C300SD/3 | Z/149 | 63.2 | +0.000 | +5.050 | 96
RAFTER | C250SD/2-3 | Z/131 | 33.2 | +4.892 | +6.872 | 76
COLUMN | C250SD/3 | Z/130 | 40.5 | +0.000 | +5.050 | 76
RAFTER | C150SD/2-3 | Z/93 | 23.6 | +4.937 | +6.868 | 64
COLUMN | C150SD/3 | Z/92 | 28.1 | +0.000 | +5.050 | 64
RAFTER | C350SD/1-2 | Z/170 | 60.4 | +4.851 | +6.876 | 125
RAFTER | C300SD/1-2 | Z/150 | 51.2 | +4.873 | +6.874 | 96
RAFTER | C250SD/1-2 | Z/131 | 33.2 | +4.892 | +6.872 | 76
RAFTER | C200SD/1-2 | Z/5 | 29.7 | +4.915 | +6.870 | 76
RAFTER | C150SD/1-2 | Z/93 | 23.6 | +4.937 | +6.868 | 64
COLUMN | C350SD/1 | Z/169 | 75.5 | +0.000 | +5.050 | 125
COLUMN | C300SD/1 | Z/149 | 63.2 | +0.000 | +5.050 | 96
COLUMN | C250SD/1 | Z/130 | 40.5 | +0.000 | +5.050 | 76
COLUMN | C200SD/1 | Z/111 | 35.9 | +0.000 | +5.050 | 76
COLUMN | C150SD/1 | Z/92 | 28.1 | +0.000 | +5.050 | 64
PLATE | C200SD/3 | Z/1031 | 3.7 | +4.775 | +5.192 | 79
FASCIA | C350SD>/3 | Z/561 | 3.4 | +4.896 | +5.048 | 64
TH | C350SD>/3 | Z/562 | 1.8 | +4.549 | +4.674 | 125
FASCIA | C300SD-C350SD/3 | Z/561 | 3.4 | +4.896 | +5.048 | 64
TH | C300SD-C350SD/3 | Z/562 | 1.8 | +4.550 | +4.675 | 125
FASCIA | C250SD-C300SD/3 | Z/561 | 3.4 | +4.895 | +5.047 | 64
TH | C250SD-C300SD/3 | Z/562 | 1.8 | +4.549 | +4.674 | 125
FASCIA | C200SD-C250SD/3 | Z/561 | 3.4 | +4.895 | +5.047 | 64
TH | C200SD-C250SD/3 | Z/562 | 1.8 | +4.549 | +4.674 | 125
TH | C350SD>/2-3 | Z/562 | 1.8 | +5.732 | +5.834 | 125
TH | C300SD-C350SD/2-3 | Z/562 | 1.8 | +5.722 | +5.824 | 125
TH | C250SD-C300SD/2-3 | Z/562 | 1.8 | +5.713 | +5.815 | 125
TH | C200SD-C250SD/2-3 | Z/562 | 1.8 | +5.704 | +5.806 | 125
FASCIA | C150SD-C200SD/3 | Z/561 | 3.4 | +4.895 | +5.047 | 64
TH | C150SD-C200SD/3 | Z/562 | 1.8 | +4.549 | +4.674 | 125
TH | C150SD-C200SD/2-3 | Z/562 | 1.8 | +5.694 | +5.796 | 125
FASCIA | C350SD>/1 | Z/561 | 3.4 | +4.896 | +5.048 | 64
TH | C350SD>/1 | Z/562 | 1.8 | +4.549 | +4.674 | 125
FASCIA | C300SD-C350SD/1 | Z/561 | 3.4 | +4.896 | +5.048 | 64
TH | C300SD-C350SD/1 | Z/562 | 1.8 | +4.550 | +4.675 | 125
FASCIA | C250SD-C300SD/1 | Z/561 | 3.4 | +4.895 | +5.047 | 64
TH | C250SD-C300SD/1 | Z/562 | 1.8 | +4.549 | +4.674 | 125
FASCIA | C200SD-C250SD/1 | Z/561 | 3.4 | +4.895 | +5.047 | 64
TH | C200SD-C250SD/1 | Z/562 | 1.8 | +4.549 | +4.674 | 125
TH | C350SD>/1-2 | Z/562 | 1.8 | +5.732 | +5.834 | 125
TH | C300SD-C350SD/1-2 | Z/562 | 1.8 | +5.722 | +5.824 | 125
TH | C250SD-C300SD/1-2 | Z/562 | 1.8 | +5.713 | +5.815 | 125
TH | C200SD-C250SD/1-2 | Z/562 | 1.8 | +5.704 | +5.806 | 125
FASCIA | C150SD-C200SD/1 | Z/561 | 3.4 | +4.895 | +5.047 | 64
TH | C150SD-C200SD/1 | Z/562 | 1.8 | +4.549 | +4.674 | 125
TH | C150SD-C200SD/1-2 | Z/562 | 1.8 | +5.694 | +5.796 | 125
PLATE | C350SD/2-3 | Z/1116 | 11.8 | +4.577 | +5.345 | 128
PLATE | C300SD/2-3 | Z/1089 | 10.1 | +4.578 | +5.322 | 99
PLATE | C250SD/2-3 | Z/1059 | 6.2 | +4.692 | +5.252 | 79
PLATE | C150SD/3 | Z/994 | 3 | +4.777 | +5.168 | 67
PLATE | C350SD/1-2 | Z/1115 | 11.8 | +4.577 | +5.345 | 128
PLATE | C350SD/1-3 | Z/1123 | 12.4 | +6.373 | +6.947 | 128
PLATE | C300SD/1-2 | Z/1088 | 10.1 | +4.578 | +5.322 | 99
PLATE | C300SD/1-3 | Z/1096 | 10.5 | +6.416 | +6.935 | 99
PLATE | C250SD/1-2 | Z/1058 | 6.2 | +4.692 | +5.252 | 79
PLATE | C250SD/2 | Z/1066 | 4.7 | +6.540 | +6.924 | 79
PLATE | C200SD/1 | Z/1030 | 3.7 | +4.775 | +5.192 | 79
PLATE | C200SD/2 | Z/1038 | 4 | +6.585 | +6.912 | 79
PLATE | C150SD/1 | Z/993 | 3 | +4.777 | +5.168 | 67
PLATE | C150SD/2 | Z/1003 | 2.5 | +6.646 | +6.900 | 67
BHL-18-350 | C350SD/1-2 | Z/1103 | 8.4 | +3.886 | +5.337 | 64
BA-18-350 | C350SD/1-3 | Z/1104 | 16.3 | +5.531 | +5.683 | 64
BHL-18-300 | C300SD/1-2 | Z/1076 | 7.8 | +3.969 | +5.349 | 64
BA-18-300 | C300SD/1-3 | Z/1077 | 15.4 | +5.577 | +5.729 | 64
BHL-18-250 | C250SD/1-2 | Z/1045 | 6.9 | +4.111 | +5.350 | 64
BA-18-250 | C250SD/1-3 | Z/1046 | 15.4 | +5.586 | +5.738 | 64
