Properties of the parts of a building model (IFC2X3), part 3 of 3

# IfcPlate: PLT3*566.6 (4)
Tekla Common - Bottom elevation: +4.572; Top elevation: +5.128; Phase: 1; Class: 11
Tekla Quantity - Weight: 8.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.9 m2; Net surface area: 0.7 m2; Height: 566.6 mm; Width: 3 mm; Length: 839.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 566.553 mm; NetArea: 0.747131 m2; GrossArea: 0.475651 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00110801 m3; GrossVolume: 0.00110801 m3
Name | ASSEMBLY_POS = Reference
PLATE | Z/2548
PLATE | Z/2550
PLATE | Z/2547
PLATE | Z/2549

# IfcPlate: PLT3*571.6 (2)
In: Undefined
Description: PLT3*571.6; Material: STEEL/450
Default - ASSEMBLY_POS: Z/1354
Tekla Common - Bottom elevation: +5.479; Top elevation: +5.882; Phase: 1; Class: 11
Tekla Quantity - Weight: 9.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.9 m2; Net surface area: 0.7 m2; Height: 571.6 mm; Width: 3 mm; Length: 955.4 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/1354
BaseQuantities - Width: 571.641 mm; NetArea: 0.801356 m2; GrossArea: 0.54616 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00118969 m3; GrossVolume: 0.00118969 m3

# IfcPlate: PLT3*576 (2)
In: Undefined
Description: PLT3*576; Material: STEEL/450
Tekla Common - Bottom elevation: +4.577; Top elevation: +5.192; Phase: 1; Class: 11
Tekla Quantity - Weight: 9.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.9 m2; Net surface area: 0.7 m2; Height: 576 mm; Width: 3 mm; Length: 879 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 576.032 mm; NetArea: 0.778939 m2; GrossArea: 0.506333 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00115652 m3; GrossVolume: 0.00115652 m3
Name | ASSEMBLY_POS = Reference
PLATE | Z/1364
PLATE | Z/1092

# IfcPlate: PLT3*576.1 (2)
In: Undefined
Description: PLT3*576.1; Material: STEEL/450
Tekla Common - Bottom elevation: +4.577; Top elevation: +5.192; Phase: 1; Class: 11
Tekla Quantity - Weight: 9.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.9 m2; Net surface area: 0.7 m2; Height: 576.1 mm; Width: 3 mm; Length: 879 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 576.057 mm; NetArea: 0.77894 m2; GrossArea: 0.506359 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00115653 m3; GrossVolume: 0.00115653 m3
Name | ASSEMBLY_POS = Reference
PLATE | Z/1363
PLATE | Z/1093

# IfcPlate: PLT3*585.2 (4)
In: Undefined
Description: PLT3*585.2; Material: STEEL/450
Tekla Common - Bottom elevation: +4.577; Top elevation: +5.231; Phase: 1; Class: 11
Tekla Quantity - Weight: 9.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.9 m2; Net surface area: 0.7 m2; Height: 585.2 mm; Length: 904.9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Tekla Quantity, Width (mm) | BaseQuantities, Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
PLATE | Z/1366 | 3 | 585.177 | 0.803909 | 0.529521 | 0.00119378
PLATE | Z/1365 | 3.1 | 585.228 | 0.803911 | 0.529577 | 0.00119381
PLATE | Z/1091 | 3.1 | 585.228 | 0.803911 | 0.529577 | 0.00119381
PLATE | Z/1090 | 3 | 585.177 | 0.803909 | 0.529521 | 0.00119378

# IfcPlate: PLT3*601.4 (2)
In: Undefined
Description: PLT3*601.4; Material: STEEL/450
Tekla Common - Bottom elevation: +4.578; Top elevation: +5.322; Phase: 1; Class: 11
Tekla Quantity - Weight: 10.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.9 m2; Net surface area: 0.9 m2; Height: 601.4 mm; Width: 3.1 mm; Length: 967.3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 601.441 mm; NetArea: 0.863374 m2; GrossArea: 0.581793 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.0012825 m3; GrossVolume: 0.0012825 m3
Name | ASSEMBLY_POS = Reference
PLATE | Z/1368
PLATE | Z/1088

# IfcPlate: PLT3*601.6 (2)
In: Undefined
Description: PLT3*601.6; Material: STEEL/450
Tekla Common - Bottom elevation: +4.578; Top elevation: +5.322; Phase: 1; Class: 11
Tekla Quantity - Weight: 10.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.9 m2; Net surface area: 0.9 m2; Height: 601.6 mm; Width: 3.1 mm; Length: 967.4 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 601.577 mm; NetArea: 0.863379 m2; GrossArea: 0.58195 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00128254 m3; GrossVolume: 0.00128254 m3
Name | ASSEMBLY_POS = Reference
PLATE | Z/1367
PLATE | Z/1089

# IfcPlate: PLT3*605.6 (4)
In: Undefined
Description: PLT3*605.6; Material: STEEL/G450
Tekla Common - Bottom elevation: +4.572; Top elevation: +5.136; Phase: 1; Class: 11
Tekla Quantity - Weight: 9.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.9 m2; Net surface area: 0.9 m2; Height: 605.6 mm; Width: 3 mm; Length: 889.3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 605.596 mm; NetArea: 0.853405 m2; GrossArea: 0.538543 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00126655 m3; GrossVolume: 0.00126655 m3
Name | ASSEMBLY_POS = Reference
PLATE | Z/2563
PLATE | Z/2565
PLATE | Z/2562
PLATE | Z/2564

# IfcPlate: PLT3*606.1 (4)
In: Undefined
Description: PLT3*606.1; Material: STEEL/450
Tekla Common - Bottom elevation: +4.577; Top elevation: +5.164; Phase: 1; Class: 11
Tekla Quantity - Weight: 10.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.9 m2; Net surface area: 0.9 m2; Height: 606.1 mm; Width: 3 mm; Length: 905.1 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - NetArea: 0.865061 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00128499 m3; GrossVolume: 0.00128499 m3
Name | ASSEMBLY_POS = Reference | Width (mm) | GrossArea (m2)
2 x PLATE | Z/1432 | 606.062 | 0.548534
2 x PLATE | Z/1431 | 606.065 | 0.548538

# IfcPlate: PLT3*609.9 (2)
In: Undefined
Description: PLT3*609.9; Material: STEEL/450
Tekla Common - Bottom elevation: +5.683; Top elevation: +6.112; Phase: 1; Class: 11
Tekla Quantity - Weight: 9.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.9 m2; Net surface area: 0.7 m2; Height: 609.9 mm; Width: 3 mm; Length: 968.2 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 609.9 mm; NetArea: 0.826034 m2; GrossArea: 0.590519 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00122661 m3; GrossVolume: 0.00122661 m3
Name | ASSEMBLY_POS = Reference
PLATE | Z/1355
PLATE | Z/1094

# IfcPlate: PLT3*618.8 (4)
In: Undefined
Description: PLT3*618.8; Material: STEEL/450
Tekla Common - Bottom elevation: +4.577; Top elevation: +5.205; Phase: 1; Class: 11
Tekla Quantity - Weight: 10.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.7 m2; Net surface area: 0.9 m2; Height: 618.8 mm; Width: 3 mm; Length: 932.1 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
PLATE | Z/1435 | 618.779 | 0.896833 | 0.576777 | 0.00133246
PLATE | Z/1434 | 618.804 | 0.896834 | 0.576804 | 0.00133245
PLATE | Z/1120 | 618.804 | 0.896834 | 0.576804 | 0.00133245
PLATE | Z/1119 | 618.779 | 0.896833 | 0.576777 | 0.00133246

# IfcPlate: PLT3*623.4 (2)
In: Undefined
Description: PLT3*623.4; Material: STEEL/450
Tekla Common - Bottom elevation: +5.299; Top elevation: +5.736; Phase: 1; Class: 11
Tekla Quantity - Weight: 10.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.7 m2; Net surface area: 0.9 m2; Height: 623.4 mm; Width: 3 mm; Length: 965.9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 623.448 mm; NetArea: 0.929783 m2; GrossArea: 0.602188 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00138161 m3; GrossVolume: 0.00138161 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1668
PLATE | PL/1673

# IfcPlate: PLT3*630.2 (2)
In: Undefined
Description: PLT3*630.2; Material: STEEL/450
Tekla Common - Bottom elevation: +4.577; Top elevation: +5.247; Phase: 1; Class: 11
Tekla Quantity - Weight: 10.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.7 m2; Net surface area: 0.9 m2; Height: 630.2 mm; Width: 3.1 mm; Length: 959.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 630.227 mm; NetArea: 0.929235 m2; GrossArea: 0.604746 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00138086 m3; GrossVolume: 0.00138086 m3
Name | ASSEMBLY_POS = Reference
PLATE | Z/1437
PLATE | Z/1117

# IfcPlate: PLT3*630.3 (2)
In: Undefined
Description: PLT3*630.3; Material: STEEL/450
Tekla Common - Bottom elevation: +4.577; Top elevation: +5.247; Phase: 1; Class: 11
Tekla Quantity - Weight: 10.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.7 m2; Net surface area: 0.9 m2; Height: 630.3 mm; Width: 3 mm; Length: 959.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 630.281 mm; NetArea: 0.929236 m2; GrossArea: 0.604807 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00138084 m3; GrossVolume: 0.00138084 m3
Name | ASSEMBLY_POS = Reference
PLATE | Z/1436
PLATE | Z/1118

# IfcPlate: PLT3*645.5 (2)
In: Undefined
Description: PLT3*645.5; Material: STEEL/450
Tekla Common - Bottom elevation: +5.893; Top elevation: +6.348; Phase: 1; Class: 11
Tekla Quantity - Weight: 9.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.9 m2; Net surface area: 0.7 m2; Height: 645.5 mm; Width: 3 mm; Length: 975.3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 645.542 mm; NetArea: 0.849539 m2; GrossArea: 0.629592 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00126179 m3; GrossVolume: 0.00126179 m3
Name | ASSEMBLY_POS = Reference
PLATE | Z/1356
PLATE | Z/1095

# IfcPlate: PLT3*650 (2)
In: Undefined
Description: PLT3*650; Material: STEEL/450
Default - ASSEMBLY_POS: Z/1427
Tekla Common - Bottom elevation: +5.433; Top elevation: +5.887; Phase: 1; Class: 11
Tekla Quantity - Weight: 11.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.7 m2; Net surface area: 0.9 m2; Height: 650 mm; Width: 3 mm; Length: 981.8 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/1427
BaseQuantities - Width: 650 mm; NetArea: 0.948818 m2; GrossArea: 0.638154 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00141008 m3; GrossVolume: 0.00141008 m3

# IfcPlate: PLT3*651.8 (2)
In: Undefined
Description: PLT3*651.8; Material: STEEL/450
Tekla Common - Bottom elevation: +4.577; Top elevation: +5.345; Phase: 1; Class: 11
Tekla Quantity - Weight: 11.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.7 m2; Net surface area: 0.9 m2; Height: 651.8 mm; Width: 3.1 mm; Length: 1025.7 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 651.804 mm; NetArea: 1.00762 m2; GrossArea: 0.668586 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00149792 m3; GrossVolume: 0.00149792 m3
Name | ASSEMBLY_POS = Reference
PLATE | Z/1439
PLATE | Z/1115

# IfcPlate: PLT3*652 (2)
In: Undefined
Description: PLT3*652; Material: STEEL/450
Tekla Common - Bottom elevation: +4.577; Top elevation: +5.345; Phase: 1; Class: 11
Tekla Quantity - Weight: 11.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.7 m2; Net surface area: 0.9 m2; Height: 652 mm; Width: 3.1 mm; Length: 1025.7 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 651.954 mm; NetArea: 1.00763 m2; GrossArea: 0.668766 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.0014979 m3; GrossVolume: 0.0014979 m3
Name | ASSEMBLY_POS = Reference
PLATE | Z/1438
PLATE | Z/1116

# IfcPlate: PLT3*687.9 (2)
In: Undefined
Description: PLT3*687.9; Material: STEEL/450
Tekla Common - Bottom elevation: +5.638; Top elevation: +6.119; Phase: 1; Class: 11
Tekla Quantity - Weight: 11.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.7 m2; Net surface area: 0.9 m2; Height: 687.9 mm; Width: 3 mm; Length: 1000.7 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 687.908 mm; NetArea: 0.97651 m2; GrossArea: 0.688403 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.0014515 m3; GrossVolume: 0.0014515 m3
Name | ASSEMBLY_POS = Reference
PLATE | Z/1428
PLATE | Z/1121

# IfcPlate: PLT3*716.4 (2)
In: Undefined
Description: PLT3*716.4; Material: STEEL/450
Tekla Common - Bottom elevation: +6.416; Top elevation: +6.935; Phase: 1; Class: 11
Tekla Quantity - Weight: 10.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.7 m2; Net surface area: 0.9 m2; Height: 716.4 mm; Width: 3 mm; Length: 969.5 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 716.41 mm; NetArea: 0.899521 m2; GrossArea: 0.694526 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00133658 m3; GrossVolume: 0.00133658 m3
Name | ASSEMBLY_POS = Reference
PLATE | Z/1357
PLATE | Z/1096

# IfcPlate: PLT3*723.1 (2)
In: Undefined
Description: PLT3*723.1; Material: STEEL/450
Tekla Common - Bottom elevation: +5.849; Top elevation: +6.357; Phase: 1; Class: 11
Tekla Quantity - Weight: 11.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.7 m2; Net surface area: 0.9 m2; Height: 723.1 mm; Width: 3 mm; Length: 1013.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 723.131 mm; NetArea: 1.00302 m2; GrossArea: 0.732998 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00149115 m3; GrossVolume: 0.00149115 m3
Name | ASSEMBLY_POS = Reference
PLATE | Z/1429
PLATE | Z/1122

# IfcPlate: PLT3*792.7 (2)
In: Undefined
Description: PLT3*792.7; Material: STEEL/450
Tekla Common - Bottom elevation: +6.373; Top elevation: +6.947; Phase: 1; Class: 11
Tekla Quantity - Weight: 12.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.7 m2; Net surface area: 1.1 m2; Height: 792.7 mm; Width: 3 mm; Length: 1020 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 792.682 mm; NetArea: 1.06002 m2; GrossArea: 0.808545 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.0015764 m3; GrossVolume: 0.0015764 m3
Name | ASSEMBLY_POS = Reference
PLATE | Z/1430
PLATE | Z/1123
