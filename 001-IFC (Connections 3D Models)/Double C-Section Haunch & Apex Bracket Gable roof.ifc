Properties of the parts of a building model (IFC2X3), part 2 of 3

# IfcElementAssembly (830)
Name | ASSEMBLY_POSITION_CODE = Assembly/Cast unit position code | ASSEMBLY_POS = Assembly/Cast unit Mark | Assembly/Cast unit weight (kg) | Assembly/Cast unit bottom elevation | Assembly/Cast unit top elevation | Width (mm)
BHL-18-200 | C200SD/1-2 | Z/1018 | 6.7 | +4.167 | +5.349 | 64
BA-18-200 | C200SD/1-3 | Z/1019 | 14.4 | +5.642 | +5.794 | 64
BHL-18-150 | C150SD/1-2 | Z/205 | 6.5 | +4.207 | +5.354 | 64
BA-18-150 | C150SD/1-3 | Z/206 | 13.7 | +5.687 | +5.839 | 64
RAFTER | C350SD/2-3 | Z/167 | 58.2 | +4.784 | +6.320 | 125
COLUMN | C350SD/3 | Z/166 | 75.7 | +0.000 | +5.057 | 125
RAFTER | C300SD/2-3 | Z/147 | 49.2 | +4.815 | +6.317 | 96
COLUMN | C300SD/3 | Z/146 | 63.2 | +0.000 | +5.057 | 96
RAFTER | C250SD/2-3 | Z/128 | 31.9 | +4.844 | +6.313 | 76
COLUMN | C250SD/3 | Z/127 | 40.6 | +0.000 | +5.057 | 76
COLUMN | C200SD/3 | Z/109 | 35.9 | +0.000 | +5.057 | 76
RAFTER | C150SD/2-3 | Z/90 | 22.6 | +4.908 | +6.307 | 64
COLUMN | C150SD/3 | Z/89 | 28.2 | +0.000 | +5.057 | 64
RAFTER | C200SD/2-3 | Z/4 | 28.5 | +4.876 | +6.310 | 76
RAFTER | C350SD/1-2 | Z/167 | 58.2 | +4.784 | +6.320 | 125
RAFTER | C300SD/1-2 | Z/147 | 49.2 | +4.815 | +6.317 | 96
RAFTER | C250SD/1-2 | Z/128 | 31.9 | +4.844 | +6.313 | 76
RAFTER | C200SD/1-2 | Z/4 | 28.5 | +4.876 | +6.310 | 76
RAFTER | C150SD/1-2 | Z/90 | 22.6 | +4.908 | +6.307 | 64
COLUMN | C350SD/1 | Z/166 | 75.7 | +0.000 | +5.057 | 125
COLUMN | C300SD/1 | Z/146 | 63.2 | +0.000 | +5.057 | 96
COLUMN | C250SD/1 | Z/127 | 40.6 | +0.000 | +5.057 | 76
COLUMN | C200SD/1 | Z/109 | 35.9 | +0.000 | +5.057 | 76
COLUMN | C150SD/1 | Z/89 | 28.2 | +0.000 | +5.057 | 64
FASCIA | C350SD>/3 | Z/561 | 3.4 | +4.902 | +5.054 | 64
TH | C350SD>/3 | Z/562 | 1.8 | +4.556 | +4.681 | 125
FASCIA | C300SD-C350SD/3 | Z/561 | 3.4 | +4.902 | +5.054 | 64
TH | C300SD-C350SD/3 | Z/562 | 1.8 | +4.556 | +4.681 | 125
FASCIA | C250SD-C300SD/3 | Z/561 | 3.4 | +4.902 | +5.054 | 64
TH | C250SD-C300SD/3 | Z/562 | 1.8 | +4.556 | +4.681 | 125
FASCIA | C200SD-C250SD/3 | Z/561 | 3.4 | +4.902 | +5.054 | 64
TH | C200SD-C250SD/3 | Z/562 | 1.8 | +4.556 | +4.681 | 125
TH | C350SD>/2-3 | Z/562 | 1.8 | +5.541 | +5.637 | 125
TH | C300SD-C350SD/2-3 | Z/562 | 1.8 | +5.537 | +5.633 | 125
TH | C250SD-C300SD/2-3 | Z/562 | 1.8 | +5.526 | +5.622 | 125
TH | C200SD-C250SD/2-3 | Z/562 | 1.8 | +5.519 | +5.615 | 125
FASCIA | C150SD-C200SD/3 | Z/561 | 3.4 | +4.902 | +5.054 | 64
TH | C150SD-C200SD/3 | Z/562 | 1.8 | +4.556 | +4.681 | 125
TH | C150SD-C200SD/2-3 | Z/562 | 1.8 | +5.511 | +5.607 | 125
FASCIA | C350SD>/1 | Z/561 | 3.4 | +4.902 | +5.054 | 64
TH | C350SD>/1 | Z/562 | 1.8 | +4.556 | +4.681 | 125
FASCIA | C300SD-C350SD/1 | Z/561 | 3.4 | +4.902 | +5.054 | 64
TH | C300SD-C350SD/1 | Z/562 | 1.8 | +4.556 | +4.681 | 125
FASCIA | C250SD-C300SD/1 | Z/561 | 3.4 | +4.902 | +5.054 | 64
TH | C250SD-C300SD/1 | Z/562 | 1.8 | +4.556 | +4.681 | 125
FASCIA | C200SD-C250SD/1 | Z/561 | 3.4 | +4.902 | +5.054 | 64
TH | C200SD-C250SD/1 | Z/562 | 1.8 | +4.556 | +4.681 | 125
TH | C350SD>/1-2 | Z/562 | 1.8 | +5.541 | +5.637 | 125
TH | C300SD-C350SD/1-2 | Z/562 | 1.8 | +5.537 | +5.633 | 125
TH | C250SD-C300SD/1-2 | Z/562 | 1.8 | +5.526 | +5.622 | 125
TH | C200SD-C250SD/1-2 | Z/562 | 1.8 | +5.519 | +5.615 | 125
FASCIA | C150SD-C200SD/1 | Z/561 | 3.4 | +4.902 | +5.054 | 64
TH | C150SD-C200SD/1 | Z/562 | 1.8 | +4.556 | +4.681 | 125
TH | C150SD-C200SD/1-2 | Z/562 | 1.8 | +5.511 | +5.607 | 125
PLATE | C350SD/2-3 | Z/1118 | 10.8 | +4.577 | +5.247 | 128
PLATE | C300SD/2-3 | Z/1091 | 9.4 | +4.577 | +5.231 | 99
PLATE | C250SD/2-3 | Z/1061 | 5.6 | +4.692 | +5.180 | 79
PLATE | C200SD/3 | Z/1035 | 3.3 | +4.777 | +5.137 | 79
PLATE | C150SD/3 | Z/996 | 2.7 | +4.777 | +5.120 | 67
PLATE | C350SD/1-2 | Z/1117 | 10.8 | +4.577 | +5.247 | 128
PLATE | C350SD/1-3 | Z/1122 | 11.8 | +5.849 | +6.357 | 128
PLATE | C300SD/1-2 | Z/1090 | 9.4 | +4.577 | +5.231 | 99
PLATE | C300SD/2 | Z/1095 | 9.9 | +5.893 | +6.348 | 99
PLATE | C250SD/1-2 | Z/1060 | 5.6 | +4.692 | +5.180 | 79
PLATE | C250SD/2 | Z/1065 | 4.4 | +5.996 | +6.341 | 79
PLATE | C200SD/1 | Z/1034 | 3.3 | +4.777 | +5.137 | 79
PLATE | C200SD/2 | Z/1037 | 3.7 | +6.041 | +6.332 | 79
PLATE | C150SD/1 | Z/995 | 2.7 | +4.777 | +5.120 | 67
PLATE | C150SD/2 | Z/1002 | 2.3 | +6.099 | +6.324 | 67
BHL-15-350 | C350SD/1-2 | Z/1100 | 7.8 | +3.886 | +5.266 | 64
BA-15-350 | C350SD/1-3 | Z/1101 | 16.3 | +5.391 | +5.543 | 64
BHL-15-300 | C300SD/1-2 | Z/1073 | 7.5 | +3.962 | +5.272 | 64
BA-15-300 | C300SD/1-3 | Z/1074 | 15.4 | +5.427 | +5.579 | 64
BHL-15-250 | C250SD/1-2 | Z/1042 | 6.9 | +4.044 | +5.283 | 64
BA-15-250 | C250SD/1-3 | Z/1043 | 15.4 | +5.451 | +5.603 | 64
BHL-15-200 | C200SD/1-2 | Z/1015 | 6.7 | +4.104 | +5.286 | 64
BA-15-200 | C200SD/1-3 | Z/1016 | 14.4 | +5.495 | +5.647 | 64
BHL-15-150 | C150SD/1-2 | Z/57 | 6.5 | +4.150 | +5.297 | 64
BA-15-150 | C150SD/1-3 | Z/190 | 13.7 | +5.539 | +5.691 | 64
RAFTER | C350SD/2-3 | Z/164 | 57.6 | +4.758 | +6.093 | 125
COLUMN | C350SD/3 | Z/163 | 75.7 | +0.000 | +5.060 | 125
RAFTER | C300SD/2-3 | Z/144 | 48.6 | +4.793 | +6.090 | 96
COLUMN | C300SD/3 | Z/143 | 63.3 | +0.000 | +5.060 | 96
RAFTER | C250SD/2-3 | Z/125 | 31.5 | +4.825 | +6.086 | 76
COLUMN | C250SD/3 | Z/124 | 40.6 | +0.000 | +5.060 | 76
RAFTER | C200SD/2-3 | Z/107 | 28.1 | +4.861 | +6.083 | 76
COLUMN | C200SD/3 | Z/106 | 35.9 | +0.000 | +5.060 | 76
RAFTER | C150SD/2-3 | Z/87 | 22.3 | +4.896 | +6.080 | 64
COLUMN | C150SD/3 | Z/86 | 28.2 | +0.000 | +5.060 | 64
RAFTER | C350SD/1-2 | Z/164 | 57.6 | +4.758 | +6.093 | 125
RAFTER | C300SD/1-2 | Z/144 | 48.6 | +4.793 | +6.090 | 96
RAFTER | C250SD/1-2 | Z/125 | 31.5 | +4.825 | +6.086 | 76
RAFTER | C200SD/1-2 | Z/107 | 28.1 | +4.861 | +6.083 | 76
RAFTER | C150SD/1-2 | Z/87 | 22.3 | +4.896 | +6.080 | 64
COLUMN | C350SD/1 | Z/163 | 75.7 | +0.000 | +5.060 | 125
COLUMN | C300SD/1 | Z/143 | 63.3 | +0.000 | +5.060 | 96
COLUMN | C250SD/1 | Z/124 | 40.6 | +0.000 | +5.060 | 76
COLUMN | C200SD/1 | Z/106 | 35.9 | +0.000 | +5.060 | 76
COLUMN | C150SD/1 | Z/86 | 28.2 | +0.000 | +5.060 | 64
FASCIA | C350SD>/3 | Z/561 | 3.4 | +4.906 | +5.058 | 64
TH | C350SD>/3 | Z/562 | 1.8 | +4.559 | +4.684 | 125
FASCIA | C300SD-C350SD/3 | Z/561 | 3.4 | +4.906 | +5.058 | 64
TH | C300SD-C350SD/3 | Z/562 | 1.8 | +4.559 | +4.684 | 125
FASCIA | C250SD-C300SD/3 | Z/561 | 3.4 | +4.905 | +5.057 | 64
TH | C250SD-C300SD/3 | Z/562 | 1.8 | +4.559 | +4.684 | 125
FASCIA | C200SD-C250SD/3 | Z/561 | 3.4 | +4.905 | +5.057 | 64
TH | C200SD-C250SD/3 | Z/562 | 1.8 | +4.559 | +4.684 | 125
TH | C350SD>/2-3 | Z/562 | 1.8 | +5.453 | +5.547 | 125
TH | C300SD-C350SD/2-3 | Z/562 | 1.8 | +5.447 | +5.540 | 125
TH | C250SD-C300SD/2-3 | Z/562 | 1.8 | +5.441 | +5.534 | 125
TH | C200SD-C250SD/2-3 | Z/562 | 1.8 | +5.435 | +5.528 | 125
FASCIA | C150SD-C200SD/3 | Z/561 | 3.4 | +4.905 | +5.057 | 64
TH | C150SD-C200SD/3 | Z/562 | 1.8 | +4.559 | +4.684 | 125
TH | C150SD-C200SD/2-3 | Z/562 | 1.8 | +5.428 | +5.522 | 125
FASCIA | C350SD>/1 | Z/561 | 3.4 | +4.906 | +5.058 | 64
TH | C350SD>/1 | Z/562 | 1.8 | +4.559 | +4.684 | 125
FASCIA | C300SD-C350SD/1 | Z/561 | 3.4 | +4.906 | +5.058 | 64
TH | C300SD-C350SD/1 | Z/562 | 1.8 | +4.559 | +4.684 | 125
FASCIA | C250SD-C300SD/1 | Z/561 | 3.4 | +4.905 | +5.057 | 64
TH | C250SD-C300SD/1 | Z/562 | 1.8 | +4.559 | +4.684 | 125
FASCIA | C200SD-C250SD/1 | Z/561 | 3.4 | +4.905 | +5.057 | 64
TH | C200SD-C250SD/1 | Z/562 | 1.8 | +4.559 | +4.684 | 125
TH | C350SD>/1-2 | Z/562 | 1.8 | +5.453 | +5.547 | 125
TH | C300SD-C350SD/1-2 | Z/562 | 1.8 | +5.447 | +5.540 | 125
TH | C250SD-C300SD/1-2 | Z/562 | 1.8 | +5.441 | +5.534 | 125
TH | C200SD-C250SD/1-2 | Z/562 | 1.8 | +5.435 | +5.528 | 125
FASCIA | C150SD-C200SD/1 | Z/561 | 3.4 | +4.905 | +5.057 | 64
TH | C150SD-C200SD/1 | Z/562 | 1.8 | +4.559 | +4.684 | 125
TH | C150SD-C200SD/1-2 | Z/562 | 1.8 | +5.428 | +5.522 | 125
PLATE | C350SD/2-3 | Z/1120 | 10.5 | +4.577 | +5.205 | 128
PLATE | C300SD/2-3 | Z/1093 | 9.1 | +4.577 | +5.192 | 99
PLATE | C250SD/2-3 | Z/1063 | 5.3 | +4.692 | +5.149 | 79
PLATE | C200SD/3 | Z/1033 | 3.2 | +4.777 | +5.114 | 79
PLATE | C150SD/3 | Z/998 | 2.6 | +4.777 | +5.100 | 67
PLATE | C350SD/1-2 | Z/1119 | 10.5 | +4.577 | +5.205 | 128
PLATE | C350SD/1-3 | Z/1121 | 11.4 | +5.638 | +6.119 | 128
PLATE | C300SD/1-2 | Z/1092 | 9.1 | +4.577 | +5.192 | 99
PLATE | C300SD/2 | Z/1094 | 9.7 | +5.683 | +6.112 | 99
PLATE | C250SD/1-2 | Z/1062 | 5.3 | +4.692 | +5.149 | 79
PLATE | C250SD/2 | Z/1064 | 4.2 | +5.776 | +6.105 | 79
PLATE | C200SD/1 | Z/1032 | 3.2 | +4.777 | +5.114 | 79
PLATE | C200SD/2 | Z/1036 | 3.6 | +5.822 | +6.099 | 79
PLATE | C150SD/1 | Z/997 | 2.6 | +4.777 | +5.100 | 67
PLATE | C150SD/2 | Z/1001 | 2.3 | +5.878 | +6.092 | 67
RAFTER | C350SD/2-3 | Z/1457 | 57.1 | +4.734 | +5.871 | 125
COLUMN | C350SD/3 | Z/1458 | 75.7 | +0.000 | +5.063 | 125
RAFTER | C350SD/1-2 | Z/1456 | 57.1 | +4.734 | +5.871 | 125
COLUMN | C350SD/1 | Z/1455 | 75.7 | +0.000 | +5.063 | 125
RAFTER | C300SD/2-3 | Z/1384 | 48.2 | +4.772 | +5.868 | 96
COLUMN | C300SD/3 | Z/1385 | 63.3 | +0.000 | +5.063 | 96
RAFTER | C300SD/1-2 | Z/1383 | 48.2 | +4.772 | +5.868 | 96
COLUMN | C300SD/1 | Z/1382 | 63.3 | +0.000 | +5.063 | 96
RAFTER | C250SD/2-3 | Z/1313 | 31.2 | +4.807 | +5.865 | 76
COLUMN | C250SD/3 | Z/1314 | 40.6 | +0.000 | +5.063 | 76
RAFTER | C250SD/1-2 | Z/1312 | 31.2 | +4.807 | +5.865 | 76
COLUMN | C250SD/1 | Z/1311 | 40.6 | +0.000 | +5.063 | 76
RAFTER | C200SD/2-3 | Z/1245 | 27.7 | +4.846 | +5.861 | 76
COLUMN | C200SD/3 | Z/1246 | 35.9 | +0.000 | +5.063 | 76
RAFTER | C200SD/1-2 | Z/1244 | 27.7 | +4.846 | +5.861 | 76
COLUMN | C200SD/1 | Z/1243 | 35.9 | +0.000 | +5.063 | 76
RAFTER | C150SD/2-3 | Z/1180 | 22.1 | +4.886 | +5.858 | 64
COLUMN | C150SD/3 | Z/1181 | 28.2 | +0.000 | +5.063 | 64
RAFTER | C150SD/1-2 | Z/1179 | 22.1 | +4.886 | +5.858 | 64
COLUMN | C150SD/1 | Z/1178 | 28.2 | +0.000 | +5.063 | 64
STIFFINER SLEEVE | C250SD/3 | Z/566 | 3.4 | +3.983 | +4.383 | 66.2
STIFFINER SLEEVE | C200SD/3 | Z/527 | 3 | +4.023 | +4.423 | 66.2
FASCIA | C350SD>/3 | Z/561 | 3.4 | +4.909 | +5.061 | 64
TH | C350SD>/3 | Z/562 | 1.8 | +4.562 | +4.687 | 125
FASCIA | C300SD-C350SD/3 | Z/561 | 3.4 | +4.908 | +5.060 | 64
TH | C300SD-C350SD/3 | Z/562 | 1.8 | +4.562 | +4.687 | 125
FASCIA | C250SD-C300SD/3 | Z/561 | 3.4 | +4.908 | +5.060 | 64
TH | C250SD-C300SD/3 | Z/562 | 1.8 | +4.562 | +4.687 | 125
FASCIA | C200SD-C250SD/3 | Z/561 | 3.4 | +4.909 | +5.061 | 64
TH | C200SD-C250SD/3 | Z/562 | 1.8 | +4.562 | +4.687 | 125
TH | C350SD>/2-3 | Z/562 | 1.8 | +5.365 | +5.455 | 125
TH | C300SD-C350SD/2-3 | Z/562 | 1.8 | +5.360 | +5.450 | 125
TH | C250SD-C300SD/2-3 | Z/562 | 1.8 | +5.355 | +5.445 | 125
TH | C200SD-C250SD/2-3 | Z/562 | 1.8 | +5.349 | +5.440 | 125
TH | C150SD-C200SD/2-3 | Z/562 | 1.8 | +5.344 | +5.435 | 125
FASCIA | C150SD-C200SD/3 | Z/561 | 3.4 | +4.909 | +5.061 | 64
TH | C150SD-C200SD/3 | Z/562 | 1.8 | +4.562 | +4.687 | 125
FASCIA | C350SD>/1 | Z/561 | 3.4 | +4.909 | +5.061 | 64
TH | C350SD>/1 | Z/562 | 1.8 | +4.562 | +4.687 | 125
FASCIA | C300SD-C350SD/1 | Z/561 | 3.4 | +4.908 | +5.060 | 64
TH | C300SD-C350SD/1 | Z/562 | 1.8 | +4.562 | +4.687 | 125
FASCIA | C250SD-C300SD/1 | Z/561 | 3.4 | +4.908 | +5.060 | 64
TH | C250SD-C300SD/1 | Z/562 | 1.8 | +4.562 | +4.687 | 125
FASCIA | C200SD-C250SD/1 | Z/561 | 3.4 | +4.909 | +5.061 | 64
TH | C200SD-C250SD/1 | Z/562 | 1.8 | +4.562 | +4.687 | 125
TH | C350SD>/1-2 | Z/562 | 1.8 | +5.365 | +5.455 | 125
TH | C300SD-C350SD/1-2 | Z/562 | 1.8 | +5.360 | +5.450 | 125
TH | C250SD-C300SD/1-2 | Z/562 | 1.8 | +5.355 | +5.445 | 125
TH | C200SD-C250SD/1-2 | Z/562 | 1.8 | +5.349 | +5.440 | 125
TH | C150SD-C200SD/1-2 | Z/562 | 1.8 | +5.344 | +5.435 | 125
FASCIA | C150SD-C200SD/1 | Z/561 | 3.4 | +4.909 | +5.061 | 64
TH | C150SD-C200SD/1 | Z/562 | 1.8 | +4.562 | +4.687 | 125
BHL-12-350 | C350SD/1-2 | Z/1097 | 7.8 | +3.816 | +5.196 | 64
BHL-12-300 | C300SD/1-2 | Z/1070 | 7.5 | +3.892 | +5.202 | 64
BHL-12-250 | C250SD/1-2 | Z/1039 | 6.9 | +3.964 | +5.203 | 64
BHL-12-200 | C200SD/1-2 | Z/1012 | 6.7 | +4.034 | +5.216 | 64
BA-12-300 | C300SD/1-3 | Z/1071 | 15.4 | +5.277 | +5.429 | 64
BA-12-250 | C250SD/1-3 | Z/1040 | 15.4 | +5.318 | +5.470 | 64
BA-12-200 | C200SD/1-3 | Z/1013 | 14.4 | +5.365 | +5.517 | 64
BHL-12-150 | C150SD/1-2 | Z/22 | 6.5 | +4.093 | +5.240 | 64
BA-12-150 | C150SD/1-3 | Z/23 | 13.7 | +5.400 | +5.552 | 64
PLATE | C350SD/2-3 | Z/1431 | 10.1 | +4.577 | +5.164 | 128
PLATE | C300SD/2-3 | Z/1358 | 8.7 | +4.577 | +5.153 | 99
PLATE | C250SD/3 | Z/1287 | 5.2 | +4.692 | +5.119 | 79
PLATE | C200SD/3 | Z/548 | 3.1 | +4.777 | +5.091 | 79
PLATE | C150SD/3 | Z/1000 | 2.5 | +4.777 | +5.080 | 67
PLATE | C350SD/1-2 | Z/1432 | 10.1 | +4.577 | +5.164 | 128
PLATE | C300SD/1-2 | Z/1359 | 8.7 | +4.577 | +5.153 | 99
PLATE | C250SD/1 | Z/1289 | 5.2 | +4.692 | +5.119 | 79
PLATE | C200SD/1 | Z/227 | 3.1 | +4.777 | +5.091 | 79
PLATE | C150SD/1 | Z/220 | 2.5 | +4.777 | +5.080 | 67

# IfcMechanicalFastener: Bolt assembly (761)
In: Undefined
Tekla Bolt - Location: Site
Name | NominalDiameter (mm) = Washer diameter (mm) = Bolt size (mm) | NominalLength (mm) = Bolt length (mm) | Material = Bolt standard | Washer count | Washer type | Washer name | Nut count = Bolt count | Nut type | Nut name | Slotted hole y (mm) | Slotted hole x (mm) | Bolt hole diameter (mm) | Bolt Name
16 x Bolt assembly | 12 | 35 | 8.8S | 4 | HARD | WASHERM12-HARD | 4 | 8.8-HEX | NUTM12-8.8-HEX | 8 | 4 | 14 | BOLTM12*35
4 x Bolt assembly | 12 | 100 | PB1230 | 4 | FLAT | WASHERM12-FLAT | 4 | 4.6-HEX | NUTM12-4.6-HEX | 4 | 8 | 14
153 x Bolt assembly | 12 | 30 | PB1230 | 4 | FLAT | WASHERM12-FLAT | 4 | 4.6-HEX | NUTM12-4.6-HEX | 4 | 8 | 14 | BOLTPB1230
8 x Bolt assembly | 12 | 35 | 8.8S | 4 | HARD | WASHERM12-HARD | 4 | 8.8-HEX | NUTM12-8.8-HEX | 4 | 8 | 14 | BOLTM12*35
2 x Bolt assembly | 16 | 45 | 8.8S | 4 | HARD | WASHERM16-HARD | 4 | 8.8-HEX | NUTM16-8.8-HEX | 4 | 0 | 18 | BOLTM16*45
2 x Bolt assembly | 16 | 45 | 8.8S | 4 | HARD | WASHERM16-HARD | 4 | 8.8-HEX | NUTM16-8.8-HEX | 0 | 4 | 18 | BOLTM16*45
8 x Bolt assembly | 16 | 45 | 8.8S | 6 | HARD | WASHERM16-HARD | 6 | 8.8-HEX | NUTM16-8.8-HEX | 4 | 0 | 18 | BOLTM16*45
4 x Bolt assembly | 16 | 45 | 8.8S | 6 | HARD | WASHERM16-HARD | 6 | 8.8-HEX | NUTM16-8.8-HEX | 0 | 4 | 18 | BOLTM16*45
136 x Bolt assembly | 5 | 25 | TEK_16TPIM | 8 | UNDEF_WASH | UNDEFINED_WASHER5 | 2 | UNDEF_NUT | UNDEFINED_NUTM5 | 0 | 0 | 7 | TEKSCREW_M5*25
68 x Bolt assembly | 5 | 25 | TEK_16TPIM | 16 | UNDEF_WASH | UNDEFINED_WASHER5 | 4 | UNDEF_NUT | UNDEFINED_NUTM5 | 0 | 0 | 7 | TEKSCREW_M5*25
150 x Bolt assembly | 12 | 30 | PB1230 | 4 | FLAT | WASHERM12-FLAT | 4 | 4.6-HEX | NUTM12-4.6-HEX | 4 | 0 | 18 | BOLTPB1230
26 x Bolt assembly | 12 | 30 | 8.8S | 4 | HARD | WASHERM12-HARD | 4 | 8.8-HEX | NUTM12-8.8-HEX | 8 | 4 | 14 | BOLTM12*30
4 x Bolt assembly | 16 | 35 | 8.8S | 4 | HARD | WASHERM16-HARD | 4 | 8.8-HEX | NUTM16-8.8-HEX | 4 | 0 | 18 | BOLTM16*35
64 x Bolt assembly | 5 | 11.6 | TEK_16TPIM | 4 | UNDEF_WASH | UNDEFINED_WASHER5 | 2 | UNDEF_NUT | UNDEFINED_NUTM5 | 0 | 0 | 7 | TEKSCREW_M5*25
32 x Bolt assembly | 5 | 11.6 | TEK_16TPIM | 8 | UNDEF_WASH | UNDEFINED_WASHER5 | 4 | UNDEF_NUT | UNDEFINED_NUTM5 | 0 | 0 | 7 | TEKSCREW_M5*25
12 x Bolt assembly | 12 | 30 | 8.8S | 4 | HARD | WASHERM12-HARD | 4 | 8.8-HEX | NUTM12-8.8-HEX | 4 | 8 | 14 | BOLTM12*30
36 x Bolt assembly | 16 | 40 | 8.8S | 6 | HARD | WASHERM16-HARD | 6 | 8.8-HEX | NUTM16-8.8-HEX | 0 | 0 | 18 | BOLTM16*40
18 x Bolt assembly | 16 | 35 | 8.8S | 4 | HARD | WASHERM16-HARD | 4 | 8.8-HEX | NUTM16-8.8-HEX | 0 | 0 | 18 | BOLTM16*35
12 x Bolt assembly | 16 | 45 | 8.8S | 6 | HARD | WASHERM16-HARD | 6 | 8.8-HEX | NUTM16-8.8-HEX | 0 | 0 | 18 | BOLTM16*45
6 x Bolt assembly | 16 | 45 | 8.8S | 4 | HARD | WASHERM16-HARD | 4 | 8.8-HEX | NUTM16-8.8-HEX | 0 | 0 | 18 | BOLTM16*45

# IfcMember: C:150-19 (100)
In: Undefined
Description: C:150-19; Material: STEEL/G450
Tekla Common - Phase: 1; Class: 5
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 152 mm; Width: 64 mm
Pset_MemberCommon - LoadBearing: no
BaseQuantities - GrossSurfaceArea: 0 m2; CrossSectionArea: 0.000561 m2
Name | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | GrossVolume (m3) | NetWeight (kg) | GrossWeight (kg)
BHR-12-150 | +4.093 | +5.198 | 6.2 | 139.7 | 0.9 | 1410.7 | Z/2471 | 1410.75 | 0.868207 | 0.000818602 | 0.000791431 | 6.42602 | 6.21273
BHL-12-150 | +4.093 | +5.198 | 6.2 | 139.7 | 0.9 | 1410.7 | Z/2464 | 1410.75 | 0.868207 | 0.000818602 | 0.000791431 | 6.42602 | 6.21273
BHR-12-200 | +4.034 | +5.186 | 6.5 | 139.7 | 0.9 | 1477.7 | Z/2530 | 1477.66 | 0.909328 | 0.000857425 | 0.000828966 | 6.73079 | 6.50738
BHL-12-200 | +4.034 | +5.186 | 6.5 | 139.7 | 0.9 | 1477.7 | Z/2528 | 1477.66 | 0.909328 | 0.000857425 | 0.000828966 | 6.73079 | 6.50738
BHR-12-250 | +3.964 | +5.174 | 6.9 | 139.7 | 0.9 | 1559.6 | Z/2543 | 1559.55 | 0.959662 | 0.000904946 | 0.000874909 | 7.10383 | 6.86804
BHL-12-250 | +3.964 | +5.174 | 6.9 | 139.7 | 0.9 | 1559.6 | Z/2541 | 1559.55 | 0.959662 | 0.000904946 | 0.000874909 | 7.10383 | 6.86804
BHR-12-300 | +3.892 | +5.164 | 7.3 | 139.7 | 0.9 | 1647.3 | Z/2558 | 1647.34 | 1.01361 | 0.000955885 | 0.000924157 | 7.50369 | 7.25463
BHL-12-300 | +3.892 | +5.164 | 7.3 | 139.7 | 0.9 | 1647.3 | Z/2551 | 1647.34 | 1.01361 | 0.000955883 | 0.000924156 | 7.50368 | 7.25462
2 x BHR-12-350 | +3.816 | +5.174 | 7.8 | 139.7 | 1.1 | 1768.8 | Z/2561 | 1768.75 | 1.08824 | 0.00102634 | 0.000992271 | 8.05675 | 7.78933
BHL-12-350 | +3.816 | +5.174 | 7.8 | 139.7 | 1.1 | 1768.8 | Z/2566 | 1768.75 | 1.08824 | 0.00102634 | 0.000992271 | 8.05675 | 7.78933
BHR-12-300 | +3.892 | +5.164 | 7.3 | 139.7 | 0.9 | 1647.3 | Z/2546 | 1647.34 | 1.01361 | 0.000955885 | 0.000924157 | 7.50369 | 7.25463
BHR-12-250 | +3.964 | +5.174 | 6.9 | 139.7 | 0.9 | 1559.6 | Z/2536 | 1559.55 | 0.959662 | 0.000904946 | 0.000874909 | 7.10383 | 6.86804
BHR-12-200 | +4.034 | +5.186 | 6.5 | 139.7 | 0.9 | 1477.7 | Z/2523 | 1477.66 | 0.909328 | 0.000857425 | 0.000828966 | 6.73079 | 6.50738
BHR-12-150 | +4.093 | +5.198 | 6.2 | 139.7 | 0.9 | 1410.7 | Z/2448 | 1410.75 | 0.868207 | 0.000818602 | 0.000791431 | 6.42602 | 6.21273
BHL-12-350 | +3.816 | +5.174 | 7.8 | 139.7 | 1.1 | 1768.8 | Z/2559 | 1768.75 | 1.08824 | 0.00102634 | 0.000992271 | 8.05675 | 7.78933
BHL-12-300 | +3.892 | +5.164 | 7.3 | 139.7 | 0.9 | 1647.3 | Z/2544 | 1647.34 | 1.01361 | 0.000955883 | 0.000924156 | 7.50368 | 7.25462
BHL-12-250 | +3.964 | +5.174 | 6.9 | 139.7 | 0.9 | 1559.6 | Z/2534 | 1559.55 | 0.959662 | 0.000904946 | 0.000874909 | 7.10383 | 6.86804
BHL-12-200 | +4.034 | +5.186 | 6.5 | 139.7 | 0.9 | 1477.7 | Z/2521 | 1477.66 | 0.909328 | 0.000857425 | 0.000828966 | 6.73079 | 6.50738
BHL-12-150 | +4.093 | +5.198 | 6.2 | 139.7 | 0.9 | 1410.7 | Z/2434 | 1410.75 | 0.868207 | 0.000818602 | 0.000791431 | 6.42602 | 6.21273
BHL-25-350 | +3.886 | +5.691 | 10.6 | 116 | 1.2 | 2400 | Z/1426 | 2400 | 1.22558 | 0.00115389 | 0.0013464 | 9.05803 | 10.5692
BHL-18-350 | +3.886 | +5.337 | 8.4 | 113.5 | 0.9 | 1900 | Z/1423 | 1900 | 0.949759 | 0.000893866 | 0.0010659 | 7.01685 | 8.36732
BHL-15-350 | +3.886 | +5.266 | 7.8 | 111.3 | 0.9 | 1800 | Z/1420 | 1800 | 0.882185 | 0.00083009 | 0.0010098 | 6.51621 | 7.92693
BHL-12-350 | +3.816 | +5.196 | 7.8 | 112.2 | 0.9 | 1800 | Z/1417 | 1800 | 0.889552 | 0.00083713 | 0.0010098 | 6.57147 | 7.92693
BHL-25-350 | +3.886 | +5.691 | 10.6 | 116 | 1.2 | 2400 | Z/1424 | 2400 | 1.22558 | 0.00115388 | 0.0013464 | 9.05799 | 10.5692
BHL-18-350 | +3.886 | +5.337 | 8.4 | 113.5 | 0.9 | 1900 | Z/1421 | 1900 | 0.949759 | 0.000893862 | 0.0010659 | 7.01681 | 8.36732
BHL-15-350 | +3.886 | +5.266 | 7.8 | 111.3 | 0.9 | 1800 | Z/1418 | 1800 | 0.882185 | 0.000830091 | 0.0010098 | 6.51621 | 7.92693
2 x BHL-12-350 | +3.816 | +5.196 | 7.8 | 112.2 | 0.9 | 1800 | Z/1416 | 1800 | 0.889552 | 0.000837127 | 0.0010098 | 6.57145 | 7.92693
BHL-25-300 | +3.999 | +5.662 | 9.7 | 116.3 | 1.1 | 2200 | Z/1353 | 2200 | 1.12693 | 0.0010609 | 0.0012342 | 8.32808 | 9.68847
BHL-18-300 | +3.969 | +5.349 | 7.8 | 115 | 0.9 | 1800 | Z/1350 | 1800 | 0.911815 | 0.000858179 | 0.0010098 | 6.7367 | 7.92693
BHL-15-300 | +3.962 | +5.272 | 7.5 | 113.6 | 0.9 | 1700 | Z/1347 | 1700 | 0.850157 | 0.000800021 | 0.0009537 | 6.28017 | 7.48655
BHL-12-300 | +3.892 | +5.202 | 7.5 | 114.7 | 0.9 | 1700 | Z/630 | 1700 | 0.858776 | 0.000808254 | 0.0009537 | 6.34479 | 7.48655
BHL-25-300 | +3.999 | +5.662 | 9.7 | 116.3 | 1.1 | 2200 | Z/1351 | 2200 | 1.12693 | 0.00106091 | 0.0012342 | 8.32812 | 9.68847
BHL-18-300 | +3.969 | +5.349 | 7.8 | 115 | 0.9 | 1800 | Z/1348 | 1800 | 0.911815 | 0.000858176 | 0.0010098 | 6.73668 | 7.92693
BHL-15-300 | +3.962 | +5.272 | 7.5 | 113.6 | 0.9 | 1700 | Z/1345 | 1700 | 0.850157 | 0.000800018 | 0.0009537 | 6.28014 | 7.48655
BHL-12-300 | +3.892 | +5.202 | 7.5 | 114.7 | 0.9 | 1700 | Z/620 | 1700 | 0.858776 | 0.000808251 | 0.0009537 | 6.34477 | 7.48655
BHL-25-250 | +4.151 | +5.602 | 8.4 | 115.1 | 0.9 | 1900 | Z/1286 | 1900 | 0.963083 | 0.000906324 | 0.0010659 | 7.11464 | 8.36732
BHL-18-250 | +4.111 | +5.350 | 6.9 | 113.9 | 0.7 | 1600 | Z/1283 | 1600 | 0.802802 | 0.000755336 | 0.0008976 | 5.92939 | 7.04616
BHL-15-250 | +4.044 | +5.283 | 6.9 | 115.3 | 0.7 | 1600 | Z/1280 | 1600 | 0.812291 | 0.000764403 | 0.0008976 | 6.00057 | 7.04616
BHL-12-250 | +3.964 | +5.203 | 6.9 | 117.5 | 0.7 | 1600 | Z/592 | 1600 | 0.827996 | 0.000779368 | 0.0008976 | 6.11804 | 7.04616
BHL-25-250 | +4.151 | +5.602 | 8.4 | 115.1 | 0.9 | 1900 | Z/1284 | 1900 | 0.963083 | 0.000906335 | 0.0010659 | 7.11473 | 8.36732
BHL-18-250 | +4.111 | +5.350 | 6.9 | 113.9 | 0.7 | 1600 | Z/1281 | 1600 | 0.802802 | 0.000755336 | 0.0008976 | 5.92939 | 7.04616
BHL-15-250 | +4.044 | +5.283 | 6.9 | 115.3 | 0.7 | 1600 | Z/1278 | 1600 | 0.812291 | 0.000764401 | 0.0008976 | 6.00055 | 7.04616
BHL-12-250 | +3.964 | +5.203 | 6.9 | 117.5 | 0.7 | 1600 | Z/581 | 1600 | 0.827996 | 0.000779366 | 0.0008976 | 6.11803 | 7.04616
BHL-25-200 | +4.247 | +5.556 | 7.5 | 116.7 | 0.9 | 1700 | Z/1220 | 1700 | 0.873234 | 0.000821679 | 0.0009537 | 6.45018 | 7.48655
BHL-18-200 | +4.167 | +5.349 | 6.7 | 117.2 | 0.7 | 1520 | Z/1217 | 1520 | 0.784447 | 0.000738187 | 0.00085272 | 5.79477 | 6.69385
BHL-15-200 | +4.104 | +5.286 | 6.7 | 118.4 | 0.7 | 1520 | Z/1214 | 1520 | 0.792294 | 0.000745699 | 0.00085272 | 5.85374 | 6.69385
BHL-12-200 | +4.034 | +5.216 | 6.7 | 122.3 | 0.7 | 1520 | Z/1012 | 1520 | 0.818745 | 0.000763589 | 0.00085272 | 5.99417 | 6.69385
BHL-25-200 | +4.247 | +5.556 | 7.5 | 116.7 | 0.9 | 1700 | Z/1218 | 1700 | 0.873234 | 0.000821679 | 0.0009537 | 6.45018 | 7.48655
BHL-18-200 | +4.167 | +5.349 | 6.7 | 117.2 | 0.7 | 1520 | Z/1215 | 1520 | 0.784447 | 0.000738187 | 0.00085272 | 5.79477 | 6.69385
BHL-15-200 | +4.104 | +5.286 | 6.7 | 118.4 | 0.7 | 1520 | Z/1212 | 1520 | 0.792307 | 0.000745706 | 0.00085272 | 5.85379 | 6.69385
BHL-12-200 | +4.034 | +5.216 | 6.7 | 122.3 | 0.7 | 1520 | Z/1211 | 1520 | 0.818745 | 0.000763587 | 0.00085272 | 5.99416 | 6.69385
BHL-25-150 | +4.297 | +5.536 | 6.9 | 119.5 | 0.7 | 1600 | Z/1159 | 1600 | 0.841714 | 0.000792097 | 0.0008976 | 6.21796 | 7.04616
BHL-25-150 | +4.297 | +5.536 | 6.9 | 119.5 | 0.7 | 1600 | Z/1157 | 1600 | 0.841714 | 0.000792097 | 0.0008976 | 6.21796 | 7.04616
BHL-18-150 | +4.207 | +5.354 | 6.5 | 120.1 | 0.7 | 1470 | Z/1156 | 1470 | 0.777829 | 0.000732084 | 0.00082467 | 5.74686 | 6.47366
BHL-18-150 | +4.207 | +5.354 | 6.5 | 120.1 | 0.7 | 1470 | Z/1154 | 1470 | 0.777829 | 0.000732091 | 0.00082467 | 5.74691 | 6.47366
BHL-15-150 | +4.150 | +5.297 | 6.5 | 120.8 | 0.7 | 1470 | Z/1153 | 1470 | 0.782691 | 0.000736756 | 0.00082467 | 5.78354 | 6.47366
BHL-15-150 | +4.150 | +5.297 | 6.5 | 120.8 | 0.7 | 1470 | Z/1108 | 1470 | 0.782691 | 0.000736756 | 0.00082467 | 5.78354 | 6.47366
BHL-12-150 | +4.093 | +5.240 | 6.5 | 121.7 | 0.7 | 1470 | Z/1144 | 1470 | 0.787976 | 0.000741822 | 0.00082467 | 5.8233 | 6.47366
2 x BHL-12-150 | +4.093 | +5.240 | 6.5 | 121.7 | 0.7 | 1470 | Z/1142 | 1470 | 0.787976 | 0.000741822 | 0.00082467 | 5.8233 | 6.47366
BHL-25-350 | +3.886 | +5.691 | 10.6 | 116 | 1.2 | 2400 | Z/1454 | 2400 | 1.22558 | 0.00115388 | 0.0013464 | 9.05799 | 10.5692
BHL-18-350 | +3.886 | +5.337 | 8.4 | 113.5 | 0.9 | 1900 | Z/1453 | 1900 | 0.949759 | 0.000893862 | 0.0010659 | 7.01681 | 8.36732
BHL-15-350 | +3.886 | +5.266 | 7.8 | 111.3 | 0.9 | 1800 | Z/1452 | 1800 | 0.882185 | 0.000830087 | 0.0010098 | 6.51619 | 7.92693
BHL-25-300 | +3.999 | +5.662 | 9.7 | 116.3 | 1.1 | 2200 | Z/1381 | 2200 | 1.12693 | 0.0010609 | 0.0012342 | 8.32805 | 9.68847
BHL-18-300 | +3.969 | +5.349 | 7.8 | 115 | 0.9 | 1800 | Z/1380 | 1800 | 0.911815 | 0.000858176 | 0.0010098 | 6.73668 | 7.92693
BHL-15-300 | +3.962 | +5.272 | 7.5 | 113.6 | 0.9 | 1700 | Z/1379 | 1700 | 0.850157 | 0.000800018 | 0.0009537 | 6.28014 | 7.48655
BHL-12-300 | +3.892 | +5.202 | 7.5 | 114.7 | 0.9 | 1700 | Z/620 | 1700 | 0.858776 | 0.000808251 | 0.0009537 | 6.34477 | 7.48654
BHL-25-250 | +4.151 | +5.602 | 8.4 | 115.1 | 0.9 | 1900 | Z/1310 | 1900 | 0.963082 | 0.000906325 | 0.0010659 | 7.11466 | 8.36731
BHL-18-250 | +4.111 | +5.350 | 6.9 | 113.9 | 0.7 | 1600 | Z/1309 | 1600 | 0.802802 | 0.000755336 | 0.0008976 | 5.92939 | 7.04616
BHL-15-250 | +4.044 | +5.283 | 6.9 | 115.3 | 0.7 | 1600 | Z/1308 | 1600 | 0.812292 | 0.000764419 | 0.0008976 | 6.00069 | 7.04616
BHL-12-250 | +3.964 | +5.203 | 6.9 | 117.5 | 0.7 | 1600 | Z/581 | 1600 | 0.827996 | 0.000779387 | 0.0008976 | 6.11819 | 7.04616
BHL-25-200 | +4.247 | +5.556 | 7.5 | 116.7 | 0.9 | 1700 | Z/1242 | 1700 | 0.873234 | 0.000821697 | 0.0009537 | 6.45032 | 7.48654
BHL-18-200 | +4.167 | +5.349 | 6.7 | 117.2 | 0.7 | 1520 | Z/1241 | 1520 | 0.784447 | 0.000738188 | 0.00085272 | 5.79477 | 6.69385
BHL-15-200 | +4.104 | +5.286 | 6.7 | 118.4 | 0.7 | 1520 | Z/1240 | 1520 | 0.792307 | 0.000745724 | 0.00085272 | 5.85393 | 6.69385
BHL-12-200 | +4.034 | +5.216 | 6.7 | 122.3 | 0.7 | 1520 | Z/1211 | 1520 | 0.818745 | 0.000763608 | 0.00085272 | 5.99432 | 6.69385
BHL-25-150 | +4.297 | +5.536 | 6.9 | 119.5 | 0.7 | 1600 | Z/1177 | 1600 | 0.841715 | 0.000792115 | 0.0008976 | 6.2181 | 7.04616
BHL-18-150 | +4.207 | +5.354 | 6.5 | 120.1 | 0.7 | 1470 | Z/1176 | 1470 | 0.777829 | 0.000732084 | 0.00082467 | 5.74686 | 6.47366
BHL-15-150 | +4.150 | +5.297 | 6.5 | 120.8 | 0.7 | 1470 | Z/1175 | 1470 | 0.782691 | 0.000736756 | 0.00082467 | 5.78354 | 6.47366
BHL-25-350 | +3.886 | +5.691 | 10.6 | 116 | 1.2 | 2400 | Z/1106 | 2400 | 1.22558 | 0.00115389 | 0.0013464 | 9.05806 | 10.5692
BHL-25-300 | +3.999 | +5.662 | 9.7 | 116.3 | 1.1 | 2200 | Z/1079 | 2200 | 1.12693 | 0.00106088 | 0.0012342 | 8.32794 | 9.68847
BHL-25-250 | +4.151 | +5.602 | 8.4 | 115.1 | 0.9 | 1900 | Z/1048 | 1900 | 0.963082 | 0.000906295 | 0.0010659 | 7.11441 | 8.36732
BHL-25-200 | +4.247 | +5.556 | 7.5 | 116.7 | 0.9 | 1700 | Z/1021 | 1700 | 0.873234 | 0.000821679 | 0.0009537 | 6.45018 | 7.48655
BHL-25-150 | +4.297 | +5.536 | 6.9 | 119.5 | 0.7 | 1600 | Z/280 | 1600 | 0.841714 | 0.000792096 | 0.0008976 | 6.21796 | 7.04616
BHL-18-350 | +3.886 | +5.337 | 8.4 | 113.5 | 0.9 | 1900 | Z/1103 | 1900 | 0.949759 | 0.000893873 | 0.0010659 | 7.0169 | 8.36732
BHL-18-300 | +3.969 | +5.349 | 7.8 | 115 | 0.9 | 1800 | Z/1076 | 1800 | 0.911815 | 0.000858185 | 0.0010098 | 6.73675 | 7.92693
BHL-18-250 | +4.111 | +5.350 | 6.9 | 113.9 | 0.7 | 1600 | Z/1045 | 1600 | 0.802802 | 0.000755336 | 0.0008976 | 5.92939 | 7.04616
BHL-18-200 | +4.167 | +5.349 | 6.7 | 117.2 | 0.7 | 1520 | Z/1018 | 1520 | 0.784447 | 0.000738188 | 0.00085272 | 5.79477 | 6.69385
BHL-18-150 | +4.207 | +5.354 | 6.5 | 120.1 | 0.7 | 1470 | Z/205 | 1470 | 0.777829 | 0.000732064 | 0.00082467 | 5.7467 | 6.47366
BHL-15-350 | +3.886 | +5.266 | 7.8 | 111.3 | 0.9 | 1800 | Z/1100 | 1800 | 0.882185 | 0.000830084 | 0.0010098 | 6.51616 | 7.92693
BHL-15-300 | +3.962 | +5.272 | 7.5 | 113.6 | 0.9 | 1700 | Z/1073 | 1700 | 0.850157 | 0.000800027 | 0.0009537 | 6.28022 | 7.48654
BHL-15-250 | +4.044 | +5.283 | 6.9 | 115.3 | 0.7 | 1600 | Z/1042 | 1600 | 0.812291 | 0.000764405 | 0.0008976 | 6.00058 | 7.04616
BHL-15-200 | +4.104 | +5.286 | 6.7 | 118.4 | 0.7 | 1520 | Z/1015 | 1520 | 0.792307 | 0.000745709 | 0.00085272 | 5.85381 | 6.69385
BHL-15-150 | +4.150 | +5.297 | 6.5 | 120.8 | 0.7 | 1470 | Z/57 | 1470 | 0.782691 | 0.000736756 | 0.00082467 | 5.78354 | 6.47366
BHL-12-350 | +3.816 | +5.196 | 7.8 | 112.2 | 0.9 | 1800 | Z/1097 | 1800 | 0.889552 | 0.000837133 | 0.0010098 | 6.57149 | 7.92693
BHL-12-300 | +3.892 | +5.202 | 7.5 | 114.7 | 0.9 | 1700 | Z/1070 | 1700 | 0.858776 | 0.00080826 | 0.0009537 | 6.34484 | 7.48654
BHL-12-250 | +3.964 | +5.203 | 6.9 | 117.5 | 0.7 | 1600 | Z/1039 | 1600 | 0.827996 | 0.00077937 | 0.0008976 | 6.11805 | 7.04616
BHL-12-200 | +4.034 | +5.216 | 6.7 | 122.3 | 0.7 | 1520 | Z/1012 | 1520 | 0.818745 | 0.00076359 | 0.00085272 | 5.99418 | 6.69385
BHL-12-150 | +4.093 | +5.240 | 6.5 | 121.7 | 0.7 | 1470 | Z/22 | 1470 | 0.787976 | 0.000741822 | 0.00082467 | 5.8233 | 6.47366

# IfcMember: C:150-24 (4)
In: Undefined
Description: C:150-24; Material: STEEL/G450
Tekla Common - Finish: 25 deg; Bottom elevation: +4.937; Top elevation: +6.868; Phase: 1; Class: 1
Tekla Quantity - Weight: 23.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 111.2 m2; Net surface area: 2.6 m2; Height: 152 mm; Width: 64 mm; Length: 4242.2 mm
Pset_MemberCommon - LoadBearing: no
BaseQuantities - Length: 4242.22 mm; OuterSurfaceArea: 2.62996 m2; GrossSurfaceArea: 0 m2; CrossSectionArea: 0.00071 m2; NetVolume: 0.00312974 m3; GrossVolume: 0.00301198 m3; NetWeight: 24.5685 kg; GrossWeight: 23.644 kg
Name | Reference
2 x RAFTER | Z/1023
2 x RAFTER | Z/93

# IfcMember: C:200-24 (4)
In: Undefined
Description: C:200-24; Material: STEEL/G450
Tekla Common - Finish: 25 deg; Bottom elevation: +4.915; Top elevation: +6.870; Phase: 1; Class: 1
Tekla Quantity - Weight: 29.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 110 m2; Net surface area: 3.3 m2; Height: 203 mm; Width: 76 mm; Length: 4190.3 mm
Pset_MemberCommon - LoadBearing: no
BaseQuantities - Length: 4190.31 mm; OuterSurfaceArea: 3.26862 m2; GrossSurfaceArea: 0 m2; CrossSectionArea: 0.000903 m2; NetVolume: 0.00389598 m3; GrossVolume: 0.00378385 m3; NetWeight: 30.5835 kg; GrossWeight: 29.7032 kg
Name | Reference
2 x RAFTER | Z/1199
2 x RAFTER | Z/5

# IfcMember: C:250-24 (4)
In: Undefined
Description: C:250-24; Material: STEEL/G450
Tekla Common - Finish: 25 deg; Bottom elevation: +4.892; Top elevation: +6.872; Phase: 1; Class: 1
Tekla Quantity - Weight: 33.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 109.7 m2; Net surface area: 3.6 m2; Height: 254 mm; Width: 76 mm; Length: 4138.4 mm
Pset_MemberCommon - LoadBearing: no
BaseQuantities - Length: 4138.39 mm; OuterSurfaceArea: 3.64222 m2; GrossSurfaceArea: 0 m2; CrossSectionArea: 0.001022 m2; NetVolume: 0.00434431 m3; GrossVolume: 0.00422943 m3; NetWeight: 34.1029 kg; GrossWeight: 33.201 kg
Name | Reference
2 x RAFTER | Z/1266
2 x RAFTER | Z/131

# IfcMember: C:300-30 (4)
In: Undefined
Description: C:300-30; Material: STEEL/G450
Tekla Common - Finish: 25 deg; Bottom elevation: +4.873; Top elevation: +6.874; Phase: 1; Class: 1
Tekla Quantity - Weight: 51.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.4 m2; Net surface area: 4.5 m2; Height: 300 mm; Width: 96 mm; Length: 4091.6 mm
Pset_MemberCommon - LoadBearing: no
BaseQuantities - Length: 4091.56 mm; OuterSurfaceArea: 4.47124 m2; GrossSurfaceArea: 0 m2; CrossSectionArea: 0.001593 m2; NetVolume: 0.00666515 m3; GrossVolume: 0.00651785 m3; NetWeight: 52.3214 kg; GrossWeight: 51.1651 kg
Name | Reference
2 x RAFTER | Z/1333
2 x RAFTER | Z/150

# IfcMember: C:350-30 (4)
In: Undefined
Description: C:350-30; Material: STEEL/G450
Tekla Common - Finish: 25 deg; Bottom elevation: +4.851; Top elevation: +6.876; Phase: 1; Class: 1
Tekla Quantity - Weight: 60.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.1 m2; Net surface area: 5.3 m2; Height: 350 mm; Width: 125 mm; Length: 4040.7 mm
Pset_MemberCommon - LoadBearing: no
BaseQuantities - Length: 4040.66 mm; OuterSurfaceArea: 5.26483 m2; GrossSurfaceArea: 0 m2; CrossSectionArea: 0.001905 m2; NetVolume: 0.00785504 m3; GrossVolume: 0.00769746 m3; NetWeight: 61.6621 kg; GrossWeight: 60.425 kg
Name | Reference
2 x RAFTER | Z/1404
2 x RAFTER | Z/170

# IfcPlate: PLT3*238.6 (16)
In: Undefined
Description: PLT3*238.6; Material: STEEL/250
Tekla Common - Phase: 1; Class: 2
Tekla Quantity - Weight: 2.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87 m2; Net surface area: 0.2 m2; Height: 238.6 mm; Width: 3 mm; Length: 400 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 238.596 mm; NetArea: 0.198176 m2; GrossArea: 0.0954382 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000290091 m3; GrossVolume: 0.000290091 m3
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation
4 x STIFFINER SLEEVE | PL/147 | +4.979 | +5.192
2 x STIFFINER SLEEVE | PL/1638 | +4.073 | +4.473
2 x STIFFINER SLEEVE | PL/147 | +4.073 | +4.473
4 x STIFFINER SLEEVE | Z/1004 | +5.005 | +5.231
4 x STIFFINER SLEEVE | Z/1004 | +4.073 | +4.473

# IfcPlate: PLT3*283.3 (2)
In: Undefined
Description: PLT3*283.3; Material: STEEL/450
Tekla Common - Bottom elevation: +5.524; Top elevation: +5.719; Phase: 1; Class: 11
Tekla Quantity - Weight: 2.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.7 m2; Net surface area: 0.2 m2; Height: 283.3 mm; Width: 3 mm; Length: 422.1 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 283.291 mm; NetArea: 0.187944 m2; GrossArea: 0.119564 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000276113 m3; GrossVolume: 0.000276113 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1645
PLATE | PL/1650

# IfcPlate: PLT3*294.7 (2)
In: Undefined
Description: PLT3*294.7; Material: STEEL/450
Default - ASSEMBLY_POS: Z/182
Tekla Common - Bottom elevation: +5.664; Top elevation: +5.866; Phase: 1; Class: 11
Tekla Quantity - Weight: 2.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.7 m2; Net surface area: 0.2 m2; Height: 294.7 mm; Width: 3 mm; Length: 429.3 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/182
BaseQuantities - Width: 294.722 mm; NetArea: 0.191471 m2; GrossArea: 0.126531 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000281369 m3; GrossVolume: 0.000281369 m3

# IfcPlate: PLT3*308.7 (4)
In: Undefined
Description: PLT3*308.7; Material: STEEL/450
Tekla Common - Bottom elevation: +4.777; Top elevation: +5.080; Phase: 1; Class: 11
Tekla Quantity - Weight: 2.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.7 m2; Net surface area: 0.2 m2; Height: 308.7 mm; Width: 3 mm; Length: 451.2 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - NetArea: 0.216526 m2; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Width (mm) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
2 x PLATE | Z/220 | 308.662 | 0.139258 | 0.000318536
2 x PLATE | Z/1000 | 308.673 | 0.139264 | 0.000318537

# IfcPlate: PLT3*311 (2)
In: Undefined
Description: PLT3*311; Material: STEEL/450
Tekla Common - Bottom elevation: +5.878; Top elevation: +6.092; Phase: 1; Class: 11
Tekla Quantity - Weight: 2.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.7 m2; Net surface area: 0.2 m2; Height: 311 mm; Width: 3 mm; Length: 438.1 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 310.983 mm; NetArea: 0.196562 m2; GrossArea: 0.136236 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000288955 m3; GrossVolume: 0.000288955 m3
Name | ASSEMBLY_POS = Reference
PLATE | Z/1160
PLATE | Z/1001

# IfcPlate: PLT3*313.3 (4)
In: Undefined
Description: PLT3*313.3; Material: STEEL/G450
Tekla Common - Bottom elevation: +4.772; Top elevation: +5.067; Phase: 1; Class: 11
Tekla Quantity - Weight: 2.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.7 m2; Net surface area: 0.2 m2; Height: 313.3 mm; Width: 3 mm; Length: 445.2 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 313.286 mm; NetArea: 0.21672 m2; GrossArea: 0.139471 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000318273 m3; GrossVolume: 0.000318273 m3
Name | ASSEMBLY_POS = Reference
PLATE | Z/2453
PLATE | Z/2460
PLATE | Z/2449
PLATE | Z/2459

# IfcPlate: PLT3*313.6 (16)
In: Undefined
Description: PLT3*313.6; Material: STEEL/250
Tekla Common - Phase: 1; Class: 2
Tekla Quantity - Weight: 3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.7 m2; Net surface area: 0.3 m2; Height: 313.6 mm; Width: 3 mm; Length: 400 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 313.596 mm; NetArea: 0.258626 m2; GrossArea: 0.125438 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000380091 m3; GrossVolume: 0.000380091 m3
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation
4 x STIFFINER SLEEVE | PL/148 | +4.940 | +5.203
4 x STIFFINER SLEEVE | PL/148 | +4.023 | +4.423
4 x STIFFINER SLEEVE | Z/527 | +4.968 | +5.243
STIFFINER SLEEVE | Z/1191 | +4.023 | +4.423
3 x STIFFINER SLEEVE | Z/527 | +4.023 | +4.423

# IfcPlate: PLT3*314 (4)
In: Undefined
Description: PLT3*314; Material: STEEL/450
Tekla Common - Bottom elevation: +4.777; Top elevation: +5.100; Phase: 1; Class: 11
Tekla Quantity - Weight: 2.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.7 m2; Net surface area: 0.2 m2; Height: 314 mm; Width: 3 mm; Length: 464.4 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - NetArea: 0.223703 m2; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Width (mm) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
PLATE | Z/1164 | 314.009 | 0.145832 | 0.000329208
PLATE | Z/1163 | 314.03 | 0.145845 | 0.000329214
PLATE | Z/998 | 314.03 | 0.145845 | 0.000329214
PLATE | Z/997 | 314.009 | 0.145832 | 0.000329208

# IfcPlate: PLT3*318.7 (4)
In: Undefined
Description: PLT3*318.7; Material: STEEL/450
Tekla Common - Bottom elevation: +4.777; Top elevation: +5.120; Phase: 1; Class: 11
Tekla Quantity - Weight: 2.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.5 m2; Net surface area: 0.2 m2; Height: 318.7 mm; Width: 3 mm; Length: 477.9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - NetArea: 0.230962 m2; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Width (mm) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
PLATE | Z/1166 | 318.695 | 0.152296 | 0.000339996
PLATE | Z/1165 | 318.742 | 0.152323 | 0.000340008
PLATE | Z/996 | 318.742 | 0.152323 | 0.000340008
PLATE | Z/995 | 318.695 | 0.152296 | 0.000339996

# IfcPlate: PLT3*326 (2)
In: Undefined
Description: PLT3*326; Material: STEEL/450
Tekla Common - Bottom elevation: +6.099; Top elevation: +6.324; Phase: 1; Class: 11
Tekla Quantity - Weight: 2.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.7 m2; Net surface area: 0.2 m2; Height: 326 mm; Width: 3 mm; Length: 444.2 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 326.046 mm; NetArea: 0.201426 m2; GrossArea: 0.144845 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000296202 m3; GrossVolume: 0.000296202 m3
Name | ASSEMBLY_POS = Reference
PLATE | Z/1161
PLATE | Z/1002

# IfcPlate: PLT3*327 (2)
In: Undefined
Description: PLT3*327; Material: STEEL/450
Tekla Common - Bottom elevation: +4.777; Top elevation: +5.168; Phase: 1; Class: 11
Tekla Quantity - Weight: 3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.5 m2; Net surface area: 0.2 m2; Height: 327 mm; Width: 3.1 mm; Length: 510.2 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 327.001 mm; NetArea: 0.248283 m2; GrossArea: 0.166851 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000365726 m3; GrossVolume: 0.000365726 m3
Name | ASSEMBLY_POS = Reference
PLATE | Z/1168
PLATE | Z/993

# IfcPlate: PLT3*327.1 (2)
In: Undefined
Description: PLT3*327.1; Material: STEEL/450
Tekla Common - Bottom elevation: +4.777; Top elevation: +5.168; Phase: 1; Class: 11
Tekla Quantity - Weight: 3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.5 m2; Net surface area: 0.2 m2; Height: 327.1 mm; Width: 3.1 mm; Length: 510.2 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 327.13 mm; NetArea: 0.248286 m2; GrossArea: 0.166929 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000365749 m3; GrossVolume: 0.000365749 m3
Name | ASSEMBLY_POS = Reference
PLATE | Z/1167
PLATE | Z/994

# IfcPlate: PLT3*332.1 (4)
In: Undefined
Description: PLT3*332.1; Material: STEEL/G450
Tekla Common - Bottom elevation: +4.771; Top elevation: +5.075; Phase: 1; Class: 11
Tekla Quantity - Weight: 3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.7 m2; Net surface area: 0.3 m2; Height: 332.1 mm; Width: 3 mm; Length: 487.7 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 332.119 mm; NetArea: 0.261745 m2; GrossArea: 0.16196 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000385111 m3; GrossVolume: 0.000385111 m3
Name | ASSEMBLY_POS = Reference
PLATE | Z/2525
PLATE | Z/2527
PLATE | Z/2524
PLATE | Z/2526

# IfcPlate: PLT3*333.3 (4)
In: Undefined
Description: PLT3*333.3; Material: STEEL/450
Tekla Common - Bottom elevation: +4.777; Top elevation: +5.091; Phase: 1; Class: 11
Tekla Quantity - Weight: 3.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.3 m2; Height: 333.3 mm; Width: 3 mm; Length: 496.9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - NetArea: 0.266193 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000392276 m3; GrossVolume: 0.000392276 m3
Name | ASSEMBLY_POS = Reference | Width (mm) | GrossArea (m2)
2 x PLATE | Z/227 | 333.291 | 0.165615
2 x PLATE | Z/548 | 333.309 | 0.165626

# IfcPlate: PLT3*340.9 (2)
In: Undefined
Description: PLT3*340.9; Material: STEEL/450
Tekla Common - Bottom elevation: +4.777; Top elevation: +5.114; Phase: 1; Class: 11
Tekla Quantity - Weight: 3.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.3 m2; Height: 340.9 mm; Width: 3.1 mm; Length: 511.9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 340.879 mm; NetArea: 0.276668 m2; GrossArea: 0.174498 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000407881 m3; GrossVolume: 0.000407881 m3
Name | ASSEMBLY_POS = Reference
PLATE | Z/1227
PLATE | Z/1032

# IfcPlate: PLT3*341 (2)
In: Undefined
Description: PLT3*341; Material: STEEL/450
Tekla Common - Bottom elevation: +4.777; Top elevation: +5.114; Phase: 1; Class: 11
Tekla Quantity - Weight: 3.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.3 m2; Height: 340.9 mm; Width: 3.2 mm; Length: 511.9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 341.04 mm; NetArea: 0.276668 m2; GrossArea: 0.174592 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000407881 m3; GrossVolume: 0.000407881 m3
Name | ASSEMBLY_POS = Reference
PLATE | Z/1226
PLATE | Z/1033

# IfcPlate: PLT3*347.8 (2)
In: Undefined
Description: PLT3*347.8; Material: STEEL/450
Tekla Common - Bottom elevation: +4.777; Top elevation: +5.137; Phase: 1; Class: 11
Tekla Quantity - Weight: 3.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.3 m2; Height: 347.8 mm; Width: 3.2 mm; Length: 527.1 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 347.803 mm; NetArea: 0.287435 m2; GrossArea: 0.183329 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000423916 m3; GrossVolume: 0.000423916 m3
Name | ASSEMBLY_POS = Reference
PLATE | Z/1225
PLATE | Z/1034

# IfcPlate: PLT3*348.1 (2)
In: Undefined
Description: PLT3*348.1; Material: STEEL/450
Tekla Common - Bottom elevation: +4.777; Top elevation: +5.137; Phase: 1; Class: 11
Tekla Quantity - Weight: 3.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.3 m2; Height: 348.1 mm; Width: 3.3 mm; Length: 527.2 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 348.096 mm; NetArea: 0.287435 m2; GrossArea: 0.183505 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000423916 m3; GrossVolume: 0.000423916 m3
Name | ASSEMBLY_POS = Reference
PLATE | Z/1224
PLATE | Z/1035

# IfcPlate: PLT3*355.5 (2)
In: Undefined
Description: PLT3*355.5; Material: STEEL/450
Tekla Common - Bottom elevation: +6.646; Top elevation: +6.900; Phase: 1; Class: 11
Tekla Quantity - Weight: 2.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.7 m2; Net surface area: 0.2 m2; Height: 355.5 mm; Width: 3 mm; Length: 448.3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 355.548 mm; NetArea: 0.211784 m2; GrossArea: 0.159386 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000311633 m3; GrossVolume: 0.000311633 m3
Name | ASSEMBLY_POS = Reference
PLATE | Z/1162
PLATE | Z/1003

# IfcPlate: PLT3*359.8 (2)
In: Undefined
Description: PLT3*359.8; Material: STEEL/450
Tekla Common - Bottom elevation: +5.469; Top elevation: +5.723; Phase: 1; Class: 11
Tekla Quantity - Weight: 3.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.3 m2; Height: 359.8 mm; Width: 3 mm; Length: 519.2 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 359.788 mm; NetArea: 0.292934 m2; GrossArea: 0.186786 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000432182 m3; GrossVolume: 0.000432182 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1651
PLATE | PL/1656

# IfcPlate: PLT3*363.8 (4)
In: Undefined
Description: PLT3*363.8; Material: STEEL/450
Tekla Common - Bottom elevation: +4.775; Top elevation: +5.192; Phase: 1; Class: 11
Tekla Quantity - Weight: 3.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.3 m2; Height: 363.8 mm; Width: 3 mm; Length: 564.9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 363.821 mm; NetArea: 0.315463 m2; GrossArea: 0.205516 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00046552 m3; GrossVolume: 0.00046552 m3
Name | ASSEMBLY_POS = Reference
PLATE | Z/1233
PLATE | Z/1232
PLATE | Z/1031
PLATE | Z/1030

# IfcPlate: PLT3*364.6 (16)
In: Undefined
Description: PLT3*364.6; Material: STEEL/250
Tekla Common - Phase: 1; Class: 2
Tekla Quantity - Weight: 3.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.5 m2; Net surface area: 0.3 m2; Height: 364.6 mm; Width: 3 mm; Length: 400 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 364.596 mm; NetArea: 0.299732 m2; GrossArea: 0.145838 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000441291 m3; GrossVolume: 0.000441291 m3
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation
4 x STIFFINER SLEEVE | PL/149 | +4.903 | +5.216
2 x STIFFINER SLEEVE | PL/1648 | +3.983 | +4.383
2 x STIFFINER SLEEVE | PL/149 | +3.983 | +4.383
4 x STIFFINER SLEEVE | Z/566 | +4.934 | +5.259
STIFFINER SLEEVE | Z/1256 | +3.983 | +4.383
3 x STIFFINER SLEEVE | Z/566 | +3.983 | +4.383

# IfcPlate: PLT3*373.7 (2)
In: Undefined
Description: PLT3*373.7; Material: STEEL/450
Default - ASSEMBLY_POS: Z/187
Tekla Common - Bottom elevation: +5.609; Top elevation: +5.872; Phase: 1; Class: 11
Tekla Quantity - Weight: 3.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.3 m2; Height: 373.7 mm; Width: 3 mm; Length: 529.1 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/187
BaseQuantities - Width: 373.729 mm; NetArea: 0.298692 m2; GrossArea: 0.197735 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000440768 m3; GrossVolume: 0.000440768 m3

# IfcPlate: PLT3*393.6 (2)
In: Undefined
Description: PLT3*393.6; Material: STEEL/450
Tekla Common - Bottom elevation: +5.822; Top elevation: +6.099; Phase: 1; Class: 11
Tekla Quantity - Weight: 3.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.3 m2; Height: 393.6 mm; Width: 3 mm; Length: 541.3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 393.583 mm; NetArea: 0.307078 m2; GrossArea: 0.213063 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000453276 m3; GrossVolume: 0.000453276 m3
Name | ASSEMBLY_POS = Reference
PLATE | Z/1221
PLATE | Z/1036

# IfcPlate: PLT3*400 (32)
In: Undefined
Description: PLT3*400; Material: STEEL/250
Tekla Common - Phase: 1; Class: 2
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 400 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 400 mm; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
4 x STIFFINER SLEEVE | PL/150 | +4.873 | +5.230 | 4.2 | 86.3 | 0.3 | 447 | 0.366147 | 0.178798 | 0.000540171
2 x STIFFINER SLEEVE | PL/1655 | +3.888 | +4.288 | 4.2 | 86.3 | 0.3 | 447 | 0.366147 | 0.178798 | 0.000540171
2 x STIFFINER SLEEVE | PL/150 | +3.888 | +4.288 | 4.2 | 86.3 | 0.3 | 447 | 0.366147 | 0.178798 | 0.000540171
4 x STIFFINER SLEEVE | PL/151 | +4.838 | +5.244 | 5.3 | 86.2 | 0.5 | 555 | 0.453195 | 0.221998 | 0.000669771
4 x STIFFINER SLEEVE | PL/151 | +3.808 | +4.208 | 5.3 | 86.2 | 0.5 | 555 | 0.453195 | 0.221998 | 0.000669771
4 x STIFFINER SLEEVE | Z/643 | +4.875 | +5.293 | 5.3 | 86.2 | 0.5 | 555 | 0.453195 | 0.221998 | 0.000669771
4 x STIFFINER SLEEVE | Z/643 | +3.808 | +4.208 | 5.3 | 86.2 | 0.5 | 555 | 0.453195 | 0.221998 | 0.000669771
4 x STIFFINER SLEEVE | Z/608 | +4.907 | +5.276 | 4.2 | 86.3 | 0.3 | 447 | 0.366147 | 0.178798 | 0.000540171
4 x STIFFINER SLEEVE | Z/608 | +3.888 | +4.288 | 4.2 | 86.3 | 0.3 | 447 | 0.366147 | 0.178798 | 0.000540171

# IfcPlate: PLT3*410.8 (2)
In: Undefined
Description: PLT3*410.8; Material: STEEL/450
Default - ASSEMBLY_POS: PL/1657
Tekla Common - Bottom elevation: +5.422; Top elevation: +5.727; Phase: 1; Class: 11
Tekla Quantity - Weight: 4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.2 m2; Net surface area: 0.3 m2; Height: 410.8 mm; Width: 3 mm; Length: 536.6 mm
Pset_PlateCommon - LoadBearing: no; Reference: PL/1657
BaseQuantities - Width: 410.79 mm; NetArea: 0.347447 m2; GrossArea: 0.220441 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00051341 m3; GrossVolume: 0.00051341 m3

# IfcPlate: PLT3*412 (2)
In: Undefined
Description: PLT3*412; Material: STEEL/450
Tekla Common - Bottom elevation: +6.041; Top elevation: +6.332; Phase: 1; Class: 11
Tekla Quantity - Weight: 3.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.3 m2; Height: 412 mm; Width: 3 mm; Length: 550.3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 411.971 mm; NetArea: 0.315115 m2; GrossArea: 0.226702 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000465263 m3; GrossVolume: 0.000465263 m3
Name | ASSEMBLY_POS = Reference
PLATE | Z/1222
PLATE | Z/1037

# IfcPlate: PLT3*424.7 (2)
In: Undefined
Description: PLT3*424.7; Material: STEEL/450
Default - ASSEMBLY_POS: Z/1288
Tekla Common - Bottom elevation: +5.562; Top elevation: +5.877; Phase: 1; Class: 11
Tekla Quantity - Weight: 4.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.2 m2; Net surface area: 0.3 m2; Height: 424.7 mm; Width: 3 mm; Length: 549.8 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/1288
BaseQuantities - Width: 424.728 mm; NetArea: 0.354893 m2; GrossArea: 0.23353 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000524514 m3; GrossVolume: 0.000524514 m3

# IfcPlate: PLT3*426.1 (4)
In: Undefined
Description: PLT3*426.1; Material: STEEL/450
Tekla Common - Bottom elevation: +4.692; Top elevation: +5.119; Phase: 1; Class: 11
Tekla Quantity - Weight: 5.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.2 m2; Net surface area: 0.3 m2; Height: 426.1 mm; Width: 3 mm; Length: 656.1 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - NetArea: 0.449082 m2; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Width (mm) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
2 x PLATE | Z/1289 | 426.082 | 0.27956 | 0.000664572
2 x PLATE | Z/1287 | 426.096 | 0.279571 | 0.000664571

# IfcPlate: PLT3*428.1 (4)
In: Undefined
Description: PLT3*428.1; Material: STEEL/G450
Tekla Common - Bottom elevation: +4.686; Top elevation: +5.099; Phase: 1; Class: 11
Tekla Quantity - Weight: 5.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.2 m2; Net surface area: 0.3 m2; Height: 428.1 mm; Width: 3 mm; Length: 645.3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - NetArea: 0.445095 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000657872 m3; GrossVolume: 0.000657872 m3
Name | ASSEMBLY_POS = Reference | Width (mm) | GrossArea (m2)
PLATE | Z/2538 | 428.068 | 0.276216
PLATE | Z/2540 | 428.066 | 0.276214
PLATE | Z/2537 | 428.066 | 0.276214
PLATE | Z/2539 | 428.068 | 0.276216

# IfcPlate: PLT3*435.4 (2)
In: Undefined
Description: PLT3*435.4; Material: STEEL/450
Tekla Common - Bottom elevation: +4.692; Top elevation: +5.149; Phase: 1; Class: 11
Tekla Quantity - Weight: 5.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.2 m2; Net surface area: 0.5 m2; Height: 435.4 mm; Width: 3 mm; Length: 675.7 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 435.438 mm; NetArea: 0.465321 m2; GrossArea: 0.294207 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000688788 m3; GrossVolume: 0.000688788 m3
Name | ASSEMBLY_POS = Reference
PLATE | Z/1295
PLATE | Z/1062

# IfcPlate: PLT3*435.5 (2)
In: Undefined
Description: PLT3*435.5; Material: STEEL/450
Tekla Common - Bottom elevation: +4.692; Top elevation: +5.149; Phase: 1; Class: 11
Tekla Quantity - Weight: 5.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.2 m2; Net surface area: 0.5 m2; Height: 435.4 mm; Width: 3 mm; Length: 675.7 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 435.459 mm; NetArea: 0.465321 m2; GrossArea: 0.294224 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000688799 m3; GrossVolume: 0.000688799 m3
Name | ASSEMBLY_POS = Reference
PLATE | Z/1294
PLATE | Z/1063

# IfcPlate: PLT3*443.8 (2)
In: Undefined
Description: PLT3*443.8; Material: STEEL/450
Tekla Common - Bottom elevation: +4.692; Top elevation: +5.180; Phase: 1; Class: 11
Tekla Quantity - Weight: 5.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.9 m2; Net surface area: 0.5 m2; Height: 443.8 mm; Width: 3 mm; Length: 695.5 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 443.844 mm; NetArea: 0.48188 m2; GrossArea: 0.308713 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000713477 m3; GrossVolume: 0.000713477 m3
Name | ASSEMBLY_POS = Reference
PLATE | Z/1297
PLATE | Z/1060

# IfcPlate: PLT3*443.9 (2)
In: Undefined
Description: PLT3*443.9; Material: STEEL/450
Tekla Common - Bottom elevation: +4.692; Top elevation: +5.180; Phase: 1; Class: 11
Tekla Quantity - Weight: 5.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.9 m2; Net surface area: 0.5 m2; Height: 443.9 mm; Width: 3 mm; Length: 695.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 443.894 mm; NetArea: 0.481881 m2; GrossArea: 0.308754 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000713497 m3; GrossVolume: 0.000713497 m3
Name | ASSEMBLY_POS = Reference
PLATE | Z/1296
PLATE | Z/1061

# IfcPlate: PLT3*444.6 (2)
In: Undefined
Description: PLT3*444.6; Material: STEEL/450
Tekla Common - Bottom elevation: +5.776; Top elevation: +6.105; Phase: 1; Class: 11
Tekla Quantity - Weight: 4.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.2 m2; Net surface area: 0.3 m2; Height: 444.6 mm; Width: 3 mm; Length: 566.8 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 444.577 mm; NetArea: 0.365885 m2; GrossArea: 0.252 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000540905 m3; GrossVolume: 0.000540905 m3
Name | ASSEMBLY_POS = Reference
PLATE | Z/1290
PLATE | Z/1064

# IfcPlate: PLT3*448.1 (2)
In: Undefined
Description: PLT3*448.1; Material: STEEL/450
Tekla Common - Bottom elevation: +6.585; Top elevation: +6.912; Phase: 1; Class: 11
Tekla Quantity - Weight: 4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.2 m2; Net surface area: 0.3 m2; Height: 448.1 mm; Width: 3 mm; Length: 558.1 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 448.062 mm; NetArea: 0.332573 m2; GrossArea: 0.250076 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000491299 m3; GrossVolume: 0.000491299 m3
Name | ASSEMBLY_POS = Reference
PLATE | Z/1223
PLATE | Z/1038

# IfcPlate: PLT3*459.7 (2)
In: Undefined
Description: PLT3*459.7; Material: STEEL/450
Tekla Common - Bottom elevation: +4.692; Top elevation: +5.252; Phase: 1; Class: 11
Tekla Quantity - Weight: 6.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.9 m2; Net surface area: 0.5 m2; Height: 459.7 mm; Width: 3.1 mm; Length: 743.7 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 459.656 mm; NetArea: 0.521886 m2; GrossArea: 0.341847 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.0007731 m3; GrossVolume: 0.0007731 m3
Name | ASSEMBLY_POS = Reference
PLATE | Z/1299
PLATE | Z/1058

# IfcPlate: PLT3*459.8 (2)
In: Undefined
Description: PLT3*459.8; Material: STEEL/450
Tekla Common - Bottom elevation: +4.692; Top elevation: +5.252; Phase: 1; Class: 11
Tekla Quantity - Weight: 6.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.9 m2; Net surface area: 0.5 m2; Height: 459.7 mm; Width: 3.1 mm; Length: 743.7 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 459.8 mm; NetArea: 0.521888 m2; GrossArea: 0.341971 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000773137 m3; GrossVolume: 0.000773137 m3
Name | ASSEMBLY_POS = Reference
PLATE | Z/1298
PLATE | Z/1059

# IfcPlate: PLT3*463 (2)
In: Undefined
Description: PLT3*463; Material: STEEL/450
Tekla Common - Bottom elevation: +5.996; Top elevation: +6.341; Phase: 1; Class: 11
Tekla Quantity - Weight: 4.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.2 m2; Net surface area: 0.3 m2; Height: 463 mm; Width: 3 mm; Length: 580.3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - NetArea: 0.376626 m2; GrossArea: 0.268651 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000556923 m3; GrossVolume: 0.000556923 m3
Name | ASSEMBLY_POS = Reference | Width (mm)
PLATE | Z/1291 | 462.974
PLATE | Z/1065 | 462.973

# IfcPlate: PLT3*499.1 (2)
In: Undefined
Description: PLT3*499.1; Material: STEEL/450
Tekla Common - Bottom elevation: +6.540; Top elevation: +6.924; Phase: 1; Class: 11
Tekla Quantity - Weight: 4.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.2 m2; Net surface area: 0.3 m2; Height: 499.1 mm; Width: 3 mm; Length: 597.2 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 499.069 mm; NetArea: 0.400777 m2; GrossArea: 0.298047 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000592931 m3; GrossVolume: 0.000592931 m3
Name | ASSEMBLY_POS = Reference
PLATE | Z/1292
PLATE | Z/1066

# IfcPlate: PLT3*544.9 (2)
In: Undefined
Description: PLT3*544.9; Material: STEEL/450
Tekla Common - Bottom elevation: +5.345; Top elevation: +5.732; Phase: 1; Class: 11
Tekla Quantity - Weight: 9.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.9 m2; Net surface area: 0.7 m2; Height: 544.9 mm; Width: 3 mm; Length: 943.7 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 544.889 mm; NetArea: 0.784315 m2; GrossArea: 0.514235 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.0011642 m3; GrossVolume: 0.0011642 m3
Name | ASSEMBLY_POS = Reference
PLATE | PL/1662
PLATE | PL/1667

# IfcPlate: PLT3*565.6 (4)
In: Undefined
Description: PLT3*565.6; Material: STEEL/450
Tekla Common - Bottom elevation: +4.577; Top elevation: +5.153; Phase: 1; Class: 11
Tekla Quantity - Weight: 8.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.9 m2; Net surface area: 0.7 m2; Height: 565.6 mm; Width: 3 mm; Length: 853.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - NetArea: 0.754232 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00111964 m3; GrossVolume: 0.00111964 m3
Name | ASSEMBLY_POS = Reference | Width (mm) | GrossArea (m2)
2 x PLATE | Z/1359 | 565.634 | 0.482802
2 x PLATE | Z/1358 | 565.637 | 0.482806

# IfcPlate: PLT3*566.6 (4)
In: Undefined
Description: PLT3*566.6; Material: STEEL/G450
