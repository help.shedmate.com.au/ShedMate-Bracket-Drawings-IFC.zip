Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView_V2.0, QuantityTakeOffAddOnView], Option [BaseQuantities:On], Option [GridExport:On], Option [Assemblies:On], Option [Bolts:On], Option [Rebars:On], Option [PourObjects:Off], Option [Welds:Off], Option [SurfaceTreatments:Off], Option [LocationBy:0], Option [ViewColors:Off], Option [SectionedSpine:Off], Option [PropertySets:On], Option [Export all:Off]
File name: Mezzanine Brackets.ifc
Time: 2026-10-13T08:41:03
Author: DESKTOP-BKNQL56\admin
Organization: Structural Designer
Written by: IFC Database Version: Work
Made in: Tekla Structures 2019 Service Pack 13, IFC Export Version: 4.0.0.0 Oct 18 2021

# IfcBuildingStorey, Undefined
In: Undefined
Elevation: 0 mm

# IfcBeam: C:150-24 (38)
In: Undefined
Description: C:150-24
Tekla Common - Phase: 1
Tekla Quantity - Volume: 0 m3; Height: 152 mm; Width: 64 mm
Pset_BeamCommon - LoadBearing: no
Name | Material | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Class | Weight (kg) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
BEAM | STEEL/300PLUS | B/135 | +1.848 | +2.000 | 5 | 2.2 | 0 | 111.8 | 0.2 | 390 | 0.24312 | 0.000287726 | 2.25865
BEAM | STEEL/300PLUS | B/134 | +1.848 | +2.000 | 5 | 2.2 | 0 | 111.8 | 0.2 | 390 | 0.24312 | 0.000287726 | 2.25865
JOIST | STEEL/300PLUS | B/13 | +1.848 | +2.000 | 8 | 2 | 0 | 111.8 | 0.2 | 348 | 0.217096 | 0.00025674 | 2.01541
JOIST | STEEL/300PLUS | B/56 | +1.848 | +2.000 | 8 | 2 | 0 | 111.8 | 0.2 | 348 | 0.217096 | 0.00025674 | 2.01541
5 x BEAM | STEEL/300PLUS | B/42 | +1.848 | +2.000 | 5 | 2.8 | 0 | 111.7 | 0.3 | 495 | 0.308178 | 0.000365191 | 2.86675
5 x BEAM | STEEL/300PLUS | B/43 | +1.848 | +2.000 | 5 | 2.8 | 0 | 111.7 | 0.3 | 495 | 0.308178 | 0.000365191 | 2.86675
5 x BEAM | STEEL/300PLUS | B/46 | +1.848 | +2.000 | 5 | 2.8 | 0 | 111.7 | 0.3 | 497.5 | 0.309727 | 0.000367036 | 2.88123
5 x BEAM | STEEL/300PLUS | B/41 | +1.848 | +2.000 | 5 | 2.8 | 0 | 111.7 | 0.3 | 497.5 | 0.309727 | 0.000367036 | 2.88123
2 x RAFTER | STEEL/300PLUS | R/43 | +3.250 | +3.713 | 10 | 11.1 | 0 | 111.3 | 1.2 | 2000 | 1.24068 | 0.00147552 | 11.5828
5 x BEAM | STEEL/300PLUS | B/31 | +1.848 | +2.000 | 5 | 11.1 | 0.1 | 111.3 | 1.2 | 2000 | 1.24068 | 0.00147552 | 11.5828
2 x BEAM | STEEL/300PLUS | B/90 | +1.848 | +2.000 | 5 | 2.2 | 0 | 111.8 | 0.2 | 395.4 | 0.246465 | 0.00029171 | 2.28993
3 x MEZZANINE POST | STEEL/G450 | Z/233 | +0.000 | +2.000 | 2 | 11.1 | 0 | 111.3 | 1.2 | 2000 | 1.24068 | 0.00147552 | 11.5828 | Tekla Common - Finish: 25 deg
BEAM | STEEL/300PLUS | B/12 | +1.848 | +2.000 | 5 | 2.2 | 0 | 111.8 | 0.2 | 395.4 | 0.246465 | 0.00029171 | 2.28993
BEAM | STEEL/300PLUS | B/24 | +1.848 | +2.000 | 5 | 2.2 | 0 | 111.8 | 0.2 | 390 | 0.24312 | 0.000287726 | 2.25865

# IfcBeam: C:200-24 (37)
In: Undefined
Description: C:200-24
Tekla Common - Phase: 1
Tekla Quantity - Volume: 0 m3; Height: 203 mm; Width: 76 mm
Pset_BeamCommon - LoadBearing: no
Name | Material | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Class | Weight (kg) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
3 x BEAM | STEEL/300PLUS | B/137 | +1.797 | +2.000 | 5 | 2.8 | 0 | 110.7 | 0.3 | 390 | 0.305904 | 0.000362606 | 2.84646
BEAM | STEEL/300PLUS | B/136 | +1.797 | +2.000 | 5 | 2.8 | 0 | 110.7 | 0.3 | 390 | 0.305904 | 0.000362606 | 2.84646
JOIST | STEEL/300PLUS | B/138 | +1.797 | +2.000 | 8 | 2.4 | 0 | 110.7 | 0.3 | 342 | 0.268483 | 0.000317978 | 2.49613
JOIST | STEEL/300PLUS | B/58 | +1.797 | +2.000 | 8 | 2.4 | 0 | 110.7 | 0.3 | 342 | 0.268483 | 0.000317978 | 2.49613
2 x BEAM | STEEL/300PLUS | B/85 | +1.797 | +2.000 | 5 | 3.5 | 0 | 110.5 | 0.3 | 495 | 0.387762 | 0.000460231 | 3.61282
2 x BEAM | STEEL/300PLUS | B/86 | +1.797 | +2.000 | 5 | 3.5 | 0 | 110.5 | 0.3 | 495 | 0.387762 | 0.000460231 | 3.61282
4 x BEAM | STEEL/300PLUS | B/50 | +1.797 | +2.000 | 5 | 3.5 | 0 | 110.5 | 0.3 | 497.5 | 0.389711 | 0.000462556 | 3.63106
BEAM | STEEL/300PLUS | B/88 | +1.797 | +2.000 | 5 | 3.5 | 0 | 110.5 | 0.3 | 495 | 0.387762 | 0.000460231 | 3.61282
BEAM | STEEL/300PLUS | B/89 | +1.797 | +2.000 | 5 | 3.5 | 0 | 110.5 | 0.3 | 495 | 0.387762 | 0.000460231 | 3.61282
BEAM | STEEL/300PLUS | B/48 | +1.797 | +2.000 | 5 | 3.5 | 0 | 110.5 | 0.3 | 495 | 0.387762 | 0.000460231 | 3.61282
BEAM | STEEL/300PLUS | B/49 | +1.797 | +2.000 | 5 | 3.5 | 0 | 110.5 | 0.3 | 495 | 0.387762 | 0.000460231 | 3.61282
6 x RAFTER | STEEL/300PLUS | R/44 | +3.199 | +3.713 | 10 | 14.2 | 0 | 110.2 | 1.6 | 2000 | 1.56106 | 0.00185952 | 14.5972
4 x BEAM | STEEL/300PLUS | B/47 | +1.797 | +2.000 | 5 | 3.5 | 0 | 110.5 | 0.3 | 497.5 | 0.389711 | 0.000462556 | 3.63106
BEAM | STEEL/300PLUS | B/39 | +1.797 | +2.000 | 5 | 14.2 | 0.2 | 110.2 | 1.6 | 2000 | 1.56106 | 0.00185952 | 14.5972
BEAM | STEEL/300PLUS | B/87 | +1.797 | +2.000 | 5 | 14.2 | 0.2 | 110.2 | 1.6 | 2000 | 1.56106 | 0.00185952 | 14.5972
2 x BEAM | STEEL/300PLUS | B/84 | +1.797 | +2.000 | 5 | 14.2 | 0.2 | 110.2 | 1.6 | 2000 | 1.56106 | 0.00185952 | 14.5972
3 x MEZZANINE POST | STEEL/G450 | Z/226 | +0.000 | +2.000 | 2 | 14.2 | 0 | 110.2 | 1.6 | 2000 | 1.56106 | 0.00185952 | 14.5972 | Tekla Common - Finish: 25 deg
BEAM | STEEL/300PLUS | B/57 | +1.797 | +2.000 | 5 | 2.8 | 0 | 110.7 | 0.3 | 390 | 0.305904 | 0.000362606 | 2.84646
BEAM | STEEL/300PLUS | B/25 | +1.797 | +2.000 | 5 | 2.8 | 0 | 110.7 | 0.3 | 390 | 0.305904 | 0.000362606 | 2.84646

# IfcBeam: C:250-24 (37)
In: Undefined
Description: C:250-24
Tekla Common - Phase: 1
Tekla Quantity - Volume: 0 m3; Height: 254 mm; Width: 76 mm
Pset_BeamCommon - LoadBearing: no
Name | Material | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Class | Weight (kg) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
3 x BEAM | STEEL/300PLUS | B/140 | +1.746 | +2.000 | 5 | 3.1 | 0 | 110.3 | 0.3 | 390 | 0.345144 | 0.000409406 | 3.21384
BEAM | STEEL/300PLUS | B/139 | +1.746 | +2.000 | 5 | 3.1 | 0 | 110.3 | 0.3 | 390 | 0.345144 | 0.000409406 | 3.21384
JOIST | STEEL/300PLUS | B/141 | +1.746 | +2.000 | 8 | 2.7 | 0 | 110.3 | 0.3 | 342 | 0.302923 | 0.000359018 | 2.81829
JOIST | STEEL/300PLUS | B/61 | +1.746 | +2.000 | 8 | 2.7 | 0 | 110.3 | 0.3 | 342 | 0.302923 | 0.000359018 | 2.81829
4 x BEAM | STEEL/300PLUS | B/52 | +1.746 | +2.000 | 5 | 4 | 0 | 110.2 | 0.3 | 495 | 0.437502 | 0.000519631 | 4.07911
4 x BEAM | STEEL/300PLUS | B/53 | +1.746 | +2.000 | 5 | 4 | 0 | 110.2 | 0.3 | 495 | 0.437502 | 0.000519631 | 4.07911
4 x BEAM | STEEL/300PLUS | B/55 | +1.746 | +2.000 | 5 | 4 | 0 | 110.2 | 0.3 | 497.5 | 0.439701 | 0.000522256 | 4.09971
4 x BEAM | STEEL/300PLUS | B/51 | +1.746 | +2.000 | 5 | 4 | 0 | 110.2 | 0.3 | 497.5 | 0.439701 | 0.000522256 | 4.09971
6 x RAFTER | STEEL/300PLUS | R/45 | +3.149 | +3.713 | 10 | 16 | 0 | 109.8 | 1.8 | 2000 | 1.7613 | 0.00209952 | 16.4812
4 x BEAM | STEEL/300PLUS | B/40 | +1.746 | +2.000 | 5 | 16 | 0.2 | 109.8 | 1.8 | 2000 | 1.7613 | 0.00209952 | 16.4812
3 x MEZZANINE POST | STEEL/G450 | Z/229 | +0.000 | +2.000 | 2 | 16 | 0 | 109.8 | 1.8 | 2000 | 1.7613 | 0.00209952 | 16.4812 | Tekla Common - Finish: 25 deg
BEAM | STEEL/300PLUS | B/60 | +1.746 | +2.000 | 5 | 3.1 | 0 | 110.3 | 0.3 | 390 | 0.345144 | 0.000409406 | 3.21384
BEAM | STEEL/300PLUS | B/26 | +1.746 | +2.000 | 5 | 3.1 | 0 | 110.3 | 0.3 | 390 | 0.345144 | 0.000409406 | 3.21384

# IfcBeam: C:300-30 (6)
In: Undefined
Description: C:300-30; Material: STEEL/300PLUS
Default - ASSEMBLY_POS: R/46
Tekla Common - Bottom elevation: +3.104; Top elevation: +3.713; Phase: 1; Class: 10
Tekla Quantity - Weight: 25 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.5 m2; Net surface area: 2.2 m2; Height: 300 mm; Width: 96 mm; Length: 2000 mm
Pset_BeamCommon - LoadBearing: no; Reference: R/46
BaseQuantities - Length: 2000 mm; OuterSurfaceArea: 2.18726 m2; NetVolume: 0.003258 m3; NetWeight: 25.5753 kg

# IfcBeam: C:350-30 (6)
In: Undefined
Description: C:350-30; Material: STEEL/300PLUS
Default - ASSEMBLY_POS: R/47
Tekla Common - Bottom elevation: +3.054; Top elevation: +3.713; Phase: 1; Class: 10
Tekla Quantity - Weight: 29.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.2 m2; Net surface area: 2.6 m2; Height: 350 mm; Width: 125 mm; Length: 2000 mm
Pset_BeamCommon - LoadBearing: no; Reference: R/47
BaseQuantities - Length: 2000 mm; OuterSurfaceArea: 2.60789 m2; NetVolume: 0.003888 m3; NetWeight: 30.5208 kg

# IfcColumn: C:150-24 (29)
In: Undefined
Description: C:150-24; Material: STEEL/G450
Tekla Common - Finish: 25 deg; Bottom elevation: +0.000; Top elevation: +3.400; Phase: 1
Tekla Quantity - Weight: 18.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 111.2 m2; Net surface area: 2.1 m2; Height: 152 mm; Width: 64 mm; Length: 3400 mm
Pset_ColumnCommon - LoadBearing: no
BaseQuantities - Length: 3400 mm; OuterSurfaceArea: 2.10812 m2; NetVolume: 0.00250838 m3; NetWeight: 19.6908 kg
Name | Class | ASSEMBLY_POS = Reference
8 x MULLION | 2 | Z/1621
8 x MULLION | 2 | Z/1620
10 x MULLION | 2 | Z/352
2 x COLUMN | 12 | Z/8
COLUMN | 12 | Z/230

# IfcColumn: C:200-24 (33)
In: Undefined
Description: C:200-24; Material: STEEL/G450
Tekla Common - Finish: 25 deg; Bottom elevation: +0.000; Top elevation: +3.400; Phase: 1
Tekla Quantity - Weight: 24.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 110.2 m2; Net surface area: 2.7 m2; Height: 203 mm; Width: 76 mm; Length: 3400 mm
Pset_ColumnCommon - LoadBearing: no
BaseQuantities - Length: 3400 mm; OuterSurfaceArea: 2.6525 m2; NetVolume: 0.00316118 m3; NetWeight: 24.8153 kg
Name | Class | ASSEMBLY_POS = Reference
8 x MULLION | 2 | Z/1625
6 x COLUMN | 12 | Z/17
8 x MULLION | 2 | Z/1624
10 x MULLION | 2 | Z/1616
COLUMN | 12 | Z/349

# IfcColumn: C:250-24 (33)
In: Undefined
Description: C:250-24; Material: STEEL/G450
Tekla Common - Finish: 25 deg; Bottom elevation: +0.000; Top elevation: +3.400; Phase: 1
Tekla Quantity - Weight: 27.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 109.7 m2; Net surface area: 3 m2; Height: 254 mm; Width: 76 mm; Length: 3400 mm
Pset_ColumnCommon - LoadBearing: no
BaseQuantities - Length: 3400 mm; OuterSurfaceArea: 2.99274 m2; NetVolume: 0.00356918 m3; NetWeight: 28.0181 kg
Name | ASSEMBLY_POS = Reference | Class
8 x MULLION | Z/1629 | 2
6 x COLUMN | Z/26 | 12
8 x MULLION | Z/1626 | 2
10 x MULLION | Z/1619 | 2
COLUMN | Z/351 | 12

# IfcColumn: C:300-30 (6)
In: Undefined
Description: C:300-30; Material: STEEL/G450
Tekla Common - Finish: 25 deg; Bottom elevation: +0.000; Top elevation: +3.400; Phase: 1; Class: 12
Default - ASSEMBLY_POS: Z/36
Tekla Quantity - Weight: 42.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.3 m2; Net surface area: 3.7 m2; Height: 300 mm; Width: 96 mm; Length: 3400 mm
Pset_ColumnCommon - LoadBearing: no; Reference: Z/36
BaseQuantities - Length: 3400 mm; OuterSurfaceArea: 3.71606 m2; NetVolume: 0.0055386 m3; NetWeight: 43.478 kg

# IfcColumn: C:350-30 (6)
In: Undefined
Description: C:350-30; Material: STEEL/G450
Default - ASSEMBLY_POS: Z/42
Tekla Common - Finish: 25 deg; Bottom elevation: +0.000; Top elevation: +3.400; Phase: 1; Class: 12
Tekla Quantity - Weight: 50.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.2 m2; Net surface area: 4.4 m2; Height: 350 mm; Width: 125 mm; Length: 3400 mm
Pset_ColumnCommon - LoadBearing: no; Reference: Z/42
BaseQuantities - Length: 3400 mm; OuterSurfaceArea: 4.43069 m2; NetVolume: 0.0066096 m3; NetWeight: 51.8854 kg

# IfcElementAssembly (381)
In: Undefined
PredefinedType: RIGID_FRAME
Name | ASSEMBLY_POSITION_CODE = Assembly/Cast unit position code | ASSEMBLY_POS = Assembly/Cast unit Mark | Assembly/Cast unit weight (kg) | Assembly/Cast unit bottom elevation | Assembly/Cast unit top elevation | Width (mm)
MEZZANINE BRACKET | C150MZ/1 | PL/2085 | 0.4 | +1.854 | +1.994 | 59.6
MEZZANINE BRACKET | C150MZ/1 | PL/143 | 0.4 | +1.854 | +1.994 | 59.6
MEZZANINE BRACKET | C150MZ/1 | PL/2086 | 0.4 | +1.854 | +1.994 | 59.6
MEZZANINE BRACKET | C150MZ/2 | PL/143 | 0.4 | +1.854 | +1.994 | 59.6
2 x MEZZANINE BRACKET | C150MZ/2> | PL/143 | 0.4 | +1.854 | +1.994 | 59.6
BEAM | C350MZ/3 | B/51 | 4 | +1.746 | +2.000 | 76
MEZZANINE BRACKET | C350MZ/3> | PL/2143 | 2 | +1.772 | +1.974 | 170
BEAM | C300MZ/3 | B/51 | 4 | +1.746 | +2.000 | 76
MEZZANINE BRACKET | C300MZ/3> | PL/2134 | 2 | +1.772 | +1.974 | 170
BEAM | C250MZ/3 | B/51 | 4 | +1.746 | +2.000 | 76
MEZZANINE BRACKET | C250MZ/3> | PL/2125 | 2 | +1.772 | +1.974 | 170
BEAM | C200MZ/3 | B/51 | 4 | +1.746 | +2.000 | 76
MEZZANINE BRACKET | C200MZ/3> | PL/2125 | 2 | +1.772 | +1.974 | 170
BEAM | C200MZ/1 | B/41 | 2.8 | +1.848 | +2.000 | 64
MEZZANINE BRACKET | C200MZ/1-2 | PL/2126 | 0.9 | +1.871 | +1.976 | 170
BEAM | C150MZ/1 | B/41 | 2.8 | +1.848 | +2.000 | 64
MEZZANINE BRACKET | C150MZ/1-2 | PL/2121 | 0.9 | +1.871 | +1.976 | 170
BEAM | C350MZ/2-3 | B/48 | 3.5 | +1.797 | +2.000 | 76
MEZZANINE BRACKET | C350MZ/2-3 | PL/2145 | 1.7 | +1.823 | +1.974 | 175
BEAM | C350MZ/2 | B/47 | 3.5 | +1.797 | +2.000 | 76
MEZZANINE BRACKET | C350MZ/2-3 | PL/2142 | 1.5 | +1.823 | +1.974 | 170
BEAM | C300MZ/2-3 | B/88 | 3.5 | +1.797 | +2.000 | 76
MEZZANINE BRACKET | C300MZ/2-3 | PL/2136 | 1.6 | +1.823 | +1.974 | 175
BEAM | C300MZ/2 | B/47 | 3.5 | +1.797 | +2.000 | 76
MEZZANINE BRACKET | C300MZ/2-3 | PL/2133 | 1.5 | +1.823 | +1.974 | 170
BEAM | C250MZ/2-3 | B/85 | 3.5 | +1.797 | +2.000 | 76
MEZZANINE BRACKET | C250MZ/2-3 | PL/2127 | 1.6 | +1.823 | +1.974 | 175
BEAM | C200MZ/2-3 | B/85 | 3.5 | +1.797 | +2.000 | 76
MEZZANINE BRACKET | C200MZ/2-3 | PL/2127 | 1.6 | +1.823 | +1.974 | 175
BEAM | C250MZ/2 | B/47 | 3.5 | +1.797 | +2.000 | 76
MEZZANINE BRACKET | C250MZ/2-3 | PL/2124 | 1.5 | +1.823 | +1.974 | 170
BEAM | C200MZ/2 | B/47 | 3.5 | +1.797 | +2.000 | 76
MEZZANINE BRACKET | C200MZ/2-3 | PL/2124 | 1.5 | +1.823 | +1.974 | 170
PLATE | C250MZ/2> | PL/1393 | 2.2 | +1.750 | +2.000 | 65
PLATE | C250MZ/2> | PL/1392 | 2 | +1.750 | +2.000 | 65
PLATE | C250MZ/2 | PL/1391 | 1.5 | +1.750 | +2.000 | 55
PLATE | C200MZ/2> | PL/1389 | 1.7 | +1.800 | +2.000 | 65
PLATE | C200MZ/2> | PL/1388 | 1.5 | +1.800 | +2.000 | 65
PLATE | C200MZ/2 | PL/1387 | 1.1 | +1.800 | +2.000 | 55
PLATE | C150MZ/2> | PL/146 | 1.3 | +1.850 | +2.000 | 65
PLATE | C150MZ/2> | PL/145 | 1.1 | +1.850 | +2.000 | 65
PLATE | C150MZ/2 | PL/144 | 0.9 | +1.850 | +2.000 | 55
MEZZANINE BRACKET | C250MZ/1 | PL/2095 | 0.7 | +1.755 | +1.990 | 70
COLUMN | C250MZ/1 | Z/351 | 27.3 | +0.000 | +3.400 | 76
BEAM | C250MZ/1 | B/140 | 3.1 | +1.746 | +2.000 | 76
MEZZANINE BRACKET | C200MZ/1 | PL/2088 | 0.7 | +1.806 | +1.991 | 70
BEAM | C200MZ/1 | B/137 | 2.8 | +1.797 | +2.000 | 76
BEAM | C150MZ/1 | B/135 | 2.2 | +1.848 | +2.000 | 64
COLUMN | C150MZ/1 | Z/230 | 18.9 | +0.000 | +3.400 | 64
MEZZANINE BRACKET | C250MZ/1 | PL/2091 | 0.7 | +1.755 | +1.990 | 70
BEAM | C250MZ/1 | B/139 | 3.1 | +1.746 | +2.000 | 76
MEZZANINE BRACKET | C200MZ/1 | PL/2087 | 0.7 | +1.806 | +1.991 | 70
BEAM | C200MZ/1 | B/136 | 2.8 | +1.797 | +2.000 | 76
BEAM | C150MZ/1 | B/134 | 2.2 | +1.848 | +2.000 | 64
COLUMN | C200MZ/1 | Z/349 | 24.1 | +0.000 | +3.400 | 76
BEAM | C250MZ/2 | B/60 | 3.1 | +1.746 | +2.000 | 76
INLINE GIRT BRACKET | C250MZ/2 | Z/1669 | 0.7 | +1.763 | +1.983 | 80.0024
INLINE GIRT BRACKET | C250MZ/2 | Z/1671 | 1.1 | +1.763 | +1.983 | 80.0024
INLINE GIRT BRACKET | C150MZ/2 | Z/1630 | 0.7 | +1.864 | +1.984 | 153.591
BEAM | C150MZ/2 | B/12 | 2.2 | +1.848 | +2.000 | 64
INLINE GIRT BRACKET | C150MZ/2 | Z/350 | 0.4 | +1.864 | +1.984 | 79.9867
BEAM | C200MZ/2 | B/57 | 2.8 | +1.797 | +2.000 | 76
INLINE GIRT BRACKET | C200MZ/2 | Z/1634 | 0.9 | +1.813 | +1.984 | 80.0028
INLINE GIRT BRACKET | C200MZ/2 | Z/1631 | 0.7 | +1.813 | +1.984 | 80.0028
JOIST | C250MZ/2 | B/141 | 2.7 | +1.746 | +2.000 | 76
JOIST | C200MZ/2 | B/138 | 2.4 | +1.797 | +2.000 | 76
JOIST | C150MZ/2 | B/13 | 2 | +1.848 | +2.000 | 64
JOIST | C250MZ/2 | B/61 | 2.7 | +1.746 | +2.000 | 76
JOIST | C200MZ/2 | B/58 | 2.4 | +1.797 | +2.000 | 76
JOIST | C150MZ/2 | B/56 | 2 | +1.848 | +2.000 | 64
BEAM | C350MZ/3> | B/40 | 16 | +1.746 | +2.000 | 76
8 x MULLION |  | Z/1629 | 27.3 | +0.000 | +3.400 | 76
BEAM | C300MZ/3> | B/40 | 16 | +1.746 | +2.000 | 76
BEAM | C250MZ/3> | B/40 | 16 | +1.746 | +2.000 | 76
2 x MULLION | C350MZ/3> | Z/1625 | 24.1 | +0.000 | +3.400 | 76
2 x MULLION | C300MZ/3> | Z/1625 | 24.1 | +0.000 | +3.400 | 76
2 x MULLION | C250MZ/3> | Z/1625 | 24.1 | +0.000 | +3.400 | 76
2 x MULLION | C350MZ/3> | Z/1621 | 18.9 | +0.000 | +3.400 | 64
2 x MULLION | C300MZ/3> | Z/1621 | 18.9 | +0.000 | +3.400 | 64
2 x MULLION | C250MZ/3> | Z/1621 | 18.9 | +0.000 | +3.400 | 64
BEAM | C200MZ/3> | B/40 | 16 | +1.746 | +2.000 | 76
2 x MULLION | C200MZ/3> | Z/1625 | 24.1 | +0.000 | +3.400 | 76
2 x MULLION | C200MZ/3> | Z/1621 | 18.9 | +0.000 | +3.400 | 64
BEAM | C350MZ/2-3 | B/39 | 14.2 | +1.797 | +2.000 | 76
2 x MULLION | C350MZ/2-3 | Z/1626 | 27.3 | +0.000 | +3.400 | 76
BEAM | C300MZ/2-3 | B/87 | 14.2 | +1.797 | +2.000 | 76
2 x MULLION | C300MZ/2-3 | Z/1626 | 27.3 | +0.000 | +3.400 | 76
BEAM | C250MZ/2-3 | B/84 | 14.2 | +1.797 | +2.000 | 76
2 x MULLION | C250MZ/2-3 | Z/1626 | 27.3 | +0.000 | +3.400 | 76
2 x MULLION | C350MZ/2-3 | Z/1624 | 24.1 | +0.000 | +3.400 | 76
2 x MULLION | C300MZ/2-3 | Z/1624 | 24.1 | +0.000 | +3.400 | 76
2 x MULLION | C250MZ/2-3 | Z/1624 | 24.1 | +0.000 | +3.400 | 76
2 x MULLION | C350MZ/2-3 | Z/1620 | 18.9 | +0.000 | +3.400 | 64
2 x MULLION | C300MZ/2-3 | Z/1620 | 18.9 | +0.000 | +3.400 | 64
2 x MULLION | C250MZ/2-3 | Z/1620 | 18.9 | +0.000 | +3.400 | 64
BEAM | C200MZ/2-3 | B/84 | 14.2 | +1.797 | +2.000 | 76
2 x MULLION | C200MZ/2-3 | Z/1626 | 27.3 | +0.000 | +3.400 | 76
2 x MULLION | C200MZ/2-3 | Z/1624 | 24.1 | +0.000 | +3.400 | 76
2 x MULLION | C200MZ/2-3 | Z/1620 | 18.9 | +0.000 | +3.400 | 64
BEAM | C350MZ/1-2 | B/31 | 11.1 | +1.848 | +2.000 | 64
2 x MULLION | C350MZ/1-2 | Z/1619 | 27.3 | +0.000 | +3.400 | 76
2 x MULLION | C350MZ/1-2 | Z/1616 | 24.1 | +0.000 | +3.400 | 76
2 x MULLION | C350MZ/1-2 | Z/352 | 18.9 | +0.000 | +3.400 | 64
BEAM | C300MZ/1-2 | B/31 | 11.1 | +1.848 | +2.000 | 64
2 x MULLION | C300MZ/1-2 | Z/1619 | 27.3 | +0.000 | +3.400 | 76
2 x MULLION | C300MZ/1-2 | Z/1616 | 24.1 | +0.000 | +3.400 | 76
2 x MULLION | C300MZ/1-2 | Z/352 | 18.9 | +0.000 | +3.400 | 64
BEAM | C250MZ/1-2 | B/31 | 11.1 | +1.848 | +2.000 | 64
2 x MULLION | C250MZ/1-2 | Z/1619 | 27.3 | +0.000 | +3.400 | 76
2 x MULLION | C250MZ/1-2 | Z/1616 | 24.1 | +0.000 | +3.400 | 76
2 x MULLION | C250MZ/1-2 | Z/352 | 18.9 | +0.000 | +3.400 | 64
BEAM | C200MZ/1-2 | B/31 | 11.1 | +1.848 | +2.000 | 64
2 x MULLION | C200MZ/1-2 | Z/1619 | 27.3 | +0.000 | +3.400 | 76
2 x MULLION | C200MZ/1-2 | Z/1616 | 24.1 | +0.000 | +3.400 | 76
2 x MULLION | C200MZ/1-2 | Z/352 | 18.9 | +0.000 | +3.400 | 64
BEAM | C150MZ/1-2 | B/31 | 11.1 | +1.848 | +2.000 | 64
2 x MULLION | C150MZ/1-2 | Z/1619 | 27.3 | +0.000 | +3.400 | 76
2 x MULLION | C150MZ/1-2 | Z/1616 | 24.1 | +0.000 | +3.400 | 76
2 x MULLION | C150MZ/1-2 | Z/352 | 18.9 | +0.000 | +3.400 | 64
2 x MEZZANINE BRACKET |  | PL/1422 | 2.4 | +1.772 | +1.974 | 175
2 x MEZZANINE BRACKET |  | PL/1413 | 2.4 | +1.772 | +1.974 | 175
4 x MEZZANINE BRACKET |  | PL/1404 | 2.4 | +1.772 | +1.974 | 175
2 x MEZZANINE BRACKET |  | PL/1419 | 2.2 | +1.772 | +1.974 | 175
2 x MEZZANINE BRACKET |  | PL/1410 | 2.2 | +1.772 | +1.974 | 175
4 x MEZZANINE BRACKET |  | PL/1401 | 2.1 | +1.772 | +1.974 | 175
2 x MEZZANINE BRACKET | C350MZ/3> | PL/1416 | 2 | +1.772 | +1.974 | 170
2 x MEZZANINE BRACKET | C300MZ/3> | PL/1407 | 2 | +1.772 | +1.974 | 170
2 x MEZZANINE BRACKET | C250MZ/3> | PL/1398 | 2 | +1.772 | +1.974 | 170
2 x MEZZANINE BRACKET | C200MZ/3> | PL/1398 | 2 | +1.772 | +1.974 | 170
2 x MEZZANINE BRACKET | C350MZ/2-3 | PL/1421 | 2 | +1.823 | +1.974 | 175
2 x MEZZANINE BRACKET | C300MZ/2-3 | PL/1412 | 1.7 | +1.823 | +1.974 | 175
2 x MEZZANINE BRACKET | C250MZ/2-3 | PL/1403 | 1.7 | +1.823 | +1.974 | 175
2 x MEZZANINE BRACKET | C350MZ/2-3 | PL/1418 | 1.7 | +1.823 | +1.974 | 175
2 x MEZZANINE BRACKET | C300MZ/2-3 | PL/1409 | 1.6 | +1.823 | +1.974 | 175
2 x MEZZANINE BRACKET | C250MZ/2-3 | PL/1400 | 1.6 | +1.823 | +1.974 | 175
2 x MEZZANINE BRACKET | C350MZ/2-3 | PL/1415 | 1.5 | +1.823 | +1.974 | 170
2 x MEZZANINE BRACKET | C300MZ/2-3 | PL/1406 | 1.5 | +1.823 | +1.974 | 170
2 x MEZZANINE BRACKET | C250MZ/2-3 | PL/1397 | 1.5 | +1.823 | +1.974 | 170
2 x MEZZANINE BRACKET | C200MZ/2-3 | PL/1403 | 1.7 | +1.823 | +1.974 | 175
2 x MEZZANINE BRACKET | C200MZ/2-3 | PL/1400 | 1.6 | +1.823 | +1.974 | 175
2 x MEZZANINE BRACKET | C200MZ/2-3 | PL/1397 | 1.5 | +1.823 | +1.974 | 170
2 x MEZZANINE BRACKET | C350MZ/1-2 | PL/1423 | 1.3 | +1.871 | +1.976 | 175
2 x MEZZANINE BRACKET | C350MZ/1-2 | PL/1420 | 1.1 | +1.871 | +1.976 | 175
2 x MEZZANINE BRACKET | C350MZ/1-2 | PL/1417 | 0.9 | +1.871 | +1.976 | 170
2 x MEZZANINE BRACKET | C300MZ/1-2 | PL/1414 | 1.3 | +1.871 | +1.976 | 175
2 x MEZZANINE BRACKET | C300MZ/1-2 | PL/1411 | 1.1 | +1.871 | +1.976 | 175
2 x MEZZANINE BRACKET | C300MZ/1-2 | PL/1408 | 0.9 | +1.871 | +1.976 | 170
2 x MEZZANINE BRACKET | C250MZ/1-2 | PL/1405 | 1.3 | +1.871 | +1.976 | 175
2 x MEZZANINE BRACKET | C250MZ/1-2 | PL/1402 | 1.1 | +1.871 | +1.976 | 175
2 x MEZZANINE BRACKET | C250MZ/1-2 | PL/1399 | 0.9 | +1.871 | +1.976 | 170
2 x MEZZANINE BRACKET | C200MZ/1-2 | PL/1405 | 1.3 | +1.871 | +1.976 | 175
2 x MEZZANINE BRACKET | C200MZ/1-2 | PL/1402 | 1.1 | +1.871 | +1.976 | 175
2 x MEZZANINE BRACKET | C200MZ/1-2 | PL/1399 | 0.9 | +1.871 | +1.976 | 170
2 x MEZZANINE BRACKET | C150MZ/1-2 | PL/1396 | 1.3 | +1.871 | +1.976 | 175
2 x MEZZANINE BRACKET | C150MZ/1-2 | PL/1395 | 1.1 | +1.871 | +1.976 | 175
2 x MEZZANINE BRACKET | C150MZ/1-2 | PL/1394 | 0.9 | +1.871 | +1.976 | 170
BEAM | C350MZ/3> | B/53 | 4 | +1.746 | +2.000 | 76
BEAM | C300MZ/3> | B/53 | 4 | +1.746 | +2.000 | 76
BEAM | C250MZ/3> | B/53 | 4 | +1.746 | +2.000 | 76
MEZZANINE BRACKET |  | PL/2149 | 2.4 | +1.772 | +1.974 | 175
MEZZANINE BRACKET |  | PL/2140 | 2.4 | +1.772 | +1.974 | 175
2 x MEZZANINE BRACKET |  | PL/2131 | 2.4 | +1.772 | +1.974 | 175
BEAM | C200MZ/3> | B/53 | 4 | +1.746 | +2.000 | 76
BEAM | C300MZ/3> | B/52 | 4 | +1.746 | +2.000 | 76
BEAM | C250MZ/3> | B/52 | 4 | +1.746 | +2.000 | 76
BEAM | C200MZ/3> | B/52 | 4 | +1.746 | +2.000 | 76
MEZZANINE BRACKET | C300MZ/3> | PL/2137 | 2.2 | +1.772 | +1.974 | 175
MEZZANINE BRACKET | C250MZ/3> | PL/2128 | 2.1 | +1.772 | +1.974 | 175
MEZZANINE BRACKET | C200MZ/3> | PL/2128 | 2.1 | +1.772 | +1.974 | 175
BEAM | C350MZ/3> | B/52 | 4 | +1.746 | +2.000 | 76
MEZZANINE BRACKET | C350MZ/3> | PL/2146 | 2.2 | +1.772 | +1.974 | 175
BEAM | C350MZ/2-3 | B/49 | 3.5 | +1.797 | +2.000 | 76
MEZZANINE BRACKET | C350MZ/2-3 | PL/2148 | 2 | +1.823 | +1.974 | 175
BEAM | C300MZ/2-3 | B/89 | 3.5 | +1.797 | +2.000 | 76
MEZZANINE BRACKET | C300MZ/2-3 | PL/2139 | 1.7 | +1.823 | +1.974 | 175
BEAM | C250MZ/2-3 | B/86 | 3.5 | +1.797 | +2.000 | 76
MEZZANINE BRACKET | C250MZ/2-3 | PL/2130 | 1.7 | +1.823 | +1.974 | 175
BEAM | C200MZ/2-3 | B/86 | 3.5 | +1.797 | +2.000 | 76
MEZZANINE BRACKET | C200MZ/2-3 | PL/2130 | 1.7 | +1.823 | +1.974 | 175
BEAM | C350MZ/1-2 | B/43 | 2.8 | +1.848 | +2.000 | 64
MEZZANINE BRACKET | C350MZ/1-2 | PL/2150 | 1.3 | +1.871 | +1.976 | 175
BEAM | C300MZ/1-2 | B/43 | 2.8 | +1.848 | +2.000 | 64
MEZZANINE BRACKET | C300MZ/1-2 | PL/2141 | 1.3 | +1.871 | +1.976 | 175
BEAM | C250MZ/1-2 | B/43 | 2.8 | +1.848 | +2.000 | 64
MEZZANINE BRACKET | C250MZ/1-2 | PL/2132 | 1.3 | +1.871 | +1.976 | 175
BEAM | C200MZ/1-2 | B/43 | 2.8 | +1.848 | +2.000 | 64
MEZZANINE BRACKET | C200MZ/1-2 | PL/2132 | 1.3 | +1.871 | +1.976 | 175
BEAM | C150MZ/1-2 | B/43 | 2.8 | +1.848 | +2.000 | 64
MEZZANINE BRACKET | C150MZ/1-2 | PL/2123 | 1.3 | +1.871 | +1.976 | 175
BEAM | C350MZ/1-2 | B/42 | 2.8 | +1.848 | +2.000 | 64
MEZZANINE BRACKET | C350MZ/1-2 | PL/2147 | 1.1 | +1.871 | +1.976 | 175
BEAM | C300MZ/1-2 | B/42 | 2.8 | +1.848 | +2.000 | 64
MEZZANINE BRACKET | C300MZ/1-2 | PL/2138 | 1.1 | +1.871 | +1.976 | 175
BEAM | C250MZ/1-2 | B/42 | 2.8 | +1.848 | +2.000 | 64
MEZZANINE BRACKET | C250MZ/1-2 | PL/2129 | 1.1 | +1.871 | +1.976 | 175
BEAM | C200MZ/1-2 | B/42 | 2.8 | +1.848 | +2.000 | 64
MEZZANINE BRACKET | C200MZ/1-2 | PL/2129 | 1.1 | +1.871 | +1.976 | 175
BEAM | C150MZ/1-2 | B/42 | 2.8 | +1.848 | +2.000 | 64
MEZZANINE BRACKET | C150MZ/1-2 | PL/2122 | 1.1 | +1.871 | +1.976 | 175
BEAM | C350MZ/1 | B/41 | 2.8 | +1.848 | +2.000 | 64
MEZZANINE BRACKET | C350MZ/1-2 | PL/2144 | 0.9 | +1.871 | +1.976 | 170
BEAM | C300MZ/1 | B/41 | 2.8 | +1.848 | +2.000 | 64
MEZZANINE BRACKET | C300MZ/1-2 | PL/2135 | 0.9 | +1.871 | +1.976 | 170
BEAM | C250MZ/1 | B/41 | 2.8 | +1.848 | +2.000 | 64
MEZZANINE BRACKET | C250MZ/1-2 | PL/2126 | 0.9 | +1.871 | +1.976 | 170
4 x BEAM |  | B/55 | 4 | +1.746 | +2.000 | 76
BEAM | C200MZ/2-3 | B/50 | 3.5 | +1.797 | +2.000 | 76
BEAM | C250MZ/2-3 | B/50 | 3.5 | +1.797 | +2.000 | 76
BEAM | C300MZ/2-3 | B/50 | 3.5 | +1.797 | +2.000 | 76
BEAM | C350MZ/2-3 | B/50 | 3.5 | +1.797 | +2.000 | 76
BEAM | C350MZ/1-2 | B/46 | 2.8 | +1.848 | +2.000 | 64
BEAM | C300MZ/1-2 | B/46 | 2.8 | +1.848 | +2.000 | 64
BEAM | C250MZ/1-2 | B/46 | 2.8 | +1.848 | +2.000 | 64
BEAM | C200MZ/1-2 | B/46 | 2.8 | +1.848 | +2.000 | 64
BEAM | C150MZ/1-2 | B/46 | 2.8 | +1.848 | +2.000 | 64
2 x RAFTER | C350MZ/3> | R/47 | 29.9 | +3.054 | +3.713 | 125
2 x COLUMN | C350MZ/3 | Z/42 | 50.8 | +0.000 | +3.400 | 125
2 x RAFTER | C300MZ/3> | R/46 | 25 | +3.104 | +3.713 | 96
2 x COLUMN | C300MZ/3 | Z/36 | 42.5 | +0.000 | +3.400 | 96
2 x RAFTER | C250MZ/3> | R/45 | 16 | +3.149 | +3.713 | 76
2 x COLUMN | C250MZ/3 | Z/26 | 27.3 | +0.000 | +3.400 | 76
2 x RAFTER | C200MZ/3> | R/44 | 14.2 | +3.199 | +3.713 | 76
2 x COLUMN | C200MZ/3 | Z/17 | 24.1 | +0.000 | +3.400 | 76
2 x RAFTER | C350MZ/2-3 | R/47 | 29.9 | +3.054 | +3.713 | 125
2 x COLUMN | C350MZ/2 | Z/42 | 50.8 | +0.000 | +3.400 | 125
2 x RAFTER | C300MZ/2-3 | R/46 | 25 | +3.104 | +3.713 | 96
2 x COLUMN | C300MZ/2 | Z/36 | 42.5 | +0.000 | +3.400 | 96
2 x RAFTER | C250MZ/2-3 | R/45 | 16 | +3.149 | +3.713 | 76
2 x COLUMN | C250MZ/2 | Z/26 | 27.3 | +0.000 | +3.400 | 76
2 x RAFTER | C200MZ/2-3 | R/44 | 14.2 | +3.199 | +3.713 | 76
2 x COLUMN | C200MZ/2 | Z/17 | 24.1 | +0.000 | +3.400 | 76
2 x RAFTER | C350MZ/1-2 | R/47 | 29.9 | +3.054 | +3.713 | 125
2 x COLUMN | C350MZ/1 | Z/42 | 50.8 | +0.000 | +3.400 | 125
2 x RAFTER | C300MZ/1-2 | R/46 | 25 | +3.104 | +3.713 | 96
2 x COLUMN | C300MZ/1 | Z/36 | 42.5 | +0.000 | +3.400 | 96
2 x RAFTER | C250MZ/1-2 | R/45 | 16 | +3.149 | +3.713 | 76
2 x COLUMN | C250MZ/1 | Z/26 | 27.3 | +0.000 | +3.400 | 76
2 x RAFTER | C200MZ/1-2 | R/44 | 14.2 | +3.199 | +3.713 | 76
2 x COLUMN | C200MZ/1 | Z/17 | 24.1 | +0.000 | +3.400 | 76
2 x RAFTER | C150MZ/1-2 | R/43 | 11.1 | +3.250 | +3.713 | 64
2 x COLUMN | C150MZ/1 | Z/8 | 18.9 | +0.000 | +3.400 | 64
2 x MEZZANINE BRACKET | C250MZ/2> | PL/2095 | 0.7 | +1.755 | +1.990 | 70
2 x BEAM | C250MZ/2> | B/140 | 3.1 | +1.746 | +2.000 | 76
MEZZANINE POST | C250MZ/2> | Z/229 | 16 | +0.000 | +2.000 | 76
MEZZANINE POST | C250MZ/2> | Z/226 | 14.2 | +0.000 | +2.000 | 76
2 x MEZZANINE BRACKET | C200MZ/2> | PL/2088 | 0.7 | +1.806 | +1.991 | 70
2 x BEAM | C200MZ/2> | B/137 | 2.8 | +1.797 | +2.000 | 76
MEZZANINE POST | C200MZ/2> | Z/229 | 16 | +0.000 | +2.000 | 76
MEZZANINE POST | C200MZ/2> | Z/226 | 14.2 | +0.000 | +2.000 | 76
2 x BEAM | C150MZ/2> | B/90 | 2.2 | +1.848 | +2.000 | 64
MEZZANINE POST | C150MZ/2> | Z/229 | 16 | +0.000 | +2.000 | 76
MEZZANINE POST | C150MZ/2> | Z/226 | 14.2 | +0.000 | +2.000 | 76
MEZZANINE BRACKET | C250MZ/2 | PL/2095 | 0.7 | +1.755 | +1.990 | 70
MEZZANINE BRACKET | C200MZ/2 | PL/2088 | 0.7 | +1.806 | +1.991 | 70
MEZZANINE POST | C250MZ/2 | Z/233 | 11.1 | +0.000 | +2.000 | 64
MEZZANINE POST | C200MZ/2 | Z/233 | 11.1 | +0.000 | +2.000 | 64
MEZZANINE POST | C150MZ/2 | Z/233 | 11.1 | +0.000 | +2.000 | 64
MEZZANINE BRACKET | C250MZ/1 | PL/1390 | 0.7 | +1.755 | +1.990 | 70
BEAM | C250MZ/1 | B/26 | 3.1 | +1.746 | +2.000 | 76
MEZZANINE BRACKET | C200MZ/1 | PL/1386 | 0.7 | +1.806 | +1.991 | 70
BEAM | C200MZ/1 | B/25 | 2.8 | +1.797 | +2.000 | 76
BEAM | C150MZ/1 | B/24 | 2.2 | +1.848 | +2.000 | 64

# IfcMechanicalFastener: Bolt assembly (273)
In: Undefined
Tekla Bolt - Slotted hole y: 0 mm; Location: Site
Name | NominalDiameter (mm) = Washer diameter (mm) | NominalLength (mm) = Bolt length (mm) | Material = Bolt standard | Washer count = Nut count | Washer type | Washer name | Nut type | Nut name | Slotted hole x (mm) | Bolt hole diameter (mm) | Bolt count | Bolt size (mm) | Bolt Name
36 x Bolt assembly | 16 | 30 | 8.8S | 4 | HARD | WASHERM16-HARD | 8.8-HEX | NUTM16-8.8-HEX | 0 | 22 | 4 | 16 | BOLTM16*30
81 x Bolt assembly | 12 | 30 | FB1230Z | 4 | FLAT | WASHERM12-FLAT | 4.6-HEX | NUTM12-4.6-HEX | 0 | 18 | 4 | 12 | BOLTFB1230
6 x Bolt assembly | 16 | 3 | 8.8S | 0 | HARD | WASHERM16-HARD | 8.8-HEX | NUTM16-8.8-HEX | 0 | 22 | 2 | 22 | BOLTM16*25
12 x Bolt assembly | 12 | 3 | PB1230 | 0 | FLAT | WASHERM12-FLAT | 4.6-HEX | NUTM12-4.6-HEX | 0 | 18 | 2 | 18 | BOLTPB1230
6 x Bolt assembly | 16 | 3 | 8.8S | 0 | HARD | WASHERM16-HARD | 8.8-HEX | NUTM16-8.8-HEX | 19 | 22 | 2 | 22 | BOLTM16*25
4 x Bolt assembly | 16 | 35 | 8.8S | 2 | HARD | WASHERM16-HARD | 8.8-HEX | NUTM16-8.8-HEX | 0 | 22 | 2 | 16 | BOLTM16*35
7 x Bolt assembly | 16 | 30 | 8.8S | 2 | HARD | WASHERM16-HARD | 8.8-HEX | NUTM16-8.8-HEX | 0 | 22 | 2 | 16 | BOLTM16*30
12 x Bolt assembly | 12 | 3 | PB1230 | 0 | FLAT | WASHERM12-FLAT | 4.6-HEX | NUTM12-4.6-HEX | 19 | 18 | 2 | 18 | BOLTPB1230
22 x Bolt assembly | 12 | 30 | PB1230 | 2 | FLAT | WASHERM12-FLAT | 4.6-HEX | NUTM12-4.6-HEX | 0 | 18 | 2 | 12 | BOLTPB1230
9 x Bolt assembly | 12 | 30 | PB1230 | 2 | FLAT | WASHERM12-FLAT | 4.6-HEX | NUTM12-4.6-HEX | 4 | 18 | 2 | 12 | BOLTPB1230
12 x Bolt assembly | 16 | 30 | 8.8S | 4 | HARD | WASHERM16-HARD | 8.8-HEX | NUTM16-8.8-HEX | 18 | 22 | 4 | 16 | BOLTM16*30
54 x Bolt assembly | 12 | 30 | PB1230 | 4 | FLAT | WASHERM12-FLAT | 4.6-HEX | NUTM12-4.6-HEX | 17 | 18 | 4 | 12 | BOLTPB1230
12 x Bolt assembly | 16 | 35 | 8.8S | 4 | HARD | WASHERM16-HARD | 8.8-HEX | NUTM16-8.8-HEX | 18 | 22 | 4 | 16 | BOLTM16*35

# IfcPlate: PLT3*105 (45)
In: Undefined
Description: PLT3*105; Material: STEEL/450
Tekla Common - Bottom elevation: +1.871; Top elevation: +1.976; Phase: 1; Class: 11
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.1 m2; Height: 105 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 105 mm; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Weight (kg) | Area per tons (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
2 x MEZZANINE BRACKET | PL/2126 | 0.9 | 88.2 | 381.7 | 0.0835232 | 0.0400752 | 0.000120672
MEZZANINE BRACKET | PL/2121 | 0.9 | 88.2 | 375.7 | 0.0822272 | 0.0394452 | 0.000118782
2 x MEZZANINE BRACKET | PL/1423 | 1.3 | 88 | 513.2 | 0.111927 | 0.0538827 | 0.000162094
2 x MEZZANINE BRACKET | PL/1420 | 1.1 | 88 | 462.2 | 0.100911 | 0.0485277 | 0.000146029
2 x MEZZANINE BRACKET | PL/1417 | 0.9 | 88.2 | 406.2 | 0.0888152 | 0.0426477 | 0.000128389
2 x MEZZANINE BRACKET | PL/1414 | 1.3 | 88 | 498.7 | 0.108795 | 0.0523602 | 0.000157527
2 x MEZZANINE BRACKET | PL/1411 | 1.1 | 88.2 | 447.7 | 0.0977792 | 0.0470052 | 0.000141462
2 x MEZZANINE BRACKET | PL/1408 | 0.9 | 88.2 | 391.7 | 0.0856832 | 0.0411252 | 0.000123822
4 x MEZZANINE BRACKET | PL/1405 | 1.3 | 88 | 488.7 | 0.106635 | 0.0513102 | 0.000154377
4 x MEZZANINE BRACKET | PL/1402 | 1.1 | 88.2 | 437.7 | 0.0956192 | 0.0459552 | 0.000138312
4 x MEZZANINE BRACKET | PL/1399 | 0.9 | 88.2 | 381.7 | 0.0835232 | 0.0400752 | 0.000120672
2 x MEZZANINE BRACKET | PL/1396 | 1.3 | 88 | 482.7 | 0.105339 | 0.0506802 | 0.000152487
2 x MEZZANINE BRACKET | PL/1395 | 1.1 | 88.2 | 431.7 | 0.0943232 | 0.0453252 | 0.000136422
2 x MEZZANINE BRACKET | PL/1394 | 0.9 | 88.2 | 375.7 | 0.0822272 | 0.0394452 | 0.000118782
MEZZANINE BRACKET | PL/2150 | 1.3 | 88 | 513.2 | 0.111927 | 0.0538827 | 0.000162094
MEZZANINE BRACKET | PL/2141 | 1.3 | 88 | 498.7 | 0.108795 | 0.0523602 | 0.000157527
2 x MEZZANINE BRACKET | PL/2132 | 1.3 | 88 | 488.7 | 0.106635 | 0.0513102 | 0.000154377
MEZZANINE BRACKET | PL/2123 | 1.3 | 88 | 482.7 | 0.105339 | 0.0506802 | 0.000152487
MEZZANINE BRACKET | PL/2147 | 1.1 | 88 | 462.2 | 0.100911 | 0.0485277 | 0.000146029
MEZZANINE BRACKET | PL/2138 | 1.1 | 88.2 | 447.7 | 0.0977792 | 0.0470052 | 0.000141462
2 x MEZZANINE BRACKET | PL/2129 | 1.1 | 88.2 | 437.7 | 0.0956192 | 0.0459552 | 0.000138312
MEZZANINE BRACKET | PL/2122 | 1.1 | 88.2 | 431.7 | 0.0943232 | 0.0453252 | 0.000136422
MEZZANINE BRACKET | PL/2144 | 0.9 | 88.2 | 406.2 | 0.0888152 | 0.0426477 | 0.000128389
MEZZANINE BRACKET | PL/2135 | 0.9 | 88.2 | 391.7 | 0.0856832 | 0.0411252 | 0.000123822

# IfcPlate: PLT3*120 (2)
In: Undefined
Description: PLT3*120; Material: STEEL/250
Tekla Common - Bottom elevation: +1.864; Top elevation: +1.984; Phase: 1; Class: 10
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 120 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 120.001 mm; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) | GrossVolume (m3)
INLINE GIRT BRACKET | Z/1630 | 0.7 | 89 | 0.1 | 225.7 | 0.0530178 | 0.0270797 | 0.0000758956 | 0.0000817486
INLINE GIRT BRACKET | Z/350 | 0.4 | 89.1 | 0 | 152.1 | 0.0386424 | 0.0182471 | 0.0000552507 | 0.0000552507

# IfcPlate: PLT3*121 (6)
In: Undefined
Description: PLT3*121; Material: STEEL/450
Tekla Common - Bottom elevation: +1.854; Top elevation: +1.994; Phase: 1; Class: 11
Tekla Quantity - Weight: 0.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 89.4 m2; Net surface area: 0 m2; Height: 121 mm; Width: 3 mm; Length: 140 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 121.025 mm; NetArea: 0.0360358 m2; GrossArea: 0.0169435 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.0000513268 m3; GrossVolume: 0.0000513268 m3
Name | ASSEMBLY_POS = Reference
MEZZANINE BRACKET | PL/2085
4 x MEZZANINE BRACKET | PL/143
MEZZANINE BRACKET | PL/2086

# IfcPlate: PLT3*128.1 (12)
In: Undefined
Description: PLT3*128.1; Material: STEEL/450
Tekla Common - Phase: 1; Class: 11
Tekla Quantity - Weight: 0.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.1 m2; Height: 128.1 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 128.098 mm; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Area per tons (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
4 x MEZZANINE BRACKET | PL/2095 | +1.755 | +1.990 | 88.4 | 235 | 0.0634073 | 0.030103 | 0.0000914181
4 x MEZZANINE BRACKET | PL/2088 | +1.806 | +1.991 | 88.6 | 185 | 0.0500819 | 0.0236981 | 0.0000719674
MEZZANINE BRACKET | PL/2091 | +1.755 | +1.990 | 88.4 | 235 | 0.0634073 | 0.030103 | 0.0000914181
MEZZANINE BRACKET | PL/2087 | +1.806 | +1.991 | 88.6 | 185 | 0.0500819 | 0.0236981 | 0.0000719674
MEZZANINE BRACKET | PL/1390 | +1.755 | +1.990 | 88.4 | 235 | 0.0634073 | 0.030103 | 0.0000914181
MEZZANINE BRACKET | PL/1386 | +1.806 | +1.991 | 88.6 | 185 | 0.0500819 | 0.0236981 | 0.0000719674

# IfcPlate: PLT3*150 (3)
In: Undefined
Description: PLT3*150; Material: STEEL/450
Tekla Common - Bottom elevation: +1.850; Top elevation: +2.000; Phase: 1; Class: 9
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.1 m2; Height: 150 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 150 mm; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Weight (kg) | Area per tons (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
PLATE | PL/146 | 1.3 | 87.7 | 362.2 | 0.113044 | 0.0543293 | 0.000164404
PLATE | PL/145 | 1.1 | 87.7 | 311.2 | 0.0974383 | 0.0466793 | 0.000141454
PLATE | PL/144 | 0.9 | 88.4 | 238.5 | 0.0751351 | 0.0357718 | 0.00010845

# IfcPlate: PLT3*151 (36)
In: Undefined
Description: PLT3*151; Material: STEEL/450
Tekla Common - Bottom elevation: +1.823; Top elevation: +1.974; Phase: 1; Class: 11
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 151 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 151 mm; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
MEZZANINE BRACKET | PL/2145 | 1.7 | 87.3 | 0.1 | 468.2 | 0.145749 | 0.0706935 | 0.000212722
MEZZANINE BRACKET | PL/2142 | 1.5 | 87.3 | 0.1 | 412.2 | 0.128501 | 0.0622375 | 0.000187354
MEZZANINE BRACKET | PL/2136 | 1.6 | 87.3 | 0.1 | 453.7 | 0.141283 | 0.068504 | 0.000206154
MEZZANINE BRACKET | PL/2133 | 1.5 | 87.3 | 0.1 | 397.7 | 0.124035 | 0.060048 | 0.000180786
2 x MEZZANINE BRACKET | PL/2127 | 1.6 | 87.3 | 0.1 | 443.7 | 0.138203 | 0.066994 | 0.000201624
2 x MEZZANINE BRACKET | PL/2124 | 1.5 | 87.3 | 0.1 | 387.7 | 0.120955 | 0.058538 | 0.000176256
2 x MEZZANINE BRACKET | PL/1421 | 2 | 87.2 | 0.2 | 519.2 | 0.161457 | 0.0783945 | 0.000235825
2 x MEZZANINE BRACKET | PL/1412 | 1.7 | 87.2 | 0.2 | 504.7 | 0.156991 | 0.076205 | 0.000229257
4 x MEZZANINE BRACKET | PL/1403 | 1.7 | 87.2 | 0.2 | 494.7 | 0.153911 | 0.074695 | 0.000224727
2 x MEZZANINE BRACKET | PL/1418 | 1.7 | 87.3 | 0.1 | 468.2 | 0.145749 | 0.0706935 | 0.000212722
2 x MEZZANINE BRACKET | PL/1409 | 1.6 | 87.3 | 0.1 | 453.7 | 0.141283 | 0.068504 | 0.000206154
4 x MEZZANINE BRACKET | PL/1400 | 1.6 | 87.3 | 0.1 | 443.7 | 0.138203 | 0.066994 | 0.000201624
2 x MEZZANINE BRACKET | PL/1415 | 1.5 | 87.3 | 0.1 | 412.2 | 0.128501 | 0.0622375 | 0.000187354
2 x MEZZANINE BRACKET | PL/1406 | 1.5 | 87.3 | 0.1 | 397.7 | 0.124035 | 0.060048 | 0.000180786
4 x MEZZANINE BRACKET | PL/1397 | 1.5 | 87.3 | 0.1 | 387.7 | 0.120955 | 0.058538 | 0.000176256
MEZZANINE BRACKET | PL/2148 | 2 | 87.2 | 0.2 | 519.2 | 0.161457 | 0.0783945 | 0.000235825
MEZZANINE BRACKET | PL/2139 | 1.7 | 87.2 | 0.2 | 504.7 | 0.156991 | 0.076205 | 0.000229257
2 x MEZZANINE BRACKET | PL/2130 | 1.7 | 87.2 | 0.2 | 494.7 | 0.153911 | 0.074695 | 0.000224727

# IfcPlate: PLT3*152.1 (2)
In: Undefined
Description: PLT3*152.1; Material: STEEL/250
Tekla Common - Phase: 1; Class: 10
Tekla Quantity - Weight: 0.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.1 m2; Height: 152 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Area per tons (m2) | Length (mm) | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
INLINE GIRT BRACKET | Z/1669 | +1.763 | +1.983 | 88.2 | 220 | 152.064 | 0.0700785 | 0.0334542 | 0.000101295
INLINE GIRT BRACKET | Z/1631 | +1.813 | +1.984 | 88.4 | 170 | 152.06 | 0.0543614 | 0.0258512 | 0.0000782743

# IfcPlate: PLT3*170, INLINE GIRT BRACKET
In: Undefined
Description: PLT3*170; Material: STEEL/250
Default - ASSEMBLY_POS: Z/1634
Tekla Common - Bottom elevation: +1.813; Top elevation: +1.984; Phase: 1; Class: 10
Tekla Quantity - Weight: 0.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 88.2 m2; Net surface area: 0.1 m2; Height: 170 mm; Width: 3 mm; Length: 225.7 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/1634
BaseQuantities - Width: 170.006 mm; NetArea: 0.0760955 m2; GrossArea: 0.0383648 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000109957 m3; GrossVolume: 0.000115814 m3

# IfcPlate: PLT3*200 (3)
In: Undefined
Description: PLT3*200; Material: STEEL/450
Tekla Common - Bottom elevation: +1.800; Top elevation: +2.000; Phase: 1; Class: 9
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.1 m2; Height: 200 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 200 mm; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Weight (kg) | Area per tons (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
PLATE | PL/1389 | 1.7 | 87.2 | 362.2 | 0.149995 | 0.0724391 | 0.000219205
PLATE | PL/1388 | 1.5 | 87.3 | 311.2 | 0.129289 | 0.0622391 | 0.000188605
PLATE | PL/1387 | 1.1 | 87.7 | 240.2 | 0.100463 | 0.0480391 | 0.000146005

# IfcPlate: PLT3*203 (36)
In: Undefined
Description: PLT3*203; Material: STEEL/450
Tekla Common - Bottom elevation: +1.772; Top elevation: +1.974; Phase: 1; Class: 11
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.9 m2; Net surface area: 0.2 m2; Height: 203 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 203 mm; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Weight (kg) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
MEZZANINE BRACKET | PL/2143 | 2 | 412.2 | 0.171899 | 0.0836702 | 0.000251873
MEZZANINE BRACKET | PL/2134 | 2 | 397.7 | 0.165925 | 0.0807267 | 0.000243043
2 x MEZZANINE BRACKET | PL/2125 | 2 | 387.7 | 0.161805 | 0.0786967 | 0.000236953
2 x MEZZANINE BRACKET | PL/1422 | 2.4 | 519.2 | 0.215983 | 0.105391 | 0.000317036
2 x MEZZANINE BRACKET | PL/1413 | 2.4 | 504.7 | 0.210009 | 0.102448 | 0.000308206
4 x MEZZANINE BRACKET | PL/1404 | 2.4 | 494.7 | 0.205889 | 0.100418 | 0.000302116
2 x MEZZANINE BRACKET | PL/1419 | 2.2 | 468.2 | 0.194971 | 0.0950382 | 0.000285977
2 x MEZZANINE BRACKET | PL/1410 | 2.2 | 453.7 | 0.188997 | 0.0920947 | 0.000277147
4 x MEZZANINE BRACKET | PL/1401 | 2.1 | 443.7 | 0.184877 | 0.0900647 | 0.000271057
2 x MEZZANINE BRACKET | PL/1416 | 2 | 412.2 | 0.171899 | 0.0836702 | 0.000251873
2 x MEZZANINE BRACKET | PL/1407 | 2 | 397.7 | 0.165925 | 0.0807267 | 0.000243043
4 x MEZZANINE BRACKET | PL/1398 | 2 | 387.7 | 0.161805 | 0.0786967 | 0.000236953
MEZZANINE BRACKET | PL/2149 | 2.4 | 519.2 | 0.215983 | 0.105391 | 0.000317036
MEZZANINE BRACKET | PL/2140 | 2.4 | 504.7 | 0.210009 | 0.102448 | 0.000308206
2 x MEZZANINE BRACKET | PL/2131 | 2.4 | 494.7 | 0.205889 | 0.100418 | 0.000302116
MEZZANINE BRACKET | PL/2137 | 2.2 | 453.7 | 0.188997 | 0.0920947 | 0.000277147
2 x MEZZANINE BRACKET | PL/2128 | 2.1 | 443.7 | 0.184877 | 0.0900647 | 0.000271057
MEZZANINE BRACKET | PL/2146 | 2.2 | 468.2 | 0.194971 | 0.0950382 | 0.000285977

# IfcPlate: PLT3*220, INLINE GIRT BRACKET
In: Undefined
Description: PLT3*220; Material: STEEL/250
Tekla Common - Bottom elevation: +1.763; Top elevation: +1.983; Phase: 1; Class: 10
Default - ASSEMBLY_POS: Z/1671
Tekla Quantity - Weight: 1.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.7 m2; Net surface area: 0.1 m2; Height: 220 mm; Width: 3 mm; Length: 225.7 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/1671
BaseQuantities - Width: 220.001 mm; NetArea: 0.0991745 m2; GrossArea: 0.0496471 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000144021 m3; GrossVolume: 0.000149874 m3

# IfcPlate: PLT3*240.2, PLATE
In: Undefined
Description: PLT3*240.2; Material: STEEL/450
Tekla Common - Bottom elevation: +1.750; Top elevation: +2.000; Phase: 1; Class: 9
Default - ASSEMBLY_POS: PL/1391
Tekla Quantity - Weight: 1.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.3 m2; Net surface area: 0.1 m2; Height: 240.2 mm; Width: 3 mm; Length: 250 mm
Pset_PlateCommon - LoadBearing: no; Reference: PL/1391
BaseQuantities - Width: 240.196 mm; NetArea: 0.125214 m2; GrossArea: 0.0600489 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000182507 m3; GrossVolume: 0.000182507 m3

# IfcPlate: PLT3*250 (2)
In: Undefined
Description: PLT3*250; Material: STEEL/450
Tekla Common - Bottom elevation: +1.750; Top elevation: +2.000; Phase: 1; Class: 9
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.2 m2; Height: 250 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 250 mm; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Weight (kg) | Area per tons (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
PLATE | PL/1393 | 2.2 | 86.9 | 362.2 | 0.186946 | 0.0905489 | 0.000274007
PLATE | PL/1392 | 2 | 87.2 | 311.2 | 0.16114 | 0.0777989 | 0.000235757
