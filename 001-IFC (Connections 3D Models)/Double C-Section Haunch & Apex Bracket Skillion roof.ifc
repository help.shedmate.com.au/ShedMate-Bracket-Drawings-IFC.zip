Properties of the parts of a building model (IFC2X3), part 2 of 2

# IfcPlate: PLT3*361.2 (2)
BaseQuantities - NetArea: 0.27928 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000411573 m3; GrossVolume: 0.000411573 m3
Name | ASSEMBLY_POS = Reference | Width (mm) | GrossArea (m2)
PLATE | Z/1228 | 361.189 | 0.173655
PLATE | Z/348 | 361.196 | 0.173659

# IfcPlate: PLT3*373.5 (2)
In: Undefined
Description: PLT3*373.5; Material: STEEL/450
Tekla Common - Bottom elevation: +5.113; Top elevation: +5.419; Phase: 1; Class: 11
Tekla Quantity - Weight: 3.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.4 m2; Net surface area: 0.3 m2; Height: 373.5 mm; Width: 3 mm; Length: 458.5 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 373.514 mm; NetArea: 0.284026 m2; GrossArea: 0.171267 m2; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | NetVolume (m3) = GrossVolume (m3)
PLATE | Z/841 | 0.000418658
PLATE | Z/843 | 0.00041866

# IfcPlate: PLT3*382 (2)
In: Undefined
Description: PLT3*382; Material: STEEL/450
Tekla Common - Bottom elevation: +5.385; Top elevation: +5.700; Phase: 1; Class: 11
Tekla Quantity - Weight: 3.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.4 m2; Net surface area: 0.3 m2; Height: 382 mm; Width: 3 mm; Length: 457.9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - NetArea: 0.290629 m2; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Width (mm) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
PLATE | Z/1230 | 381.982 | 0.174902 | 0.000428496
PLATE | Z/844 | 381.984 | 0.174903 | 0.000428495

# IfcPlate: PLT3*394.6 (2)
In: Undefined
Description: PLT3*394.6; Material: STEEL/450
Tekla Common - Bottom elevation: +4.689; Top elevation: +5.029; Phase: 1; Class: 11
Tekla Quantity - Weight: 4.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.1 m2; Net surface area: 0.3 m2; Height: 394.6 mm; Width: 3 mm; Length: 599.2 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - NetArea: 0.40344 m2; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Width (mm) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
PLATE | Z/1068(?) | 394.617 | 0.23644 | 0.000596164
PLATE | Z/1307(?) | 394.62 | 0.236442 | 0.000596163

# IfcPlate: PLT3*396.7 (2)
In: Undefined
Description: PLT3*396.7; Material: STEEL/450
Tekla Common - Bottom elevation: +6.372; Top elevation: +6.700; Phase: 1; Class: 11
Tekla Quantity - Weight: 3.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.4 m2; Net surface area: 0.3 m2; Height: 396.7 mm; Width: 3 mm; Length: 470.4 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 396.7 mm; NetArea: 0.300701 m2; GrossArea: 0.186604 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000443447 m3; GrossVolume: 0.000443447 m3
Name | ASSEMBLY_POS = Reference
PLATE | Z/1234
PLATE | Z/842

# IfcPlate: PLT3*399.6 (2)
In: Undefined
Description: PLT3*399.6; Material: STEEL/450
Tekla Common - Bottom elevation: +5.935; Top elevation: +6.267; Phase: 1; Class: 11
Tekla Quantity - Weight: 3.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.4 m2; Net surface area: 0.3 m2; Height: 399.6 mm; Width: 3 mm; Length: 462 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 399.566 mm; NetArea: 0.303881 m2; GrossArea: 0.184619 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000448243 m3; GrossVolume: 0.000448243 m3
Name | ASSEMBLY_POS = Reference
PLATE | Z/1231
PLATE | Z/845

# IfcPlate: PLT3*402.7 (2)
In: Undefined
Description: PLT3*402.7; Material: STEEL/450
Tekla Common - Bottom elevation: +4.689; Top elevation: +5.049; Phase: 1; Class: 11
Tekla Quantity - Weight: 4.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.1 m2; Net surface area: 0.3 m2; Height: 402.7 mm; Width: 3 mm; Length: 611.3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - NetArea: 0.414221 m2; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Width (mm) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
PLATE | Z/1067(?) | 402.718 | 0.2462 | 0.000612245
PLATE | Z/873(?) | 402.714 | 0.246197 | 0.000612246

# IfcPlate: PLT3*417.5 (2)
In: Undefined
Description: PLT3*417.5; Material: STEEL/450
Tekla Common - Bottom elevation: +4.689; Top elevation: +5.089; Phase: 1; Class: 11
Tekla Quantity - Weight: 5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.1 m2; Net surface area: 0.3 m2; Height: 417.5 mm; Width: 3 mm; Length: 637.2 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - NetArea: 0.434362 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000642282 m3; GrossVolume: 0.000642282 m3
Name | ASSEMBLY_POS = Reference | Width (mm) | GrossArea (m2)
PLATE | Z/1293(?) | 417.541 | 0.266066
PLATE | Z/875(?) | 417.54 | 0.266065

# IfcPlate: PLT3*430.3 (2)
In: Undefined
Description: PLT3*430.3; Material: STEEL/450
Tekla Common - Bottom elevation: +5.058; Top elevation: +5.419; Phase: 1; Class: 11
Tekla Quantity - Weight: 5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.1 m2; Net surface area: 0.3 m2; Height: 430.3 mm; Width: 3 mm; Length: 587.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 430.303 mm; NetArea: 0.434181 m2; GrossArea: 0.252832 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000642069 m3; GrossVolume: 0.000642069 m3
Name | ASSEMBLY_POS = Reference
PLATE | Z/1069(?)
PLATE | Z/1057(?)

# IfcPlate: PLT3*456.7 (2)
In: Undefined
Description: PLT3*456.7; Material: STEEL/450
Tekla Common - Bottom elevation: +5.311; Top elevation: +5.700; Phase: 1; Class: 11
Tekla Quantity - Weight: 5.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.1 m2; Net surface area: 0.5 m2; Height: 456.7 mm; Width: 3 mm; Length: 590.3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 456.683 mm; NetArea: 0.459415 m2; GrossArea: 0.269558 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000679736 m3; GrossVolume: 0.000679736 m3
Name | ASSEMBLY_POS = Reference
PLATE | Z/1301(?)
PLATE | Z/871(?)

# IfcPlate: PLT3*466.6 (2)
In: Undefined
Description: PLT3*466.6; Material: STEEL/450
Tekla Common - Bottom elevation: +5.869; Top elevation: +6.267; Phase: 1; Class: 11
Tekla Quantity - Weight: 5.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.1 m2; Net surface area: 0.5 m2; Height: 466.6 mm; Width: 3 mm; Length: 605 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 466.569 mm; NetArea: 0.469213 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000694353 m3; GrossVolume: 0.000694353 m3
Name | ASSEMBLY_POS = Reference | GrossArea (m2)
PLATE | Z/1300(?) | 0.282264
PLATE | Z/874(?) | 0.282265

# IfcPlate: PLT3*496.2 (2)
In: Undefined
Description: PLT3*496.2; Material: STEEL/450
Tekla Common - Bottom elevation: +6.272; Top elevation: +6.700; Phase: 1; Class: 11
Tekla Quantity - Weight: 5.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.1 m2; Net surface area: 0.5 m2; Height: 496.2 mm; Width: 3 mm; Length: 615.1 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 496.203 mm; NetArea: 0.496119 m2; GrossArea: 0.305235 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000734453 m3; GrossVolume: 0.000734453 m3
Name | ASSEMBLY_POS = Reference
PLATE | Z/1302(?)
PLATE | Z/869(?)

# IfcPlate: PLT3*529.2 (2)
In: Undefined
Description: PLT3*529.2; Material: STEEL/450
Tekla Common - Bottom elevation: +4.574; Top elevation: +5.038; Phase: 1; Class: 11
Tekla Quantity - Weight: 7.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.6 m2; Height: 529.2 mm; Width: 3 mm; Length: 779.7 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - NetArea: 0.683154 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00101308 m3; GrossVolume: 0.00101308 m3
Name | ASSEMBLY_POS = Reference | Width (mm) | GrossArea (m2)
PLATE | Z/1360(?) | 529.203 | 0.412626
PLATE | Z/1378(?) | 529.206 | 0.412629

# IfcPlate: PLT3*538.5 (2)
In: Undefined
Description: PLT3*538.5; Material: STEEL/450
Tekla Common - Bottom elevation: +4.574; Top elevation: +5.064; Phase: 1; Class: 11
Tekla Quantity - Weight: 8.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.6 m2; Height: 538.5 mm; Width: 3 mm; Length: 796 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - NetArea: 0.69912 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00103692 m3; GrossVolume: 0.00103692 m3
Name | ASSEMBLY_POS = Reference | Width (mm) | GrossArea (m2)
PLATE | Z/1361(?) | 538.535 | 0.428679
PLATE | Z/902(?) | 538.531 | 0.428675

# IfcPlate: PLT3*555.7 (2)
In: Undefined
Description: PLT3*555.7; Material: STEEL/450
Tekla Common - Bottom elevation: +4.575; Top elevation: +5.115; Phase: 1; Class: 11
Tekla Quantity - Weight: 8.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.6 m2; Height: 555.7 mm; Width: 3 mm; Length: 829 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 555.705 mm; NetArea: 0.731391 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00108508 m3; GrossVolume: 0.00108508 m3
Name | ASSEMBLY_POS = Reference | GrossArea (m2)
PLATE | Z/1362(?) | 0.460689
PLATE | Z/903(?) | 0.460688

# IfcPlate: PLT3*562.6 (2)
In: Undefined
Description: PLT3*562.6; Material: STEEL/450
Tekla Common - Bottom elevation: +4.574; Top elevation: +5.041; Phase: 1; Class: 11
Tekla Quantity - Weight: 9.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.8 m2; Height: 562.6 mm; Width: 3 mm; Length: 825.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000009 m2; NetVolume: 0.0011504 m3; GrossVolume: 0.0011504 m3
Name | ASSEMBLY_POS = Reference | Width (mm) | NetArea (m2) | GrossArea (m2)
PLATE | Z/1440(?) | 562.596 | 0.775279 | 0.464453
PLATE | Z/1451(?) | 562.595 | 0.775278 | 0.464452

# IfcPlate: PLT3*570 (2)
In: Undefined
Description: PLT3*570; Material: STEEL/450
Tekla Common - Bottom elevation: +4.936; Top elevation: +5.419; Phase: 1; Class: 11
Tekla Quantity - Weight: 8.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.6 m2; Height: 570 mm; Width: 3 mm; Length: 761.7 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - NetArea: 0.725868 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00107692 m3; GrossVolume: 0.00107692 m3
Name | ASSEMBLY_POS = Reference | Width (mm) | GrossArea (m2)
PLATE | Z/1369(?) | 570.034 | 0.43421
PLATE | Z/1377(?) | 570.035 | 0.434211

# IfcPlate: PLT3*573.5 (2)
In: Undefined
Description: PLT3*573.5; Material: STEEL/450
Tekla Common - Bottom elevation: +4.574; Top elevation: +5.068; Phase: 1; Class: 11
Tekla Quantity - Weight: 9.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.8 m2; Height: 573.5 mm; Width: 3 mm; Length: 843.2 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 573.52 mm; NetArea: 0.795105 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00118002 m3; GrossVolume: 0.00118002 m3
Name | ASSEMBLY_POS = Reference | GrossArea (m2)
PLATE | Z/1441(?) | 0.483605
PLATE | Z/930(?) | 0.483604

# IfcPlate: PLT3*589.9 (2)
In: Undefined
Description: PLT3*589.9; Material: STEEL/450
Tekla Common - Bottom elevation: +5.765; Top elevation: +6.267; Phase: 1; Class: 11
Tekla Quantity - Weight: 8.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.6 m2; Height: 589.9 mm; Width: 3 mm; Length: 771.8 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - NetArea: 0.748799 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00111118 m3; GrossVolume: 0.00111118 m3
Name | ASSEMBLY_POS = Reference | Width (mm) | GrossArea (m2)
PLATE | Z/1371(?) | 589.896 | 0.455257
PLATE | Z/900(?) | 589.901 | 0.455261

# IfcPlate: PLT3*593.8 (2)
In: Undefined
Description: PLT3*593.8; Material: STEEL/450
Tekla Common - Bottom elevation: +4.574; Top elevation: +5.123; Phase: 1; Class: 11
Tekla Quantity - Weight: 9.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.8 m2; Height: 593.8 mm; Width: 3 mm; Length: 878.7 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - NetArea: 0.835641 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00124058 m3; GrossVolume: 0.00124058 m3
Name | ASSEMBLY_POS = Reference | Width (mm) | GrossArea (m2)
PLATE | Z/1433(?) | 593.82 | 0.521792
PLATE | Z/932(?) | 593.827 | 0.521799

# IfcPlate: PLT3*606 (2)
In: Undefined
Description: PLT3*606; Material: STEEL/450
Tekla Common - Bottom elevation: +4.930; Top elevation: +5.419; Phase: 1; Class: 11
Tekla Quantity - Weight: 9.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.8 m2; Height: 606 mm; Width: 3 mm; Length: 809.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - NetArea: 0.825728 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00122582 m3; GrossVolume: 0.00122582 m3
Name | ASSEMBLY_POS = Reference | Width (mm) | GrossArea (m2)
PLATE | Z/1445(?) | 605.985 | 0.49061
PLATE | Z/1450(?) | 605.983 | 0.490608

# IfcPlate: PLT3*613.5 (2)
In: Undefined
Description: PLT3*613.5; Material: STEEL/450
Tekla Common - Bottom elevation: +5.171; Top elevation: +5.700; Phase: 1; Class: 11
Tekla Quantity - Weight: 9.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.8 m2; Height: 613.5 mm; Width: 3 mm; Length: 766.2 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000009 m2; NetVolume: 0.00115449 m3; GrossVolume: 0.00115449 m3
Name | ASSEMBLY_POS = Reference | Width (mm) | NetArea (m2) | GrossArea (m2)
PLATE | Z/1370(?) | 613.523 | 0.777789 | 0.470081
PLATE | Z/899(?) | 613.526 | 0.77779 | 0.470084

# IfcPlate: PLT3*615.6 (2)
In: Undefined
Description: PLT3*615.6; Material: STEEL/450
Tekla Common - Bottom elevation: +6.173; Top elevation: +6.700; Phase: 1; Class: 11
Tekla Quantity - Weight: 9.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.8 m2; Height: 615.6 mm; Width: 3 mm; Length: 783.2 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 615.642 mm; NetArea: 0.776955 m2; GrossArea: 0.48217 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00115317 m3; GrossVolume: 0.00115317 m3
Name | ASSEMBLY_POS = Reference
PLATE | Z/1372(?)
PLATE | Z/897(?)

# IfcPlate: PLT3*644.9 (2)
In: Undefined
Description: PLT3*644.9; Material: STEEL/450
Tekla Common - Bottom elevation: +5.170; Top elevation: +5.700; Phase: 1; Class: 11
Tekla Quantity - Weight: 10.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.8 m2; Height: 644.9 mm; Width: 3 mm; Length: 815.2 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - NetArea: 0.877296 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.0013029 m3; GrossVolume: 0.0013029 m3
Name | ASSEMBLY_POS = Reference | Width (mm) | GrossArea (m2)
PLATE | Z/1443(?) | 644.925 | 0.525727
PLATE | Z/928(?) | 644.926 | 0.525728

# IfcPlate: PLT3*668.3, PLATE
In: Undefined
Description: PLT3*668.3; Material: STEEL/450
Tekla Common - Bottom elevation: +5.715; Top elevation: +6.267; Phase: 1; Class: 11
Default - ASSEMBLY_POS: Z/931(?)
Tekla Quantity - Weight: 10.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.8 m2; Height: 668.3 mm; Width: 3 mm; Length: 829.6 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/931(?)
BaseQuantities - Width: 668.348 mm; NetArea: 0.908001 m2; GrossArea: 0.554431 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00134879 m3; GrossVolume: 0.00134879 m3

# IfcPlate: PLT3*668.4, PLATE
In: Undefined
Description: PLT3*668.4; Material: STEEL/450
Default - ASSEMBLY_POS: Z/1442(?)
Tekla Common - Bottom elevation: +5.715; Top elevation: +6.267; Phase: 1; Class: 11
Tekla Quantity - Weight: 10.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.8 m2; Height: 668.4 mm; Width: 3 mm; Length: 829.6 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/1442(?)
BaseQuantities - Width: 668.353 mm; NetArea: 0.908002 m2; GrossArea: 0.554436 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00134879 m3; GrossVolume: 0.00134879 m3

# IfcPlate: PLT3*693.6 (2)
In: Undefined
Description: PLT3*693.6; Material: STEEL/450
Tekla Common - Bottom elevation: +6.123; Top elevation: +6.700; Phase: 1; Class: 11
Tekla Quantity - Weight: 11 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.7 m2; Net surface area: 0.8 m2; Height: 693.6 mm; Width: 3 mm; Length: 843.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 693.603 mm; NetArea: 0.939159 m2; GrossArea: 0.585119 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00139527 m3; GrossVolume: 0.00139527 m3
Name | ASSEMBLY_POS = Reference
PLATE | Z/1444(?)
PLATE | Z/927(?)
