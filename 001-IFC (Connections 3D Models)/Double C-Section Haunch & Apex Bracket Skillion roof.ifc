Properties of the parts of a building model (IFC2X3), part 1 of 2

# File
Description: ViewDefinition[CoordinationView_V2.0, QuantityTakeOffAddOnView], Option [BaseQuantities:On], Option [GridExport:On], Option [Assemblies:On], Option [Bolts:On], Option [Rebars:On], Option [PourObjects:Off], Option [Welds:Off], Option [SurfaceTreatments:Off], Option [LocationBy:0], Option [ViewColors:Off], Option [SectionedSpine:Off], Option [PropertySets:On], Option [Export all:Off]
File name: Double C-Section Haunch & Apex Bracket Skillion roof.ifc
Time: 2026-03-26T08:51:41
Author: DESKTOP-BKNQL56\admin
Organization: Structural Designer
Written by: IFC Database Version: Work
Made in: Tekla Structures 2019 Service Pack 13, IFC Export Version: 4.0.0.0 Oct 18 2021

# IfcBuildingStorey, Undefined
In: Undefined
Elevation: 0 mm

# IfcBeam: C:150-15 (35)
In: Undefined
Description: C:150-15; Material: STEEL/300PLUS
Default - ASSEMBLY_POS: Z/561
Tekla Common - Phase: 1; Class: 13
Tekla Quantity - Weight: 3.5 kg; Volume: 0 m3; Gross footprint area: 0.1 m2; Area per tons: 176.5 m2; Net surface area: 0.6 m2; Height: 152 mm; Width: 64 mm; Length: 1000 mm
Pset_BeamCommon - LoadBearing: no; Reference: Z/561
BaseQuantities - Length: 1000 mm; OuterSurfaceArea: 0.613915 m2; NetVolume: 0.0004575 m3; NetWeight: 3.59138 kg
Name | Bottom elevation | Top elevation
FASCIA | +6.702 | +6.854
FASCIA | +6.691 | +6.843
FASCIA | +6.681 | +6.833
FASCIA | +6.670 | +6.822
FASCIA | +6.660 | +6.812
FASCIA | +6.248 | +6.400
5 x FASCIA | +4.912 | +5.064
FASCIA | +6.240 | +6.392
FASCIA | +6.233 | +6.385
FASCIA | +6.225 | +6.377
FASCIA | +6.217 | +6.369
FASCIA | +5.655 | +5.807
2 x FASCIA | +4.917 | +5.069
FASCIA | +5.650 | +5.802
FASCIA | +5.646 | +5.798
3 x FASCIA | +4.916 | +5.068
FASCIA | +5.642 | +5.794
FASCIA | +5.637 | +5.789
FASCIA | +5.361 | +5.513
FASCIA | +5.359 | +5.511
FASCIA | +5.356 | +5.508
FASCIA | +5.353 | +5.505
5 x FASCIA | +4.919 | +5.071
FASCIA | +5.351 | +5.503

# IfcBeam: C:150-24 (15)
In: Undefined
Description: C:150-24; Material: STEEL/G450
Tekla Common - Phase: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 111.2 m2; Height: 152 mm; Width: 64 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Finish | Bottom elevation | Top elevation | Class | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x RAFTER | Z/1102 | 12 deg | +4.886 | +6.691 | 1 | 44.4 | 4.9 | 7970.6 | 7970.57 | 4.94004 | 0.00588037 | 46.1609
COLUMN | Z/1105 | 12 deg | +0.000 | +6.812 | 10 | 38 | 4.2 | 6811.6 | 6811.57 | 4.22192 | 0.0050253 | 39.4486
RAFTER | Z/1081 | 9 deg | +4.875 | +6.261 | 1 | 44 | 4.9 | 7901.5 | 7901.5 | 4.89725 | 0.00582941 | 45.7609
COLUMN | Z/1078 | 9 deg | +0.000 | +5.066 | 10 | 28.2 | 3.1 | 5066.4 | 5066.36 | 3.14059 | 0.00373776 | 29.3414
COLUMN | Z/1190 | 9 deg | +0.000 | +6.371 | 10 | 35.5 | 3.9 | 6371.1 | 6371.13 | 3.94903 | 0.00470037 | 36.8979
RAFTER | Z/1189 | 9 deg | +4.875 | +6.261 | 1 | 44 | 4.9 | 7901.5 | 7901.5 | 4.89725 | 0.00582941 | 45.7609
RAFTER | Z/1072 | 5 deg | +4.862 | +5.698 | 1 | 43.7 | 4.9 | 7844.6 | 7844.6 | 4.86199 | 0.00578743 | 45.4314
COLUMN | Z/1050 | 5 deg | +0.000 | +5.071 | 10 | 28.2 | 3.1 | 5070.9 | 5071.03 | 3.14349 | 0.0037412 | 29.3684
COLUMN | Z/1187 | 5 deg | +0.000 | +5.792 | 10 | 32.3 | 3.6 | 5791.8 | 5791.76 | 3.59005 | 0.00427293 | 33.5425
RAFTER | Z/1186 | 5 deg | +4.862 | +5.698 | 1 | 43.7 | 4.9 | 7844.6 | 7844.6 | 4.86199 | 0.00578743 | 45.4314
RAFTER | Z/1044 | 3 deg | +4.856 | +5.418 | 1 | 43.6 | 4.9 | 7830.8 | 7830.76 | 4.85342 | 0.00577722 | 45.3512
COLUMN | Z/1041 | 3 deg | +0.000 | +5.074 | 10 | 28.2 | 3.1 | 5073.6 | 5073.57 | 3.14506 | 0.00374308 | 29.3832
COLUMN | Z/1184 | 3 deg | +0.000 | +5.505 | 10 | 30.7 | 3.4 | 5505.3 | 5505.3 | 3.41256 | 0.00406159 | 31.8835
RAFTER | Z/1183 | 3 deg | +4.856 | +5.418 | 1 | 43.6 | 4.9 | 7830.8 | 7830.76 | 4.85342 | 0.00577722 | 45.3512

# IfcBeam: C:200-24 (15)
In: Undefined
Description: C:200-24; Material: STEEL/G450
Tekla Common - Phase: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 110 m2; Height: 203 mm; Width: 76 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Finish | Bottom elevation | Top elevation | Class | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x RAFTER | Z/1209 | 12 deg | +4.846 | +6.689 | 1 | 56.1 | 6.2 | 7907.6 | 7907.59 | 6.16662 | 0.00735216 | 57.7145
COLUMN | Z/1210 | 12 deg | +0.000 | +6.825 | 10 | 48.4 | 5.3 | 6824.9 | 6824.93 | 5.32257 | 0.00634555 | 49.8125
RAFTER | Z/1207 | 9 deg | +4.833 | +6.260 | 1 | 55.6 | 6.2 | 7841.8 | 7841.79 | 6.11532 | 0.00729098 | 57.2342
COLUMN | Z/1206 | 9 deg | +0.000 | +5.066 | 10 | 35.9 | 3.9 | 5066.4 | 5066.35 | 3.95159 | 0.00471049 | 36.9773
COLUMN | Z/1255 | 9 deg | +0.000 | +6.379 | 10 | 45.2 | 4.9 | 6379.2 | 6379.2 | 4.97508 | 0.00593113 | 46.5593
RAFTER | Z/1254 | 9 deg | +4.833 | +6.260 | 1 | 55.6 | 6.2 | 7841.8 | 7841.79 | 6.11532 | 0.00729098 | 57.2342
RAFTER | Z/1204 | 5 deg | +4.816 | +5.697 | 1 | 55.2 | 6.2 | 7788.9 | 7788.95 | 6.07412 | 0.00724185 | 56.8486
COLUMN | Z/1203 | 5 deg | +0.000 | +5.071 | 10 | 35.9 | 3.9 | 5070.9 | 5071.01 | 3.95522 | 0.00471482 | 37.0114
COLUMN | Z/1252 | 5 deg | +0.000 | +5.796 | 10 | 41.1 | 4.5 | 5796.2 | 5796.21 | 4.52058 | 0.00538908 | 42.3043
RAFTER | Z/1251 | 5 deg | +4.816 | +5.697 | 1 | 55.2 | 6.2 | 7788.9 | 7788.95 | 6.07412 | 0.00724185 | 56.8486
RAFTER | Z/1201 | 3 deg | +4.808 | +5.418 | 1 | 55.1 | 6.2 | 7777 | 7777.03 | 6.06483 | 0.00723077 | 56.7616
COLUMN | Z/1200 | 3 deg | +0.000 | +5.073 | 10 | 36 | 3.9 | 5073.4 | 5073.47 | 3.95714 | 0.00471711 | 37.0293
COLUMN | Z/1249 | 3 deg | +0.000 | +5.508 | 10 | 39 | 4.2 | 5507.9 | 5507.88 | 4.2958 | 0.00512101 | 40.1999
RAFTER | Z/1248 | 3 deg | +4.808 | +5.418 | 1 | 55.1 | 6.2 | 7777 | 7777.03 | 6.06483 | 0.00723077 | 56.7616

# IfcBeam: C:250-24 (15)
In: Undefined
Description: C:250-24; Material: STEEL/G450
Tekla Common - Phase: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 109.7 m2; Height: 254 mm; Width: 76 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Finish | Bottom elevation | Top elevation | Class | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x RAFTER | Z/1276(?) | 12 deg | +4.807 | +6.687 | 1 | 62.9 | 6.9 | 7844.6 | 7844.61 | 6.90222 | 0.00823496 | 64.6444
COLUMN | Z/1277(?) | 12 deg | +0.000 | +6.836 | 10 | 54.8 | 6 | 6835.7 | 6835.66 | 6.01475 | 0.0071758 | 56.3301
RAFTER | Z/1274(?) | 9 deg | +4.791 | +6.259 | 1 | 62.4 | 6.9 | 7782.1 | 7782.08 | 6.84721 | 0.00816931 | 64.1291
COLUMN | Z/1273(?) | 9 deg | +0.000 | +5.066 | 10 | 40.6 | 4.5 | 5066.2 | 5066.24 | 4.45836 | 0.00531834 | 41.7489
COLUMN | Z/1323(?) | 9 deg | +0.000 | +6.387 | 10 | 51.2 | 5.6 | 6387.2 | 6387.17 | 5.62025 | 0.006705 | 52.6342
RAFTER | Z/1322(?) | 9 deg | +4.791 | +6.259 | 1 | 62.4 | 6.9 | 7782.1 | 7782.08 | 6.84721 | 0.00816931 | 64.1291
RAFTER | Z/1271(?) | 5 deg | +4.770 | +5.697 | 1 | 62 | 6.9 | 7733.3 | 7733.29 | 6.8043 | 0.0081181 | 63.7271
COLUMN | Z/1270(?) | 5 deg | +0.000 | +5.071 | 10 | 40.7 | 4.5 | 5070.9 | 5070.92 | 4.46248 | 0.00532325 | 41.7875
COLUMN | Z/1320(?) | 5 deg | +0.000 | +5.801 | 10 | 46.5 | 5.1 | 5800.6 | 5800.58 | 5.10429 | 0.00608922 | 47.8004
RAFTER | Z/1319(?) | 5 deg | +4.770 | +5.697 | 1 | 62 | 6.9 | 7733.3 | 7733.29 | 6.8043 | 0.0081181 | 63.7271
RAFTER | Z/1268(?) | 3 deg | +4.760 | +5.418 | 1 | 62 | 6.9 | 7723.3 | 7723.3 | 6.79551 | 0.00810761 | 63.6447
COLUMN | Z/1267(?) | 3 deg | +0.000 | +5.073 | 10 | 40.7 | 4.5 | 5073.4 | 5073.37 | 4.46464 | 0.00532582 | 41.8077
COLUMN | Z/1317(?) | 3 deg | +0.000 | +5.510 | 10 | 44.2 | 4.9 | 5510.5 | 5510.45 | 4.84909 | 0.00578465 | 45.4095
RAFTER | Z/1316(?) | 3 deg | +4.760 | +5.418 | 1 | 62 | 6.9 | 7723.3 | 7723.3 | 6.79551 | 0.00810761 | 63.6447

# IfcBeam: C:300-30 (15)
In: Undefined
Description: C:300-30; Material: STEEL/G450
Tekla Common - Phase: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.4 m2; Height: 300 mm; Width: 96 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Finish | Bottom elevation | Top elevation | Class | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x RAFTER | Z/1343(?) | 12 deg | +4.772 | +6.685 | 1 | 97.4 | 8.5 | 7787.8 | 7787.8 | 8.50753 | 0.0126863 | 99.5877
COLUMN | Z/1344(?) | 12 deg | +0.000 | +6.845 | 10 | 85.6 | 7.5 | 6845.3 | 6845.31 | 7.47834 | 0.011151 | 87.5354
RAFTER | Z/1341(?) | 9 deg | +4.753 | +6.258 | 1 | 96.6 | 8.3 | 7728.2 | 7728.22 | 8.44247 | 0.0125893 | 98.8258
COLUMN | Z/1340(?) | 9 deg | +0.000 | +5.067 | 10 | 63.4 | 5.5 | 5066.6 | 5066.64 | 5.53603 | 0.00825356 | 64.7904
COLUMN | Z/1394(?) | 9 deg | +0.000 | +6.395 | 10 | 80 | 6.9 | 6394.9 | 6394.85 | 6.98643 | 0.0104172 | 81.7751
RAFTER | Z/1393(?) | 9 deg | +4.753 | +6.258 | 1 | 96.6 | 8.3 | 7728.2 | 7728.22 | 8.44247 | 0.0125893 | 98.8258
RAFTER | Z/1338(?) | 5 deg | +4.728 | +5.697 | 1 | 96.1 | 8.3 | 7683.1 | 7683.09 | 8.39319 | 0.0125158 | 98.2487
COLUMN | Z/1337(?) | 5 deg | +0.000 | +5.071 | 10 | 63.4 | 5.5 | 5071.3 | 5071.31 | 5.54113 | 0.00826116 | 64.8501
COLUMN | Z/1391(?) | 5 deg | +0.000 | +5.805 | 10 | 72.6 | 6.3 | 5805 | 5804.99 | 6.34231 | 0.00945633 | 74.2322
RAFTER | Z/1390(?) | 5 deg | +4.728 | +5.697 | 1 | 96.1 | 8.3 | 7683.1 | 7683.09 | 8.39319 | 0.0125158 | 98.2487
RAFTER | Z/1335(?) | 3 deg | +4.717 | +5.418 | 1 | 96 | 8.3 | 7674.8 | 7674.83 | 8.38417 | 0.0125023 | 98.143
COLUMN | Z/1334(?) | 3 deg | +0.000 | +5.074 | 10 | 63.4 | 5.5 | 5073.8 | 5073.76 | 5.5438 | 0.00826516 | 64.8815
COLUMN | Z/1388(?) | 3 deg | +0.000 | +5.513 | 10 | 68.9 | 6 | 5513.3 | 5513.25 | 6.02373 | 0.00898108 | 70.5015
RAFTER | Z/1387(?) | 3 deg | +4.717 | +5.418 | 1 | 96 | 8.3 | 7674.8 | 7674.83 | 8.38417 | 0.0125023 | 98.143

# IfcBeam: C:350-30 (15)
In: Undefined
Description: C:350-30; Material: STEEL/G450
Tekla Common - Phase: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.1 m2; Height: 350 mm; Width: 125 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Finish | Bottom elevation | Top elevation | Class | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x RAFTER | Z/1414(?) | 12 deg | +4.734 | +6.683 | 1 | 115.5 | 10.1 | 7726.1 | 7726.05 | 10.0632 | 0.0150194 | 117.903
COLUMN | Z/1415(?) | 12 deg | +0.000 | +6.856 | 10 | 102.5 | 8.9 | 6856.2 | 6856.17 | 8.93062 | 0.0133284 | 104.628
RAFTER | Z/1412(?) | 9 deg | +4.711 | +6.257 | 1 | 114.7 | 10 | 7669.7 | 7669.67 | 9.9898 | 0.0149098 | 117.042
COLUMN | Z/1411(?) | 9 deg | +0.000 | +5.067 | 10 | 75.7 | 6.6 | 5066.6 | 5066.65 | 6.60066 | 0.00984956 | 77.3191
COLUMN | Z/1467(?) | 9 deg | +0.000 | +6.403 | 10 | 95.7 | 8.3 | 6402.8 | 6402.78 | 8.3403 | 0.012447 | 97.7089
RAFTER | Z/1466(?) | 9 deg | +4.711 | +6.257 | 1 | 114.7 | 10 | 7669.7 | 7669.67 | 9.9898 | 0.0149098 | 117.042
RAFTER | Z/1409(?) | 5 deg | +4.683 | +5.696 | 1 | 114.1 | 10 | 7628.5 | 7628.52 | 9.93622 | 0.0148298 | 116.414
COLUMN | Z/1408(?) | 5 deg | +0.000 | +5.071 | 10 | 75.7 | 6.6 | 5071.3 | 5071.32 | 6.60674 | 0.00985864 | 77.3903
COLUMN | Z/1464(?) | 5 deg | +0.000 | +5.809 | 10 | 86.9 | 7.6 | 5809.4 | 5809.38 | 7.5677 | 0.0112934 | 88.6534
RAFTER | Z/1463(?) | 5 deg | +4.683 | +5.696 | 1 | 114.1 | 10 | 7628.5 | 7628.52 | 9.93622 | 0.0148298 | 116.414
RAFTER | Z/1406(?) | 3 deg | +4.669 | +5.418 | 1 | 114 | 10 | 7622.1 | 7622.13 | 9.9279 | 0.0148174 | 116.317
COLUMN | Z/1405(?) | 3 deg | +0.000 | +5.074 | 10 | 75.9 | 6.6 | 5073.8 | 5073.78 | 6.60995 | 0.00986342 | 77.4279
COLUMN | Z/1461(?) | 3 deg | +0.000 | +5.516 | 10 | 82.5 | 7.2 | 5515.9 | 5515.89 | 7.18557 | 0.0107229 | 84.1746
RAFTER | Z/1460(?) | 3 deg | +4.669 | +5.418 | 1 | 114 | 10 | 7622.1 | 7622.13 | 9.9279 | 0.0148174 | 116.317

# IfcBeam: PLT1.6*60 (70)
In: Undefined
Description: PLT1.6*60; Material: STEEL/250
Default - ASSEMBLY_POS: Z/52
Tekla Common - Phase: 1; Class: 12
Tekla Quantity - Weight: 0.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 164.6 m2; Net surface area: 0 m2; Height: 60 mm; Width: 1.6 mm; Length: 297.9 mm
Pset_BeamCommon - LoadBearing: no; Reference: Z/52
BaseQuantities - Length: 297.881 mm; OuterSurfaceArea: 0.0371807 m2; NetVolume: 0.0000287808 m3; NetWeight: 0.225929 kg
Name | Bottom elevation | Top elevation
2 x FASCIA BRACKET | +6.699 | +6.856
2 x FASCIA BRACKET | +6.246 | +6.403
4 x FASCIA BRACKET | +4.909 | +5.067
2 x FASCIA BRACKET | +5.652 | +5.809
10 x FASCIA BRACKET | +4.914 | +5.071
2 x FASCIA BRACKET | +5.359 | +5.516
4 x FASCIA BRACKET | +4.917 | +5.074
2 x FASCIA BRACKET | +6.688 | +6.845
2 x FASCIA BRACKET | +6.238 | +6.395
2 x FASCIA BRACKET | +5.648 | +5.805
2 x FASCIA BRACKET | +5.356 | +5.513
2 x FASCIA BRACKET | +6.678 | +6.836
2 x FASCIA BRACKET | +6.230 | +6.387
6 x FASCIA BRACKET | +4.909 | +5.066
2 x FASCIA BRACKET | +5.643 | +5.801
2 x FASCIA BRACKET | +5.353 | +5.510
4 x FASCIA BRACKET | +4.916 | +5.073
2 x FASCIA BRACKET | +5.351 | +5.508
2 x FASCIA BRACKET | +5.639 | +5.796
2 x FASCIA BRACKET | +6.222 | +6.379
2 x FASCIA BRACKET | +6.668 | +6.825
2 x FASCIA BRACKET | +6.657 | +6.814
2 x FASCIA BRACKET | +6.214 | +6.371
2 x FASCIA BRACKET | +5.635 | +5.792
2 x FASCIA BRACKET | +5.348 | +5.505
2 x FASCIA BRACKET | +4.916 | +5.074

# IfcBeam: PLT6*61 (2)
In: Undefined
Description: PLT6*61; Material: STEEL/450
Default - ASSEMBLY_POS: Z/53
Tekla Common - Finish: GALVANIZE; Bottom elevation: -0.000; Top elevation: +0.155; Phase: 1; Class: 5
Tekla Quantity - Weight: 1.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 47.2 m2; Net surface area: 0.1 m2; Height: 61 mm; Width: 6 mm; Length: 528.9 mm
Pset_BeamCommon - LoadBearing: no; Reference: Z/53
BaseQuantities - Length: 528.908 mm; OuterSurfaceArea: 0.0728201 m2; NetVolume: 0.000196615 m3; NetWeight: 1.54343 kg

# IfcBeam: TH:75-95 (51)
In: Undefined
Description: TH:75-95; Material: STEEL/300PLUS
Default - ASSEMBLY_POS: Z/562
Tekla Common - Phase: 1; Class: 4
Tekla Quantity - Weight: 1.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 0 m2; Net surface area: 0.5 m2; Height: 75 mm; Width: 125 mm; Length: 1000 mm
Pset_BeamCommon - LoadBearing: no; Reference: Z/562
BaseQuantities - Length: 1000 mm; OuterSurfaceArea: 4.5602e-07 m2; NetVolume: 0.000231901 m3; NetWeight: 1.82042 kg
Name | Bottom elevation | Top elevation
TH | +6.356 | +6.481
TH | +6.345 | +6.470
TH | +6.335 | +6.460
TH | +6.324 | +6.449
TH | +6.313 | +6.438
TH | +5.874 | +5.965
TH | +5.869 | +5.959
TH | +5.864 | +5.954
TH | +5.848 | +5.939
TH | +5.853 | +5.943
5 x TH | +4.566 | +4.691
TH | +5.885 | +6.010
TH | +5.888 | +6.013
TH | +5.270 | +5.356
TH | +5.266 | +5.352
TH | +5.262 | +5.349
TH | +5.259 | +5.345
TH | +5.880 | +6.005
TH | +5.255 | +5.341
5 x TH | +4.570 | +4.695
TH | +5.298 | +5.423
TH | +5.301 | +5.426
TH | +5.151 | +5.233
TH | +5.149 | +5.230
TH | +5.146 | +5.228
TH | +5.145 | +5.226
TH | +5.296 | +5.421
TH | +5.142 | +5.224
TH | +5.091 | +5.170
TH | +5.089 | +5.168
TH | +5.087 | +5.166
TH | +5.086 | +5.165
5 x TH | +5.008 | +5.133
5 x TH | +4.573 | +4.698
TH | +5.085 | +5.164

# IfcColumn: C:150-24 (8)
In: Undefined
Description: C:150-24; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Phase: 1; Class: 10
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 111.2 m2; Height: 152 mm; Width: 64 mm
Pset_ColumnCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Finish | Top elevation | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
COLUMN | Z/1105 | 12 deg | +6.812 | 38 | 4.2 | 6811.6 | 6811.57 | 4.22192 | 0.0050253 | 39.4486
COLUMN | Z/33 | 12 deg | +5.063 | 28.2 | 3.1 | 5063.1 | 5063.14 | 3.1386 | 0.00373538 | 29.3228
COLUMN | Z/1099 | 9 deg | +6.371 | 35.5 | 3.9 | 6371.1 | 6371.13 | 3.94903 | 0.00470037 | 36.8979
COLUMN | Z/1188 | 9 deg | +5.066 | 28.2 | 3.1 | 5066.4 | 5066.36 | 3.14059 | 0.00373776 | 29.3414
COLUMN | Z/1075 | 5 deg | +5.792 | 32.3 | 3.6 | 5791.8 | 5791.76 | 3.59005 | 0.00427293 | 33.5425
COLUMN | Z/1185 | 5 deg | +5.071 | 28.2 | 3.1 | 5070.9 | 5071.03 | 3.14349 | 0.0037412 | 29.3684
COLUMN | Z/1047 | 3 deg | +5.505 | 30.7 | 3.4 | 5505.3 | 5505.3 | 3.41256 | 0.00406159 | 31.8835
COLUMN | Z/1182 | 3 deg | +5.074 | 28.2 | 3.1 | 5073.6 | 5073.57 | 3.14506 | 0.00374308 | 29.3832

# IfcColumn: C:200-24 (8)
In: Undefined
Description: C:200-24; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Phase: 1; Class: 10
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 110 m2; Height: 203 mm; Width: 76 mm
Pset_ColumnCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Finish | Top elevation | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
COLUMN | Z/1210 | 12 deg | +6.825 | 48.4 | 5.3 | 6824.9 | 6824.93 | 5.32257 | 0.00634555 | 49.8125
COLUMN | Z/59 | 12 deg | +5.063 | 35.9 | 3.9 | 5063.3 | 5063.16 | 3.9491 | 0.00470752 | 36.9541
COLUMN | Z/1208 | 9 deg | +6.379 | 45.2 | 4.9 | 6379.2 | 6379.2 | 4.97508 | 0.00593113 | 46.5593
COLUMN | Z/1253 | 9 deg | +5.066 | 35.9 | 3.9 | 5066.4 | 5066.35 | 3.95159 | 0.00471049 | 36.9773
COLUMN | Z/1205 | 5 deg | +5.796 | 41.1 | 4.5 | 5796.2 | 5796.21 | 4.52058 | 0.00538908 | 42.3043
COLUMN | Z/1250 | 5 deg | +5.071 | 35.9 | 3.9 | 5070.9 | 5071.01 | 3.95522 | 0.00471482 | 37.0114
COLUMN | Z/1202 | 3 deg | +5.508 | 39 | 4.2 | 5507.9 | 5507.88 | 4.2958 | 0.00512101 | 40.1999
COLUMN | Z/1247 | 3 deg | +5.073 | 36 | 3.9 | 5073.4 | 5073.47 | 3.95714 | 0.00471711 | 37.0293

# IfcColumn: C:250-24 (8)
In: Undefined
Description: C:250-24; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Phase: 1; Class: 10
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 109.7 m2; Height: 254 mm; Width: 76 mm
Pset_ColumnCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Finish | Top elevation | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
COLUMN | Z/1277(?) | 12 deg | +6.836 | 54.8 | 6 | 6835.7 | 6835.66 | 6.01475 | 0.0071758 | 56.3301
COLUMN | Z/195 | 12 deg | +5.063 | 40.6 | 4.5 | 5063.3 | 5063.25 | 4.45573 | 0.0053152 | 41.7243
COLUMN | Z/1275(?) | 9 deg | +6.387 | 51.2 | 5.6 | 6387.2 | 6387.17 | 5.62025 | 0.006705 | 52.6342
COLUMN | Z/1321(?) | 9 deg | +5.066 | 40.6 | 4.5 | 5066.2 | 5066.24 | 4.45836 | 0.00531834 | 41.7489
COLUMN | Z/1272(?) | 5 deg | +5.801 | 46.5 | 5.1 | 5800.6 | 5800.58 | 5.10429 | 0.00608922 | 47.8004
COLUMN | Z/1318(?) | 5 deg | +5.071 | 40.7 | 4.5 | 5070.9 | 5070.92 | 4.46248 | 0.00532325 | 41.7875
COLUMN | Z/1269(?) | 3 deg | +5.510 | 44.2 | 4.9 | 5510.5 | 5510.45 | 4.84909 | 0.00578465 | 45.4095
COLUMN | Z/1315(?) | 3 deg | +5.073 | 40.7 | 4.5 | 5073.4 | 5073.37 | 4.46464 | 0.00532582 | 41.8077

# IfcColumn: C:300-30 (8)
In: Undefined
Description: C:300-30; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Phase: 1; Class: 10
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.4 m2; Height: 300 mm; Width: 96 mm
Pset_ColumnCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Finish | Top elevation | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
COLUMN | Z/1344(?) | 12 deg | +6.845 | 85.6 | 7.5 | 6845.3 | 6845.31 | 7.47834 | 0.011151 | 87.5354
COLUMN | Z/268 | 12 deg | +5.063 | 63.3 | 5.5 | 5062.8 | 5062.81 | 5.53185 | 0.00824732 | 64.7414
COLUMN | Z/1342(?) | 9 deg | +6.395 | 80 | 6.9 | 6394.9 | 6394.85 | 6.98643 | 0.0104172 | 81.7751
COLUMN | Z/1392(?) | 9 deg | +5.067 | 63.4 | 5.5 | 5066.6 | 5066.64 | 5.53603 | 0.00825356 | 64.7904
COLUMN | Z/1339(?) | 5 deg | +5.805 | 72.6 | 6.3 | 5805 | 5804.99 | 6.34231 | 0.00945633 | 74.2322
COLUMN | Z/1389(?) | 5 deg | +5.071 | 63.4 | 5.5 | 5071.3 | 5071.31 | 5.54113 | 0.00826116 | 64.8501
COLUMN | Z/1336(?) | 3 deg | +5.513 | 68.9 | 6 | 5513.3 | 5513.25 | 6.02373 | 0.00898108 | 70.5015
COLUMN | Z/1386(?) | 3 deg | +5.074 | 63.4 | 5.5 | 5073.8 | 5073.76 | 5.5438 | 0.00826516 | 64.8815

# IfcColumn: C:350-30 (8)
In: Undefined
Description: C:350-30; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Phase: 1; Class: 10
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.1 m2; Height: 350 mm; Width: 125 mm
Pset_ColumnCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Finish | Top elevation | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
COLUMN | Z/1415(?) | 12 deg | +6.856 | 102.5 | 8.9 | 6856.2 | 6856.17 | 8.93062 | 0.0133284 | 104.628
COLUMN | Z/310 | 12 deg | +5.063 | 75.7 | 6.6 | 5063 | 5063.04 | 6.59596 | 0.00984254 | 77.264
COLUMN | Z/1413(?) | 9 deg | +6.403 | 95.7 | 8.3 | 6402.8 | 6402.78 | 8.3403 | 0.012447 | 97.7089
COLUMN | Z/1465(?) | 9 deg | +5.067 | 75.7 | 6.6 | 5066.6 | 5066.65 | 6.60066 | 0.00984956 | 77.3191
COLUMN | Z/1410(?) | 5 deg | +5.809 | 86.9 | 7.6 | 5809.4 | 5809.38 | 7.5677 | 0.0112934 | 88.6534
COLUMN | Z/1462(?) | 5 deg | +5.071 | 75.7 | 6.6 | 5071.3 | 5071.32 | 6.60674 | 0.00985864 | 77.3903
COLUMN | Z/1407(?) | 3 deg | +5.516 | 82.5 | 7.2 | 5515.9 | 5515.89 | 7.18557 | 0.0107229 | 84.1746
COLUMN | Z/1459(?) | 3 deg | +5.074 | 75.9 | 6.6 | 5073.8 | 5073.78 | 6.60995 | 0.00986342 | 77.4279

# IfcColumn: D16 (4)
In: Undefined
Description: D16; Material: STEEL/300
Default - ASSEMBLY_POS: Z/65
Tekla Common - Bottom elevation: -0.119; Top elevation: +0.031; Phase: 1; Class: 1
Tekla Quantity - Weight: 0.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 36.2 m2; Net surface area: 0 m2; Height: 16 mm; Width: 16 mm; Length: 150 mm
Pset_ColumnCommon - LoadBearing: no; Reference: Z/65
BaseQuantities - Length: 150 mm; OuterSurfaceArea: 0.00770956 m2; NetVolume: 0.0000271529 m3; NetWeight: 0.21315 kg

# IfcElementAssembly (407)
In: Undefined
PredefinedType: RIGID_FRAME
Name | ASSEMBLY_POSITION_CODE = Assembly/Cast unit position code | ASSEMBLY_POS = Assembly/Cast unit Mark | Assembly/Cast unit weight (kg) | Assembly/Cast unit bottom elevation | Assembly/Cast unit top elevation | Width (mm)
BHR-9-350 | C350SD/2-3 | Z/1449 | 8.8 | +4.471 | +5.993 | 64
BHL-9-350 | C350SD/1-2 | Z/1448 | 8.8 | +3.616 | +5.138 | 64
BHR-5-350 | C350SD/2-3 | Z/1447 | 8.1 | +4.101 | +5.517 | 64
BHL-5-350 | C350SD/1-2 | Z/1446 | 8.1 | +3.616 | +5.032 | 64
BHR-3-350 | C350SD/2-3 | Z/923 | 7.9 | +3.921 | +5.302 | 64
BHL-3-350 | C350SD/1-2 | Z/922 | 7.9 | +3.616 | +4.996 | 64
BHR-9-300 | C300SD/2-3 | Z/1376 | 8.4 | +4.581 | +6.032 | 64
BHL-9-300 | C300SD/1-2 | Z/1375 | 8.4 | +3.712 | +5.163 | 64
BHR-5-300 | C300SD/2-3 | Z/1374 | 7.7 | +4.211 | +5.556 | 64
BHL-5-300 | C300SD/1-2 | Z/1373 | 7.7 | +3.712 | +5.057 | 64
BHR-3-300 | C300SD/2-3 | Z/894 | 7.5 | +4.021 | +5.331 | 64
BHL-3-300 | C300SD/1-2 | Z/893 | 7.5 | +3.712 | +5.022 | 64
BHR-9-250 | C250SD/2-3 | Z/1306 | 6.6 | +4.925 | +6.093 | 64
BHL-9-250 | C250SD/1-2 | Z/1305 | 6.6 | +3.964 | +5.132 | 64
BHR-5-250 | C250SD/2-3 | Z/1304 | 6.2 | +4.505 | +5.603 | 64
BHL-5-250 | C250SD/1-2 | Z/1303 | 6.2 | +3.964 | +5.062 | 64
BHR-3-250 | C250SD/2-3 | Z/866 | 5.9 | +4.295 | +5.357 | 64
BHL-3-250 | C250SD/1-2 | Z/865 | 5.9 | +3.964 | +5.026 | 64
BHR-9-200 | C200SD/2-3 | Z/1239 | 6.2 | +5.059 | +6.139 | 64
BHL-9-200 | C200SD/1-2 | Z/1238 | 6.2 | +4.069 | +5.149 | 64
BHR-5-200 | C200SD/2-3 | Z/1237 | 5.6 | +4.627 | +5.636 | 64
BHL-5-200 | C200SD/1-2 | Z/1236 | 5.6 | +4.069 | +5.078 | 64
BHR-3-200 | C200SD/2-3 | Z/839 | 5.6 | +4.367 | +5.376 | 64
BHL-3-200 | C200SD/1-2 | Z/1235 | 5.6 | +4.034 | +5.043 | 64
2 x FASCIA BRACKET | C350SD/3 | Z/52 | 0.2 | +6.699 | +6.856 | 157.2
2 x FASCIA BRACKET | C350SD/3 | Z/52 | 0.2 | +6.246 | +6.403 | 157.2
2 x FASCIA BRACKET | C350SD/1 | Z/52 | 0.2 | +4.909 | +5.067 | 157.2
2 x FASCIA BRACKET | C350SD/3 | Z/52 | 0.2 | +5.652 | +5.809 | 157.2
2 x FASCIA BRACKET | C350SD/1 | Z/52 | 0.2 | +4.914 | +5.071 | 157.2
2 x FASCIA BRACKET | C350SD/3 | Z/52 | 0.2 | +5.359 | +5.516 | 157.2
2 x FASCIA BRACKET | C350SD/1 | Z/52 | 0.2 | +4.917 | +5.074 | 157.2
2 x FASCIA BRACKET | C300SD/3 | Z/52 | 0.2 | +6.688 | +6.845 | 157.2
2 x FASCIA BRACKET | C300SD/3 | Z/52 | 0.2 | +6.238 | +6.395 | 157.2
2 x FASCIA BRACKET | C300SD/1 | Z/52 | 0.2 | +4.909 | +5.067 | 157.2
2 x FASCIA BRACKET | C300SD/3 | Z/52 | 0.2 | +5.648 | +5.805 | 157.2
2 x FASCIA BRACKET | C300SD/1 | Z/52 | 0.2 | +4.914 | +5.071 | 157.2
2 x FASCIA BRACKET | C300SD/3 | Z/52 | 0.2 | +5.356 | +5.513 | 157.2
2 x FASCIA BRACKET | C300SD/1 | Z/52 | 0.2 | +4.917 | +5.074 | 157.2
2 x FASCIA BRACKET | C250SD/3 | Z/52 | 0.2 | +6.678 | +6.836 | 157.2
2 x FASCIA BRACKET | C250SD/3 | Z/52 | 0.2 | +6.230 | +6.387 | 157.2
2 x FASCIA BRACKET | C250SD/1 | Z/52 | 0.2 | +4.909 | +5.066 | 157.2
2 x FASCIA BRACKET | C250SD/3 | Z/52 | 0.2 | +5.643 | +5.801 | 157.2
2 x FASCIA BRACKET | C250SD/1 | Z/52 | 0.2 | +4.914 | +5.071 | 157.2
2 x FASCIA BRACKET | C250SD/3 | Z/52 | 0.2 | +5.353 | +5.510 | 157.2
2 x FASCIA BRACKET | C250SD/1 | Z/52 | 0.2 | +4.916 | +5.073 | 157.2
2 x FASCIA BRACKET | C200SD/1 | Z/52 | 0.2 | +4.916 | +5.073 | 157.2
2 x FASCIA BRACKET | C200SD/3 | Z/52 | 0.2 | +5.351 | +5.508 | 157.2
2 x FASCIA BRACKET | C200SD/1 | Z/52 | 0.2 | +4.914 | +5.071 | 157.2
2 x FASCIA BRACKET | C200SD/3 | Z/52 | 0.2 | +5.639 | +5.796 | 157.2
2 x FASCIA BRACKET | C200SD/1 | Z/52 | 0.2 | +4.909 | +5.066 | 157.2
2 x FASCIA BRACKET | C200SD/3 | Z/52 | 0.2 | +6.222 | +6.379 | 157.2
2 x FASCIA BRACKET | C200SD/3 | Z/52 | 0.2 | +6.668 | +6.825 | 157.2
2 x FASCIA BRACKET | C150SD/3 | Z/52 | 0.2 | +6.657 | +6.814 | 157.2
2 x FASCIA BRACKET | C150SD/3 | Z/52 | 0.2 | +6.214 | +6.371 | 157.2
2 x FASCIA BRACKET | C150SD/1 | Z/52 | 0.2 | +4.909 | +5.066 | 157.2
2 x FASCIA BRACKET | C150SD/3 | Z/52 | 0.2 | +5.635 | +5.792 | 157.2
2 x FASCIA BRACKET | C150SD/1 | Z/52 | 0.2 | +4.914 | +5.071 | 157.2
2 x FASCIA BRACKET | C150SD/3 | Z/52 | 0.2 | +5.348 | +5.505 | 157.2
2 x FASCIA BRACKET | C150SD/1 | Z/52 | 0.2 | +4.916 | +5.074 | 157.2
BHR-9-150 | C150SD/2-3 | Z/1174 | 5.9 | +5.124 | +6.171 | 64
BHL-9-150 | C150SD/1-2 | Z/1173 | 5.9 | +4.124 | +5.172 | 64
BHR-5-150 | C150SD/2-3 | Z/1172 | 5.4 | +4.689 | +5.666 | 64
BHL-5-150 | C150SD/1-2 | Z/1171 | 5.4 | +4.124 | +5.101 | 64
BHR-3-150 | C150SD/2-3 | Z/1170 | 5.4 | +4.432 | +5.409 | 64
BHL-3-150 | C150SD/1-2 | Z/1169 | 5.4 | +4.093 | +5.070 | 64
PLATE | C350SD/2-3 | Z/1444(?) | 11 | +6.123 | +6.700 | 128
PLATE | C300SD/2-3 | Z/1372(?) | 9.1 | +6.173 | +6.700 | 99
PLATE | C250SD/3 | Z/1302(?) | 5.9 | +6.272 | +6.700 | 79
PLATE | C200SD/3 | Z/1234 | 3.5 | +6.372 | +6.700 | 79
PLATE | C150SD/3 | Z/1011 | 2.6 | +6.413 | +6.700 | 67
2 x COLUMN | C350SD/3 | Z/1415(?) | 102.5 | +0.000 | +6.856 | 125
2 x RAFTER | C350SD/1-3 | Z/1414(?) | 115.5 | +4.734 | +6.683 | 125
2 x COLUMN | C300SD/3 | Z/1344(?) | 85.6 | +0.000 | +6.845 | 96
2 x RAFTER | C300SD/1-3 | Z/1343(?) | 97.4 | +4.772 | +6.685 | 96
2 x COLUMN | C250SD/3 | Z/1277(?) | 54.8 | +0.000 | +6.836 | 76
2 x RAFTER | C250SD/1-3 | Z/1276(?) | 62.9 | +4.807 | +6.687 | 76
2 x COLUMN | C200SD/3 | Z/1210 | 48.4 | +0.000 | +6.825 | 76
2 x RAFTER | C200SD/1-3 | Z/1209 | 56.1 | +4.846 | +6.689 | 76
2 x COLUMN | C150SD/3 | Z/1105 | 38 | +0.000 | +6.812 | 64
2 x RAFTER | C150SD/1-3 | Z/1102 | 44.4 | +4.886 | +6.691 | 64
PLATE | C350SD/2-3 | Z/927(?) | 11 | +6.123 | +6.700 | 128
PLATE | C300SD/2-3 | Z/897(?) | 9.1 | +6.173 | +6.700 | 99
PLATE | C250SD/3 | Z/869(?) | 5.9 | +6.272 | +6.700 | 79
PLATE | C200SD/3 | Z/842 | 3.5 | +6.372 | +6.700 | 79
PLATE | C150SD/3 | Z/988 | 2.6 | +6.413 | +6.700 | 67
FASCIA | C350SD>/3 | Z/561 | 3.5 | +6.702 | +6.854 | 64
TH | C350SD>/3 | Z/562 | 1.8 | +6.356 | +6.481 | 125
FASCIA | C300SD-C350SD/3 | Z/561 | 3.5 | +6.691 | +6.843 | 64
TH | C300SD-C350SD/3 | Z/562 | 1.8 | +6.345 | +6.470 | 125
FASCIA | C250SD-C300SD/3 | Z/561 | 3.5 | +6.681 | +6.833 | 64
TH | C250SD-C300SD/3 | Z/562 | 1.8 | +6.335 | +6.460 | 125
FASCIA | C200SD-C250SD/3 | Z/561 | 3.5 | +6.670 | +6.822 | 64
TH | C200SD-C250SD/3 | Z/562 | 1.8 | +6.324 | +6.449 | 125
FASCIA | C150SD-C200SD/3 | Z/561 | 3.5 | +6.660 | +6.812 | 64
TH | C150SD-C200SD/3 | Z/562 | 1.8 | +6.313 | +6.438 | 125
TH | C350SD>/2 | Z/562 | 1.8 | +5.874 | +5.965 | 125
TH | C300SD-C350SD/2 | Z/562 | 1.8 | +5.869 | +5.959 | 125
TH | C250SD-C300SD/2 | Z/562 | 1.8 | +5.864 | +5.954 | 125
TH | C200SD-C250SD/2 | Z/562 | 1.8 | +5.848 | +5.939 | 125
TH | C150SD-C200SD/2 | Z/562 | 1.8 | +5.853 | +5.943 | 125
COLUMN | C350SD/1 | Z/310 | 75.7 | +0.000 | +5.063 | 125
COLUMN | C300SD/1 | Z/268 | 63.3 | +0.000 | +5.063 | 96
COLUMN | C250SD/1 | Z/195 | 40.6 | +0.000 | +5.063 | 76
COLUMN | C200SD/1 | Z/59 | 35.9 | +0.000 | +5.063 | 76
COLUMN | C150SD/1 | Z/33 | 28.2 | +0.000 | +5.063 | 64
PLATE | C350SD/2-3 | Z/1442(?) | 10.6 | +5.715 | +6.267 | 128
PLATE | C300SD/2-3 | Z/1371(?) | 8.8 | +5.765 | +6.267 | 99
PLATE | C250SD/3 | Z/1300(?) | 5.4 | +5.869 | +6.267 | 79
PLATE | C200SD/3 | Z/1231 | 3.5 | +5.935 | +6.267 | 79
PLATE | C150SD/3 | Z/1010 | 2.6 | +5.986 | +6.267 | 67
PLATE | C350SD/1-2 | Z/1433(?) | 9.7 | +4.574 | +5.123 | 128
PLATE | C300SD/1-2 | Z/1362(?) | 8.4 | +4.575 | +5.115 | 99
PLATE | C250SD/1 | Z/1293(?) | 5 | +4.689 | +5.089 | 79
PLATE | C200SD/1 | Z/1229 | 3 | +4.774 | +5.068 | 79
PLATE | C150SD/1 | Z/1009 | 2.4 | +4.774 | +5.060 | 67
COLUMN | C350SD/3 | Z/1413(?) | 95.7 | +0.000 | +6.403 | 125
RAFTER | C350SD/1-3 | Z/1412(?) | 114.7 | +4.711 | +6.257 | 125
COLUMN | C350SD/1 | Z/1411(?) | 75.7 | +0.000 | +5.067 | 125
COLUMN | C300SD/3 | Z/1342(?) | 80 | +0.000 | +6.395 | 96
RAFTER | C300SD/1-3 | Z/1341(?) | 96.6 | +4.753 | +6.258 | 96
COLUMN | C300SD/1 | Z/1340(?) | 63.4 | +0.000 | +5.067 | 96
COLUMN | C250SD/3 | Z/1275(?) | 51.2 | +0.000 | +6.387 | 76
RAFTER | C250SD/1-3 | Z/1274(?) | 62.4 | +4.791 | +6.259 | 76
COLUMN | C250SD/1 | Z/1273(?) | 40.6 | +0.000 | +5.066 | 76
COLUMN | C200SD/3 | Z/1208 | 45.2 | +0.000 | +6.379 | 76
RAFTER | C200SD/1-3 | Z/1207 | 55.6 | +4.833 | +6.260 | 76
COLUMN | C200SD/1 | Z/1206 | 35.9 | +0.000 | +5.066 | 76
COLUMN | C150SD/3 | Z/1099 | 35.5 | +0.000 | +6.371 | 64
RAFTER | C150SD/1-3 | Z/1081 | 44 | +4.875 | +6.261 | 64
COLUMN | C150SD/1 | Z/1078 | 28.2 | +0.000 | +5.066 | 64
FASCIA | C350SD>/3 | Z/561 | 3.5 | +6.248 | +6.400 | 64
FASCIA | C350SD>/1 | Z/561 | 3.5 | +4.912 | +5.064 | 64
TH | C350SD>/1 | Z/562 | 1.8 | +4.566 | +4.691 | 125
FASCIA | C300SD-C350SD/3 | Z/561 | 3.5 | +6.240 | +6.392 | 64
FASCIA | C300SD-C350SD/1 | Z/561 | 3.5 | +4.912 | +5.064 | 64
TH | C300SD-C350SD/1 | Z/562 | 1.8 | +4.566 | +4.691 | 125
FASCIA | C250SD-C300SD/3 | Z/561 | 3.5 | +6.233 | +6.385 | 64
TH | C250SD-C300SD/3 | Z/562 | 1.8 | +5.885 | +6.010 | 125
FASCIA | C250SD-C300SD/1 | Z/561 | 3.5 | +4.912 | +5.064 | 64
TH | C250SD-C300SD/1 | Z/562 | 1.8 | +4.566 | +4.691 | 125
FASCIA | C200SD-C250SD/3 | Z/561 | 3.5 | +6.225 | +6.377 | 64
TH | C200SD-C250SD/3 | Z/562 | 1.8 | +5.888 | +6.013 | 125
FASCIA | C200SD-C250SD/1 | Z/561 | 3.5 | +4.912 | +5.064 | 64
TH | C200SD-C250SD/1 | Z/562 | 1.8 | +4.566 | +4.691 | 125
TH | C350SD>/1-2 | Z/562 | 1.8 | +5.270 | +5.356 | 125
TH | C300SD-C350SD/1-2 | Z/562 | 1.8 | +5.266 | +5.352 | 125
TH | C250SD-C300SD/1-2 | Z/562 | 1.8 | +5.262 | +5.349 | 125
TH | C200SD-C250SD/1-2 | Z/562 | 1.8 | +5.259 | +5.345 | 125
FASCIA | C150SD-C200SD/3 | Z/561 | 3.5 | +6.217 | +6.369 | 64
TH | C150SD-C200SD/3 | Z/562 | 1.8 | +5.880 | +6.005 | 125
FASCIA | C150SD-C200SD/1 | Z/561 | 3.5 | +4.912 | +5.064 | 64
TH | C150SD-C200SD/1 | Z/562 | 1.8 | +4.566 | +4.691 | 125
TH | C150SD-C200SD/1-2 | Z/562 | 1.8 | +5.255 | +5.341 | 125
BHR-9-350 | C350SD/2-3 | Z/1114 | 8.8 | +4.471 | +5.993 | 64
BHL-9-350 | C350SD/1-2 | Z/1113 | 8.8 | +3.616 | +5.138 | 64
BHR-9-300 | C300SD/2-3 | Z/1087 | 8.4 | +4.581 | +6.032 | 64
BHL-9-300 | C300SD/1-2 | Z/1086 | 8.4 | +3.712 | +5.163 | 64
BHR-9-250 | C250SD/2-3 | Z/1056 | 6.6 | +4.925 | +6.093 | 64
BHL-9-250 | C250SD/1-2 | Z/1055 | 6.6 | +3.964 | +5.132 | 64
BHR-9-200 | C200SD/2-3 | Z/1029 | 6.2 | +5.059 | +6.139 | 64
BHL-9-200 | C200SD/1-2 | Z/1028 | 6.2 | +4.069 | +5.149 | 64
BHR-9-150 | C150SD/2-3 | Z/986 | 5.9 | +5.124 | +6.171 | 64
BHL-9-150 | C150SD/1-2 | Z/985 | 5.9 | +4.124 | +5.172 | 64
PLATE | C350SD/2-3 | Z/931(?) | 10.6 | +5.715 | +6.267 | 128
COLUMN | C350SD/3 | Z/1467(?) | 95.7 | +0.000 | +6.403 | 125
PLATE | C300SD/2-3 | Z/900(?) | 8.8 | +5.765 | +6.267 | 99
COLUMN | C300SD/3 | Z/1394(?) | 80 | +0.000 | +6.395 | 96
PLATE | C250SD/3 | Z/874(?) | 5.4 | +5.869 | +6.267 | 79
COLUMN | C250SD/3 | Z/1323(?) | 51.2 | +0.000 | +6.387 | 76
PLATE | C200SD/3 | Z/845 | 3.5 | +5.935 | +6.267 | 79
COLUMN | C200SD/3 | Z/1255 | 45.2 | +0.000 | +6.379 | 76
PLATE | C150SD/3 | Z/987 | 2.6 | +5.986 | +6.267 | 67
COLUMN | C150SD/3 | Z/1190 | 35.5 | +0.000 | +6.371 | 64
PLATE | C350SD/1-2 | Z/932(?) | 9.7 | +4.574 | +5.123 | 128
RAFTER | C350SD/1-3 | Z/1466(?) | 114.7 | +4.711 | +6.257 | 125
COLUMN | C350SD/1 | Z/1465(?) | 75.7 | +0.000 | +5.067 | 125
PLATE | C300SD/1-2 | Z/903(?) | 8.4 | +4.575 | +5.115 | 99
RAFTER | C300SD/1-3 | Z/1393(?) | 96.6 | +4.753 | +6.258 | 96
COLUMN | C300SD/1 | Z/1392(?) | 63.4 | +0.000 | +5.067 | 96
PLATE | C250SD/1 | Z/875(?) | 5 | +4.689 | +5.089 | 79
RAFTER | C250SD/1-3 | Z/1322(?) | 62.4 | +4.791 | +6.259 | 76
COLUMN | C250SD/1 | Z/1321(?) | 40.6 | +0.000 | +5.066 | 76
PLATE | C200SD/1 | Z/846 | 3 | +4.774 | +5.068 | 79
RAFTER | C200SD/1-3 | Z/1254 | 55.6 | +4.833 | +6.260 | 76
COLUMN | C200SD/1 | Z/1253 | 35.9 | +0.000 | +5.066 | 76
PLATE | C150SD/1 | Z/989 | 2.4 | +4.774 | +5.060 | 67
RAFTER | C150SD/1-3 | Z/1189 | 44 | +4.875 | +6.261 | 64
COLUMN | C150SD/1 | Z/1188 | 28.2 | +0.000 | +5.066 | 64
COLUMN | C250SD/3 | Z/1320(?) | 46.5 | +0.000 | +5.801 | 76
BASEPLATE | C250SD/3 | Z/53 | 1.5 | -0.000 | +0.155 | 247.2
COLUMN | C250SD/1 | Z/1318(?) | 40.7 | +0.000 | +5.071 | 76
BASEPLATE | C250SD/1 | Z/53 | 1.5 | -0.000 | +0.155 | 247.2
PLATE | C350SD/2-3 | Z/1443(?) | 10.2 | +5.170 | +5.700 | 128
PLATE | C300SD/2-3 | Z/1370(?) | 9.1 | +5.171 | +5.700 | 99
PLATE | C250SD/3 | Z/1301(?) | 5.4 | +5.311 | +5.700 | 79
PLATE | C200SD/3 | Z/1230 | 3.5 | +5.385 | +5.700 | 79
PLATE | C150SD/3 | Z/1007 | 2.6 | +5.421 | +5.700 | 67
PLATE | C350SD/1-2 | Z/1441(?) | 9.3 | +4.574 | +5.068 | 128
PLATE | C300SD/1-2 | Z/1361(?) | 8.1 | +4.574 | +5.064 | 99
PLATE | C250SD/1 | Z/1067(?) | 4.8 | +4.689 | +5.049 | 79
PLATE | C200SD/1 | Z/1228 | 3.2 | +4.724 | +5.037 | 79
PLATE | C150SD/1 | Z/1005 | 2.3 | +4.774 | +5.033 | 67
COLUMN | C350SD/3 | Z/1410(?) | 86.9 | +0.000 | +5.809 | 125
RAFTER | C350SD/1-3 | Z/1409(?) | 114.1 | +4.683 | +5.696 | 125
COLUMN | C350SD/1 | Z/1408(?) | 75.7 | +0.000 | +5.071 | 125
COLUMN | C300SD/3 | Z/1339(?) | 72.6 | +0.000 | +5.805 | 96
RAFTER | C300SD/1-3 | Z/1338(?) | 96.1 | +4.728 | +5.697 | 96
COLUMN | C300SD/1 | Z/1337(?) | 63.4 | +0.000 | +5.071 | 96
COLUMN | C250SD/3 | Z/1272(?) | 46.5 | +0.000 | +5.801 | 76
RAFTER | C250SD/1-3 | Z/1271(?) | 62 | +4.770 | +5.697 | 76
COLUMN | C250SD/1 | Z/1270(?) | 40.7 | +0.000 | +5.071 | 76
COLUMN | C200SD/3 | Z/1205 | 41.1 | +0.000 | +5.796 | 76
RAFTER | C200SD/1-3 | Z/1204 | 55.2 | +4.816 | +5.697 | 76
COLUMN | C200SD/1 | Z/1203 | 35.9 | +0.000 | +5.071 | 76
COLUMN | C150SD/3 | Z/1075 | 32.3 | +0.000 | +5.792 | 64
RAFTER | C150SD/1-3 | Z/1072 | 43.7 | +4.862 | +5.698 | 64
COLUMN | C150SD/1 | Z/1050 | 28.2 | +0.000 | +5.071 | 64
FASCIA | C350SD>/3 | Z/561 | 3.5 | +5.655 | +5.807 | 64
FASCIA | C350SD>/1 | Z/561 | 3.5 | +4.917 | +5.069 | 64
TH | C350SD>/1 | Z/562 | 1.8 | +4.570 | +4.695 | 125
FASCIA | C300SD-C350SD/3 | Z/561 | 3.5 | +5.650 | +5.802 | 64
FASCIA | C300SD-C350SD/1 | Z/561 | 3.5 | +4.917 | +5.069 | 64
TH | C300SD-C350SD/1 | Z/562 | 1.8 | +4.570 | +4.695 | 125
FASCIA | C250SD-C300SD/3 | Z/561 | 3.5 | +5.646 | +5.798 | 64
TH | C250SD-C300SD/3 | Z/562 | 1.8 | +5.298 | +5.423 | 125
FASCIA | C250SD-C300SD/1 | Z/561 | 3.5 | +4.916 | +5.068 | 64
TH | C250SD-C300SD/1 | Z/562 | 1.8 | +4.570 | +4.695 | 125
FASCIA | C200SD-C250SD/3 | Z/561 | 3.5 | +5.642 | +5.794 | 64
TH | C200SD-C250SD/3 | Z/562 | 1.8 | +5.301 | +5.426 | 125
FASCIA | C200SD-C250SD/1 | Z/561 | 3.5 | +4.916 | +5.068 | 64
TH | C200SD-C250SD/1 | Z/562 | 1.8 | +4.570 | +4.695 | 125
TH | C350SD>/1-2 | Z/562 | 1.8 | +5.151 | +5.233 | 125
TH | C300SD-C350SD/1-2 | Z/562 | 1.8 | +5.149 | +5.230 | 125
TH | C250SD-C300SD/1-2 | Z/562 | 1.8 | +5.146 | +5.228 | 125
TH | C200SD-C250SD/1-2 | Z/562 | 1.8 | +5.145 | +5.226 | 125
FASCIA | C150SD-C200SD/3 | Z/561 | 3.5 | +5.637 | +5.789 | 64
TH | C150SD-C200SD/3 | Z/562 | 1.8 | +5.296 | +5.421 | 125
FASCIA | C150SD-C200SD/1 | Z/561 | 3.5 | +4.916 | +5.068 | 64
TH | C150SD-C200SD/1 | Z/562 | 1.8 | +4.570 | +4.695 | 125
TH | C150SD-C200SD/1-2 | Z/562 | 1.8 | +5.142 | +5.224 | 125
2 x THROUGH BOLTS | C250SD/3 | Z/65 | 0.2 | -0.119 | +0.031 | 16
2 x THROUGH BOLTS | C250SD/1 | Z/65 | 0.2 | -0.119 | +0.031 | 16
BHR-5-350 | C350SD/2-3 | Z/1112 | 8.1 | +4.101 | +5.517 | 64
BHL-5-350 | C350SD/1-2 | Z/1111 | 8.1 | +3.616 | +5.032 | 64
BHR-5-300 | C300SD/2-3 | Z/1085 | 7.7 | +4.211 | +5.556 | 64
BHL-5-300 | C300SD/1-2 | Z/1084 | 7.7 | +3.712 | +5.057 | 64
BHR-5-250 | C250SD/2-3 | Z/1054 | 6.2 | +4.505 | +5.603 | 64
BHL-5-250 | C250SD/1-2 | Z/1053 | 6.2 | +3.964 | +5.062 | 64
BHR-5-200 | C200SD/2-3 | Z/1027 | 5.6 | +4.627 | +5.636 | 64
BHL-5-200 | C200SD/1-2 | Z/1026 | 5.6 | +4.069 | +5.078 | 64
BHR-5-150 | C150SD/2-3 | Z/984 | 5.4 | +4.689 | +5.666 | 64
BHL-5-150 | C150SD/1-2 | Z/983 | 5.4 | +4.124 | +5.101 | 64
PLATE | C350SD/2-3 | Z/928(?) | 10.2 | +5.170 | +5.700 | 128
PLATE | C250SD/3 | Z/871(?) | 5.4 | +5.311 | +5.700 | 79
COLUMN | C350SD/3 | Z/1464(?) | 86.9 | +0.000 | +5.809 | 125
PLATE | C300SD/2-3 | Z/899(?) | 9.1 | +5.171 | +5.700 | 99
COLUMN | C300SD/3 | Z/1391(?) | 72.6 | +0.000 | +5.805 | 96
PLATE | C200SD/3 | Z/844 | 3.5 | +5.385 | +5.700 | 79
COLUMN | C200SD/3 | Z/1252 | 41.1 | +0.000 | +5.796 | 76
PLATE | C150SD/3 | Z/992 | 2.6 | +5.421 | +5.700 | 67
COLUMN | C150SD/3 | Z/1187 | 32.3 | +0.000 | +5.792 | 64
PLATE | C350SD/1-2 | Z/930(?) | 9.3 | +4.574 | +5.068 | 128
RAFTER | C350SD/1-3 | Z/1463(?) | 114.1 | +4.683 | +5.696 | 125
COLUMN | C350SD/1 | Z/1462(?) | 75.7 | +0.000 | +5.071 | 125
PLATE | C300SD/1-2 | Z/902(?) | 8.1 | +4.574 | +5.064 | 99
RAFTER | C300SD/1-3 | Z/1390(?) | 96.1 | +4.728 | +5.697 | 96
COLUMN | C300SD/1 | Z/1389(?) | 63.4 | +0.000 | +5.071 | 96
PLATE | C250SD/1 | Z/873(?) | 4.8 | +4.689 | +5.049 | 79
RAFTER | C250SD/1-3 | Z/1319(?) | 62 | +4.770 | +5.697 | 76
PLATE | C200SD/1 | Z/348 | 3.2 | +4.724 | +5.037 | 79
RAFTER | C200SD/1-3 | Z/1251 | 55.2 | +4.816 | +5.697 | 76
COLUMN | C200SD/1 | Z/1250 | 35.9 | +0.000 | +5.071 | 76
PLATE | C150SD/1 | Z/999 | 2.3 | +4.774 | +5.033 | 67
RAFTER | C150SD/1-3 | Z/1186 | 43.7 | +4.862 | +5.698 | 64
COLUMN | C150SD/1 | Z/1185 | 28.2 | +0.000 | +5.071 | 64
PLATE | C350SD/2-3 | Z/1445(?) | 9.7 | +4.930 | +5.419 | 128
PLATE | C300SD/2-3 | Z/1369(?) | 8.4 | +4.936 | +5.419 | 99
PLATE | C250SD/3 | Z/1069(?) | 5 | +5.058 | +5.419 | 79
PLATE | C200SD/3 | Z/841 | 3.3 | +5.113 | +5.419 | 79
PLATE | C150SD/3 | Z/1008 | 2.4 | +5.164 | +5.419 | 67
PLATE | C300SD/1-2 | Z/1360(?) | 7.9 | +4.574 | +5.038 | 99
PLATE | C350SD/1-2 | Z/1440(?) | 9.1 | +4.574 | +5.041 | 128
PLATE | C200SD/1 | Z/840 | 3.1 | +4.729 | +5.022 | 79
PLATE | C250SD/1 | Z/1068(?) | 4.7 | +4.689 | +5.029 | 79
PLATE | C150SD/1 | Z/1006 | 2.3 | +4.774 | +5.020 | 67
COLUMN | C350SD/3 | Z/1407(?) | 82.5 | +0.000 | +5.516 | 125
RAFTER | C350SD/1-3 | Z/1406(?) | 114 | +4.669 | +5.418 | 125
COLUMN | C350SD/1 | Z/1405(?) | 75.9 | +0.000 | +5.074 | 125
COLUMN | C300SD/3 | Z/1336(?) | 68.9 | +0.000 | +5.513 | 96
RAFTER | C300SD/1-3 | Z/1335(?) | 96 | +4.717 | +5.418 | 96
COLUMN | C300SD/1 | Z/1334(?) | 63.4 | +0.000 | +5.074 | 96
COLUMN | C250SD/3 | Z/1269(?) | 44.2 | +0.000 | +5.510 | 76
RAFTER | C250SD/1-3 | Z/1268(?) | 62 | +4.760 | +5.418 | 76
COLUMN | C250SD/1 | Z/1267(?) | 40.7 | +0.000 | +5.073 | 76
COLUMN | C200SD/3 | Z/1202 | 39 | +0.000 | +5.508 | 76
RAFTER | C200SD/1-3 | Z/1201 | 55.1 | +4.808 | +5.418 | 76
COLUMN | C200SD/1 | Z/1200 | 36 | +0.000 | +5.073 | 76
COLUMN | C150SD/3 | Z/1047 | 30.7 | +0.000 | +5.505 | 64
RAFTER | C150SD/1-3 | Z/1044 | 43.6 | +4.856 | +5.418 | 64
COLUMN | C150SD/1 | Z/1041 | 28.2 | +0.000 | +5.074 | 64
TH | C350SD>/1-2 | Z/562 | 1.8 | +5.091 | +5.170 | 125
TH | C300SD-C350SD/1-2 | Z/562 | 1.8 | +5.089 | +5.168 | 125
TH | C250SD-C300SD/1-2 | Z/562 | 1.8 | +5.087 | +5.166 | 125
TH | C200SD-C250SD/1-2 | Z/562 | 1.8 | +5.086 | +5.165 | 125
FASCIA | C350SD>/3 | Z/561 | 3.5 | +5.361 | +5.513 | 64
TH | C350SD>/3 | Z/562 | 1.8 | +5.008 | +5.133 | 125
FASCIA | C300SD-C350SD/3 | Z/561 | 3.5 | +5.359 | +5.511 | 64
TH | C300SD-C350SD/3 | Z/562 | 1.8 | +5.008 | +5.133 | 125
FASCIA | C250SD-C300SD/3 | Z/561 | 3.5 | +5.356 | +5.508 | 64
TH | C250SD-C300SD/3 | Z/562 | 1.8 | +5.008 | +5.133 | 125
FASCIA | C200SD-C250SD/3 | Z/561 | 3.5 | +5.353 | +5.505 | 64
TH | C200SD-C250SD/3 | Z/562 | 1.8 | +5.008 | +5.133 | 125
FASCIA | C350SD>/1 | Z/561 | 3.5 | +4.919 | +5.071 | 64
TH | C350SD>/1 | Z/562 | 1.8 | +4.573 | +4.698 | 125
FASCIA | C300SD-C350SD/1 | Z/561 | 3.5 | +4.919 | +5.071 | 64
TH | C300SD-C350SD/1 | Z/562 | 1.8 | +4.573 | +4.698 | 125
FASCIA | C250SD-C300SD/1 | Z/561 | 3.5 | +4.919 | +5.071 | 64
TH | C250SD-C300SD/1 | Z/562 | 1.8 | +4.573 | +4.698 | 125
FASCIA | C200SD-C250SD/1 | Z/561 | 3.5 | +4.919 | +5.071 | 64
TH | C200SD-C250SD/1 | Z/562 | 1.8 | +4.573 | +4.698 | 125
FASCIA | C150SD-C200SD/3 | Z/561 | 3.5 | +5.351 | +5.503 | 64
TH | C150SD-C200SD/3 | Z/562 | 1.8 | +5.008 | +5.133 | 125
FASCIA | C150SD-C200SD/1 | Z/561 | 3.5 | +4.919 | +5.071 | 64
TH | C150SD-C200SD/1 | Z/562 | 1.8 | +4.573 | +4.698 | 125
TH | C150SD-C200SD/1-2 | Z/562 | 1.8 | +5.085 | +5.164 | 125
BHR-3-350 | C350SD/2-3 | Z/1110 | 7.9 | +3.921 | +5.302 | 64
BHL-3-350 | C350SD/1-2 | Z/1109 | 7.9 | +3.616 | +4.996 | 64
BHR-3-300 | C300SD/2-3 | Z/1083 | 7.5 | +4.021 | +5.331 | 64
BHL-3-300 | C300SD/1-2 | Z/1082 | 7.5 | +3.712 | +5.022 | 64
BHR-3-250 | C250SD/2-3 | Z/1052 | 5.9 | +4.295 | +5.357 | 64
BHL-3-250 | C250SD/1-2 | Z/1051 | 5.9 | +3.964 | +5.026 | 64
BHR-3-200 | C200SD/2-3 | Z/1025 | 5.6 | +4.367 | +5.376 | 64
BHL-3-200 | C200SD/1-2 | Z/1024 | 5.6 | +4.034 | +5.043 | 64
BHR-3-150 | C150SD/2-3 | Z/982 | 5.4 | +4.432 | +5.409 | 64
BHL-3-150 | C150SD/1-2 | Z/981 | 5.4 | +4.093 | +5.070 | 64
PLATE | C300SD/2-3 | Z/1377(?) | 8.4 | +4.936 | +5.419 | 99
PLATE | C300SD/1-2 | Z/1378(?) | 7.9 | +4.574 | +5.038 | 99
PLATE | C350SD/2-3 | Z/1450(?) | 9.7 | +4.930 | +5.419 | 128
PLATE | C350SD/1-2 | Z/1451(?) | 9.1 | +4.574 | +5.041 | 128
PLATE | C250SD/3 | Z/1057(?) | 5 | +5.058 | +5.419 | 79
PLATE | C150SD/3 | Z/990 | 2.4 | +5.164 | +5.419 | 67
PLATE | C200SD/3 | Z/843 | 3.3 | +5.113 | +5.419 | 79
COLUMN | C350SD/3 | Z/1461(?) | 82.5 | +0.000 | +5.516 | 125
COLUMN | C300SD/3 | Z/1388(?) | 68.9 | +0.000 | +5.513 | 96
COLUMN | C250SD/3 | Z/1317(?) | 44.2 | +0.000 | +5.510 | 76
COLUMN | C200SD/3 | Z/1249 | 39 | +0.000 | +5.508 | 76
COLUMN | C150SD/3 | Z/1184 | 30.7 | +0.000 | +5.505 | 64
PLATE | C200SD/1 | Z/347 | 3.1 | +4.729 | +5.022 | 79
PLATE | C150SD/1 | Z/991 | 2.3 | +4.774 | +5.020 | 67
RAFTER | C350SD/1-3 | Z/1460(?) | 114 | +4.669 | +5.418 | 125
COLUMN | C350SD/1 | Z/1459(?) | 75.9 | +0.000 | +5.074 | 125
RAFTER | C300SD/1-3 | Z/1387(?) | 96 | +4.717 | +5.418 | 96
COLUMN | C300SD/1 | Z/1386(?) | 63.4 | +0.000 | +5.074 | 96
PLATE | C250SD/1 | Z/1307(?) | 4.7 | +4.689 | +5.029 | 79
RAFTER | C250SD/1-3 | Z/1316(?) | 62 | +4.760 | +5.418 | 76
COLUMN | C250SD/1 | Z/1315(?) | 40.7 | +0.000 | +5.073 | 76
RAFTER | C200SD/1-3 | Z/1248 | 55.1 | +4.808 | +5.418 | 76
COLUMN | C200SD/1 | Z/1247 | 36 | +0.000 | +5.073 | 76
RAFTER | C150SD/1-3 | Z/1183 | 43.6 | +4.856 | +5.418 | 64
COLUMN | C150SD/1 | Z/1182 | 28.2 | +0.000 | +5.074 | 64

# IfcMechanicalFastener: Bolt assembly (346)
In: Undefined
Tekla Bolt - Location: Site
Name | NominalDiameter (mm) = Washer diameter (mm) = Bolt size (mm) | NominalLength (mm) = Bolt length (mm) | Material = Bolt standard | Washer count | Washer type | Washer name | Nut count | Nut type | Nut name | Slotted hole y (mm) | Slotted hole x (mm) | Bolt hole diameter (mm) | Bolt count | Bolt Name
140 x Bolt assembly | 5 | 25 | TEK_16TPIM | 8 | UNDEF_WASH | UNDEFINED_WASHER5 | 2 | UNDEF_NUT | UNDEFINED_NUTM5 | 0 | 0 | 7 | 2 | TEKSCREW_M5*25
70 x Bolt assembly | 5 | 25 | TEK_16TPIM | 16 | UNDEF_WASH | UNDEFINED_WASHER5 | 4 | UNDEF_NUT | UNDEFINED_NUTM5 | 0 | 0 | 7 | 4 | TEKSCREW_M5*25
28 x Bolt assembly | 16 | 45 | 8.8S | 6 | HARD | WASHERM16-HARD | 6 | 8.8-HEX | NUTM16-8.8-HEX | 0 | 0 | 18 | 6 | BOLTM16*45
14 x Bolt assembly | 16 | 45 | 8.8S | 4 | HARD | WASHERM16-HARD | 4 | 8.8-HEX | NUTM16-8.8-HEX | 0 | 0 | 18 | 4 | BOLTM16*45
14 x Bolt assembly | 12 | 35 | 8.8S | 4 | HARD | WASHERM12-HARD | 4 | 8.8-HEX | NUTM12-8.8-HEX | 4 | 8 | 14 | 4 | BOLTM12*35
14 x Bolt assembly | 12 | 35 | 8.8S | 4 | HARD | WASHERM12-HARD | 4 | 8.8-HEX | NUTM12-8.8-HEX | 8 | 4 | 14 | 4 | BOLTM12*35
60 x Bolt assembly | 12 | 30 | PB1230 | 4 | FLAT | WASHERM12-FLAT | 4 | 4.6-HEX | NUTM12-4.6-HEX | 4 | 0 | 18 | 4 | BOLTPB1230
4 x Bolt assembly | 12 | 30 | 8.8S | 2 | HARD | WASHERM12-HARD | 2 | 8.8-HEX | NUTM12-8.8-HEX | 4 | 8 | 14 | 2 | BOLTM12*30
2 x Bolt assembly | 20 | 16 | 8.8S | 0 | HARD | WASHERM20-HARD | 0 | 8.8-HEX | NUTM20-8.8-HEX | 0 | 0 | 20 | 2 | BOLTM20*25

# IfcMember: C:150-19 (60)
In: Undefined
Description: C:150-19; Material: STEEL/G450
Tekla Common - Phase: 1; Class: 5
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 152 mm; Width: 64 mm
Pset_MemberCommon - LoadBearing: no
BaseQuantities - GrossSurfaceArea: 0 m2; CrossSectionArea: 0.000561 m2
Name | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | Reference | OuterSurfaceArea (m2) | NetVolume (m3) | GrossVolume (m3) | NetWeight (kg) | GrossWeight (kg)
BHR-9-350 | +4.471 | +5.993 | 8.8 | 118.8 | 1 | 2000 | Z/1449 | 1.04658 | 0.000985749 | 0.001122 | 7.73813 | 8.8077
BHL-9-350 | +3.616 | +5.138 | 8.8 | 116.3 | 1 | 2000 | Z/1448 | 1.02469 | 0.000964825 | 0.001122 | 7.57388 | 8.8077
BHR-5-350 | +4.101 | +5.517 | 8.1 | 116.7 | 1 | 1850 | Z/1447 | 0.950984 | 0.000895454 | 0.00103785 | 7.02932 | 8.14712
BHL-5-350 | +3.616 | +5.032 | 8.1 | 114.9 | 1 | 1850 | Z/1446 | 0.936452 | 0.000881589 | 0.00103785 | 6.92047 | 8.14712
BHR-3-350 | +3.921 | +5.302 | 7.9 | 114.4 | 1 | 1800 | Z/923 | 0.907137 | 0.000853969 | 0.0010098 | 6.70366 | 7.92693
BHL-3-350 | +3.616 | +4.996 | 7.9 | 113.8 | 1 | 1800 | Z/922 | 0.902279 | 0.000849321 | 0.0010098 | 6.66717 | 7.92693
BHR-9-300 | +4.581 | +6.032 | 8.4 | 120.3 | 1 | 1900 | Z/1376 | 1.00683 | 0.000948348 | 0.0010659 | 7.44453 | 8.36732
BHL-9-300 | +3.712 | +5.163 | 8.4 | 117.7 | 1 | 1900 | Z/1375 | 0.984743 | 0.000927229 | 0.0010659 | 7.27875 | 8.36732
BHR-5-300 | +4.211 | +5.556 | 7.7 | 118.1 | 1 | 1750 | Z/1374 | 0.910479 | 0.000857335 | 0.00098175 | 6.73008 | 7.70674
BHL-5-300 | +3.712 | +5.057 | 7.7 | 116.7 | 1 | 1750 | Z/1373 | 0.898697 | 0.000846082 | 0.00098175 | 6.64174 | 7.70674
BHR-3-300 | +4.021 | +5.331 | 7.5 | 116.3 | 1 | 1700 | Z/894 | 0.870379 | 0.00081941 | 0.0009537 | 6.43237 | 7.48655
BHL-3-300 | +3.712 | +5.022 | 7.5 | 115.6 | 1 | 1700 | Z/893 | 0.865528 | 0.000814768 | 0.0009537 | 6.39593 | 7.48655
BHR-9-250 | +4.925 | +6.093 | 6.6 | 118.8 | 0.8 | 1500 | Z/1306 | 0.78548 | 0.000739508 | 0.0008415 | 5.80514 | 6.60578
BHL-9-250 | +3.964 | +5.132 | 6.6 | 116.5 | 0.8 | 1500 | Z/1305 | 0.769874 | 0.000724554 | 0.0008415 | 5.68775 | 6.60578
BHR-5-250 | +4.505 | +5.603 | 6.2 | 116.3 | 0.8 | 1400 | Z/1304 | 0.717903 | 0.000675652 | 0.0007854 | 5.30387 | 6.16539
BHL-5-250 | +3.964 | +5.062 | 6.2 | 114.9 | 0.8 | 1400 | Z/1303 | 0.707709 | 0.0006659 | 0.0007854 | 5.22731 | 6.16539
BHR-3-250 | +4.295 | +5.357 | 5.9 | 114.9 | 0.8 | 1350 | Z/866 | 0.683177 | 0.000642832 | 0.00075735 | 5.04623 | 5.9452
BHL-3-250 | +3.964 | +5.026 | 5.9 | 114.1 | 0.8 | 1350 | Z/865 | 0.678312 | 0.000638177 | 0.00075735 | 5.00969 | 5.9452
BHR-9-200 | +5.059 | +6.139 | 6.2 | 120 | 0.8 | 1375 | Z/1239 | 0.726876 | 0.000684285 | 0.000771375 | 5.37164 | 6.05529
BHL-9-200 | +4.069 | +5.149 | 6.2 | 118 | 0.8 | 1375 | Z/1238 | 0.714523 | 0.000672427 | 0.000771375 | 5.27855 | 6.05529
BHR-5-200 | +4.627 | +5.636 | 5.6 | 118 | 0.8 | 1275 | Z/1237 | 0.662666 | 0.000623628 | 0.000715275 | 4.89548 | 5.61491
BHL-5-200 | +4.069 | +5.078 | 5.6 | 116.7 | 0.8 | 1275 | Z/1236 | 0.655173 | 0.000616445 | 0.000715275 | 4.83909 | 5.61491
BHR-3-200 | +4.367 | +5.376 | 5.6 | 118.1 | 0.8 | 1275 | Z/839 | 0.663333 | 0.000624251 | 0.000715275 | 4.90037 | 5.61491
BHL-3-200 | +4.034 | +5.043 | 5.6 | 120 | 0.8 | 1275 | Z/1235 | 0.673852 | 0.000626921 | 0.000715275 | 4.92133 | 5.61491
BHR-9-150 | +5.124 | +6.171 | 5.9 | 122 | 0.8 | 1330 | Z/1174 | 0.714775 | 0.000672958 | 0.00074613 | 5.28272 | 5.85712
BHL-9-150 | +4.124 | +5.172 | 5.9 | 120.2 | 0.8 | 1330 | Z/1173 | 0.703848 | 0.000662454 | 0.00074613 | 5.20027 | 5.85712
BHR-5-150 | +4.689 | +5.666 | 5.4 | 120.3 | 0.8 | 1230 | Z/1172 | 0.651632 | 0.000613312 | 0.00069003 | 4.8145 | 5.41674
BHL-5-150 | +4.124 | +5.101 | 5.4 | 119.2 | 0.6 | 1230 | Z/1171 | 0.64576 | 0.000607668 | 0.00069003 | 4.77019 | 5.41674
BHR-3-150 | +4.432 | +5.409 | 5.4 | 120.2 | 0.6 | 1230 | Z/1170 | 0.651141 | 0.00061283 | 0.00069003 | 4.81072 | 5.41674
BHL-3-150 | +4.093 | +5.070 | 5.4 | 119.6 | 0.6 | 1230 | Z/1169 | 0.64787 | 0.000609684 | 0.00069003 | 4.78602 | 5.41674
BHR-9-350 | +4.471 | +5.993 | 8.8 | 118.8 | 1 | 2000 | Z/1114 | 1.04658 | 0.000985733 | 0.001122 | 7.738 | 8.8077
BHL-9-350 | +3.616 | +5.138 | 8.8 | 116.3 | 1 | 2000 | Z/1113 | 1.02469 | 0.000964832 | 0.001122 | 7.57393 | 8.8077
BHR-9-300 | +4.581 | +6.032 | 8.4 | 120.3 | 1 | 1900 | Z/1087 | 1.00683 | 0.000948334 | 0.0010659 | 7.44442 | 8.36732
BHL-9-300 | +3.712 | +5.163 | 8.4 | 117.7 | 1 | 1900 | Z/1086 | 0.984743 | 0.000927234 | 0.0010659 | 7.27879 | 8.36731
BHR-9-250 | +4.925 | +6.093 | 6.6 | 118.8 | 0.8 | 1500 | Z/1056 | 0.78548 | 0.000739498 | 0.0008415 | 5.80506 | 6.60578
BHL-9-250 | +3.964 | +5.132 | 6.6 | 116.5 | 0.8 | 1500 | Z/1055 | 0.769874 | 0.00072456 | 0.0008415 | 5.6878 | 6.60577
BHR-9-200 | +5.059 | +6.139 | 6.2 | 120 | 0.6 | 1375 | Z/1029 | 0.726876 | 0.000684277 | 0.000771375 | 5.37158 | 6.05529
BHL-9-200 | +4.069 | +5.149 | 6.2 | 118 | 0.6 | 1375 | Z/1028 | 0.714523 | 0.000672416 | 0.000771375 | 5.27847 | 6.05529
BHR-9-150 | +5.124 | +6.171 | 5.9 | 122 | 0.6 | 1330 | Z/986 | 0.714774 | 0.000672948 | 0.00074613 | 5.28264 | 5.85712
BHL-9-150 | +4.124 | +5.172 | 5.9 | 120.2 | 0.6 | 1330 | Z/985 | 0.703848 | 0.000662448 | 0.00074613 | 5.20022 | 5.85712
BHR-5-350 | +4.101 | +5.517 | 8.1 | 116.7 | 1 | 1850 | Z/1112 | 0.950984 | 0.000895438 | 0.00103785 | 7.02919 | 8.14712
BHL-5-350 | +3.616 | +5.032 | 8.1 | 114.9 | 0.8 | 1850 | Z/1111 | 0.936452 | 0.000881573 | 0.00103785 | 6.92035 | 8.14712
BHR-5-300 | +4.211 | +5.556 | 7.7 | 118.1 | 0.8 | 1750 | Z/1085 | 0.910479 | 0.000857324 | 0.00098175 | 6.72999 | 7.70674
BHL-5-300 | +3.712 | +5.057 | 7.7 | 116.7 | 0.8 | 1750 | Z/1084 | 0.898697 | 0.000846066 | 0.00098175 | 6.64162 | 7.70674
BHR-5-250 | +4.505 | +5.603 | 6.2 | 116.3 | 0.6 | 1400 | Z/1054 | 0.717903 | 0.000675643 | 0.0007854 | 5.30379 | 6.16539
BHL-5-250 | +3.964 | +5.062 | 6.2 | 114.9 | 0.6 | 1400 | Z/1053 | 0.707709 | 0.000665892 | 0.0007854 | 5.22726 | 6.16539
BHR-5-200 | +4.627 | +5.636 | 5.6 | 118 | 0.6 | 1275 | Z/1027 | 0.662666 | 0.00062362 | 0.000715275 | 4.89542 | 5.61491
BHL-5-200 | +4.069 | +5.078 | 5.6 | 116.7 | 0.6 | 1275 | Z/1026 | 0.655173 | 0.000616437 | 0.000715275 | 4.83903 | 5.61491
BHR-5-150 | +4.689 | +5.666 | 5.4 | 120.3 | 0.6 | 1230 | Z/984 | 0.651633 | 0.000613308 | 0.00069003 | 4.81447 | 5.41674
BHL-5-150 | +4.124 | +5.101 | 5.4 | 119.2 | 0.6 | 1230 | Z/983 | 0.64576 | 0.00060765 | 0.00069003 | 4.77005 | 5.41674
BHR-3-350 | +3.921 | +5.302 | 7.9 | 114.4 | 0.8 | 1800 | Z/1110 | 0.907137 | 0.000853953 | 0.0010098 | 6.70353 | 7.92693
BHL-3-350 | +3.616 | +4.996 | 7.9 | 113.8 | 0.8 | 1800 | Z/1109 | 0.902279 | 0.000849309 | 0.0010098 | 6.66707 | 7.92693
BHR-3-300 | +4.021 | +5.331 | 7.5 | 116.3 | 0.8 | 1700 | Z/1083 | 0.870379 | 0.000819396 | 0.0009537 | 6.43226 | 7.48654
BHL-3-300 | +3.712 | +5.022 | 7.5 | 115.6 | 0.8 | 1700 | Z/1082 | 0.865528 | 0.000814755 | 0.0009537 | 6.39582 | 7.48654
BHR-3-250 | +4.295 | +5.357 | 5.9 | 114.9 | 0.6 | 1350 | Z/1052 | 0.683177 | 0.000642822 | 0.00075735 | 5.04615 | 5.9452
BHL-3-250 | +3.964 | +5.026 | 5.9 | 114.1 | 0.6 | 1350 | Z/1051 | 0.678312 | 0.000638158 | 0.00075735 | 5.00954 | 5.9452
BHR-3-200 | +4.367 | +5.376 | 5.6 | 118.1 | 0.6 | 1275 | Z/1025 | 0.663333 | 0.000624243 | 0.000715275 | 4.90031 | 5.61491
BHL-3-200 | +4.034 | +5.043 | 5.6 | 120 | 0.6 | 1275 | Z/1024 | 0.673852 | 0.000626925 | 0.000715275 | 4.92136 | 5.61491
BHR-3-150 | +4.432 | +5.409 | 5.4 | 120.2 | 0.6 | 1230 | Z/982 | 0.651141 | 0.00061283 | 0.00069003 | 4.81072 | 5.41674
BHL-3-150 | +4.093 | +5.070 | 5.4 | 119.6 | 0.6 | 1230 | Z/981 | 0.647869 | 0.000609671 | 0.00069003 | 4.78592 | 5.41674

# IfcPlate: PLT3*290.9 (2)
In: Undefined
Description: PLT3*290.9; Material: STEEL/450
Tekla Common - Bottom elevation: +4.774; Top elevation: +5.020; Phase: 1; Class: 11
Tekla Quantity - Weight: 2.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.8 m2; Net surface area: 0.2 m2; Height: 290.9 mm; Width: 3 mm; Length: 412.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - NetArea: 0.196336 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000288273 m3; GrossVolume: 0.000288273 m3
Name | ASSEMBLY_POS = Reference | Width (mm) | GrossArea (m2)
PLATE | Z/1006 | 290.867 | 0.120007
PLATE | Z/991 | 290.868 | 0.120008

# IfcPlate: PLT3*295.6 (2)
In: Undefined
Description: PLT3*295.6; Material: STEEL/450
Tekla Common - Bottom elevation: +4.774; Top elevation: +5.033; Phase: 1; Class: 11
Tekla Quantity - Weight: 2.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.6 m2; Net surface area: 0.2 m2; Height: 295.6 mm; Width: 3 mm; Length: 421.2 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - NetArea: 0.200954 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00029514 m3; GrossVolume: 0.00029514 m3
Name | ASSEMBLY_POS = Reference | Width (mm) | GrossArea (m2)
PLATE | Z/1005 | 295.632 | 0.124517
PLATE | Z/999 | 295.63 | 0.124516

# IfcPlate: PLT3*304.6 (2)
In: Undefined
Description: PLT3*304.6; Material: STEEL/450
Tekla Common - Bottom elevation: +4.774; Top elevation: +5.060; Phase: 1; Class: 11
Tekla Quantity - Weight: 2.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.6 m2; Net surface area: 0.2 m2; Height: 304.6 mm; Width: 3 mm; Length: 438.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 304.605 mm; NetArea: 0.210452 m2; GrossArea: 0.133615 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000309307 m3; GrossVolume: 0.000309307 m3
Name | ASSEMBLY_POS = Reference
PLATE | Z/1009
PLATE | Z/989

# IfcPlate: PLT3*311.1 (2)
In: Undefined
Description: PLT3*311.1; Material: STEEL/450
Tekla Common - Bottom elevation: +5.164; Top elevation: +5.419; Phase: 1; Class: 11
Tekla Quantity - Weight: 2.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.6 m2; Net surface area: 0.2 m2; Height: 311.1 mm; Width: 3 mm; Length: 403.5 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - NetArea: 0.207043 m2; GrossArea: 0.125545 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000304221 m3; GrossVolume: 0.000304221 m3
Name | ASSEMBLY_POS = Reference | Width (mm)
PLATE | Z/1008 | 311.133
PLATE | Z/990 | 311.132

# IfcPlate: PLT3*326.6 (2)
In: Undefined
Description: PLT3*326.6; Material: STEEL/450
Tekla Common - Bottom elevation: +4.774; Top elevation: +5.068; Phase: 1; Class: 11
Tekla Quantity - Weight: 3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.4 m2; Net surface area: 0.3 m2; Height: 326.6 mm; Width: 3 mm; Length: 482.2 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - NetArea: 0.256943 m2; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Width (mm) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
PLATE | Z/1229 | 326.587 | 0.157484 | 0.00037825
PLATE | Z/846 | 326.583 | 0.157482 | 0.000378251

# IfcPlate: PLT3*333.1 (2)
In: Undefined
Description: PLT3*333.1; Material: STEEL/450
Tekla Common - Bottom elevation: +5.421; Top elevation: +5.700; Phase: 1; Class: 11
Tekla Quantity - Weight: 2.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.6 m2; Net surface area: 0.2 m2; Height: 333.1 mm; Width: 3 mm; Length: 406.4 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - NetArea: 0.220983 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000324973 m3; GrossVolume: 0.000324973 m3
Name | ASSEMBLY_POS = Reference | Width (mm) | GrossArea (m2)
PLATE | Z/1007 | 333.093 | 0.135371
PLATE | Z/992 | 333.091 | 0.13537

# IfcPlate: PLT3*336.8 (2)
In: Undefined
Description: PLT3*336.8; Material: STEEL/450
Tekla Common - Bottom elevation: +5.986; Top elevation: +6.267; Phase: 1; Class: 11
Tekla Quantity - Weight: 2.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.6 m2; Net surface area: 0.2 m2; Height: 336.8 mm; Width: 3 mm; Length: 403.1 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 336.848 mm; NetArea: 0.222298 m2; GrossArea: 0.135774 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000326971 m3; GrossVolume: 0.000326971 m3
Name | ASSEMBLY_POS = Reference
PLATE | Z/1010
PLATE | Z/987

# IfcPlate: PLT3*344.1 (2)
In: Undefined
Description: PLT3*344.1; Material: STEEL/450
Tekla Common - Bottom elevation: +6.413; Top elevation: +6.700; Phase: 1; Class: 11
Tekla Quantity - Weight: 2.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.6 m2; Net surface area: 0.2 m2; Height: 344.1 mm; Width: 3 mm; Length: 408.8 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 344.143 mm; NetArea: 0.225714 m2; GrossArea: 0.140681 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00033197 m3; GrossVolume: 0.00033197 m3
Name | ASSEMBLY_POS = Reference
PLATE | Z/1011
PLATE | Z/988

# IfcPlate: PLT3*350.3 (2)
In: Undefined
Description: PLT3*350.3; Material: STEEL/450
Tekla Common - Bottom elevation: +4.729; Top elevation: +5.022; Phase: 1; Class: 11
Tekla Quantity - Weight: 3.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.4 m2; Net surface area: 0.3 m2; Height: 350.3 mm; Width: 3 mm; Length: 468.3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - NetArea: 0.268637 m2; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Width (mm) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
PLATE | Z/840 | 350.332 | 0.164051 | 0.000395717
PLATE | Z/347 | 350.336 | 0.164054 | 0.000395714

# IfcPlate: PLT3*361.2 (2)
In: Undefined
Description: PLT3*361.2; Material: STEEL/450
Tekla Common - Bottom elevation: +4.724; Top elevation: +5.037; Phase: 1; Class: 11
Tekla Quantity - Weight: 3.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.4 m2; Net surface area: 0.3 m2; Height: 361.2 mm; Width: 3 mm; Length: 480.8 mm
Pset_PlateCommon - LoadBearing: no
