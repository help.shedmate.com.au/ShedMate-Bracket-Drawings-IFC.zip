Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView_V2.0, QuantityTakeOffAddOnView], Option [BaseQuantities:On], Option [GridExport:On], Option [Assemblies:On], Option [Bolts:On], Option [Rebars:On], Option [PourObjects:Off], Option [Welds:Off], Option [SurfaceTreatments:Off], Option [LocationBy:0], Option [ViewColors:Off], Option [SectionedSpine:Off], Option [PropertySets:On], Option [Export all:Off]
File name: Fascia Bracket.ifc
Time: 2026-02-19T15:18:57
Author: DESKTOP-BKNQL56\admin
Organization: Structural Designer
Written by: IFC Database Version: Work
Made in: Tekla Structures 2019 Service Pack 13, IFC Export Version: 4.0.0.0 Oct 18 2021

# IfcBuildingStorey, Undefined
In: Undefined
Elevation: 0 mm

# IfcBeam: C:100-15 (5)
In: Undefined
Description: C:100-15; Material: STEEL/300PLUS
Default - ASSEMBLY_POS: F/7
Tekla Common - Bottom elevation: +3.109; Top elevation: +3.211; Phase: 1; Class: 13
Tekla Quantity - Weight: 3.4 kg; Volume: 0 m3; Gross footprint area: 0.1 m2; Area per tons: 178.9 m2; Net surface area: 0.6 m2; Height: 102 mm; Width: 51 mm; Length: 1350 mm
Pset_BeamCommon - LoadBearing: no; Reference: F/7
BaseQuantities - Length: 1350 mm; OuterSurfaceArea: 0.612225 m2; NetVolume: 0.000455625 m3; NetWeight: 3.57666 kg

# IfcBeam: C:150-15 (5)
In: Undefined
Description: C:150-15; Material: STEEL/300PLUS
Default - ASSEMBLY_POS: F/8
Tekla Common - Bottom elevation: +2.899; Top elevation: +3.051; Phase: 1; Class: 13
Tekla Quantity - Weight: 4.7 kg; Volume: 0 m3; Gross footprint area: 0.1 m2; Area per tons: 176.5 m2; Net surface area: 0.8 m2; Height: 152 mm; Width: 64 mm; Length: 1350 mm
Pset_BeamCommon - LoadBearing: no; Reference: F/8
BaseQuantities - Length: 1350 mm; OuterSurfaceArea: 0.828465 m2; NetVolume: 0.000617625 m3; NetWeight: 4.84836 kg

# IfcBeam: C:200-15 (2)
In: Undefined
Description: C:200-15; Material: STEEL/300PLUS
Default - ASSEMBLY_POS: F/9
Tekla Common - Bottom elevation: +2.638; Top elevation: +2.841; Phase: 1; Class: 13
Tekla Quantity - Weight: 5.9 kg; Volume: 0 m3; Gross footprint area: 0.1 m2; Area per tons: 175.3 m2; Net surface area: 1 m2; Height: 203 mm; Width: 76 mm; Length: 1350 mm
Pset_BeamCommon - LoadBearing: no; Reference: F/9
BaseQuantities - Length: 1350 mm; OuterSurfaceArea: 1.03119 m2; NetVolume: 0.0007695 m3; NetWeight: 6.04058 kg

# IfcBeam: PLT3*60 (12)
In: Undefined
Description: PLT3*60; Material: STEEL/250
Tekla Common - Phase: 1; Class: 12
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 60 mm; Width: 3 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
FASCIA BRACKET | FB/11 | +2.894 | +3.055 | 0.4 | 90.3 | 0 | 268.4 | 268.425 | 0.0347521 | 0.00004905 | 0.385042
FASCIA BRACKET | FB/12 | +3.104 | +3.215 | 0.4 | 90.5 | 0 | 218.4 | 218.425 | 0.0284521 | 0.00004005 | 0.314392
FASCIA BRACKET | FB/10 | +2.894 | +3.055 | 0.4 | 90.2 | 0 | 274.6 | 274.625 | 0.0355333 | 0.000050166 | 0.393803
FASCIA BRACKET | FB/7 | +2.634 | +2.845 | 0.6 | 89.8 | 0.1 | 436.4 | 436.425 | 0.0559201 | 0.00007929 | 0.622426
FASCIA BRACKET | FB/8 | +2.894 | +3.055 | 0.6 | 89.8 | 0 | 386.4 | 386.425 | 0.0496201 | 0.00007029 | 0.551776
FASCIA BRACKET | FB/9 | +3.104 | +3.215 | 0.4 | 90 | 0 | 336.4 | 336.425 | 0.0433201 | 0.00006129 | 0.481126
FASCIA BRACKET | FB/4 | +2.634 | +2.845 | 0.6 | 89.8 | 0 | 388.4 | 388.425 | 0.0498721 | 0.00007065 | 0.554602
FASCIA BRACKET | FB/5 | +2.894 | +3.055 | 0.4 | 90 | 0 | 338.4 | 338.425 | 0.0435721 | 0.00006165 | 0.483952
FASCIA BRACKET | FB/6 | +3.104 | +3.215 | 0.4 | 90.2 | 0 | 288.4 | 288.425 | 0.0372721 | 0.00005265 | 0.413302
FASCIA BRACKET | FB/2 | +2.894 | +3.055 | 0.4 | 90.2 | 0 | 296.4 | 296.425 | 0.0382801 | 0.00005409 | 0.424606
FASCIA BRACKET | FB/3 | +3.104 | +3.215 | 0.4 | 90.3 | 0 | 246.4 | 246.425 | 0.0319801 | 0.00004509 | 0.353956
FASCIA BRACKET | FB/1 | +3.104 | +3.215 | 0.4 | 90.5 | 0 | 224.4 | 224.425 | 0.0292081 | 0.00004113 | 0.32287

# IfcBeam: TH:120-95, TH
In: Undefined
Description: TH:120-95; Material: STEEL/300PLUS
Default - ASSEMBLY_POS: B/4
Tekla Common - Bottom elevation: +2.402; Top elevation: +2.567; Phase: 1; Class: 4
Tekla Quantity - Weight: 2.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 0 m2; Net surface area: 1 m2; Height: 120 mm; Width: 165 mm; Length: 1350 mm
Pset_BeamCommon - LoadBearing: no; Reference: B/4
BaseQuantities - Length: 1350 mm; OuterSurfaceArea: 6.15627e-07 m2; NetVolume: 0.000474125 m3; NetWeight: 3.72188 kg

# IfcBeam: TH:61-95, TH
In: Undefined
Description: TH:61-95; Material: STEEL/300PLUS
Default - ASSEMBLY_POS: B/22
Tekla Common - Bottom elevation: +2.720; Top elevation: +2.850; Phase: 1; Class: 4
Tekla Quantity - Weight: 2.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 0 m2; Net surface area: 0.6 m2; Height: 61 mm; Width: 130 mm; Length: 1350 mm
Pset_BeamCommon - LoadBearing: no; Reference: B/22
BaseQuantities - Length: 1350 mm; OuterSurfaceArea: 6.15627e-07 m2; NetVolume: 0.0002835 m3; NetWeight: 2.22547 kg

# IfcBeam: TH:64-95, TH
In: Undefined
Description: TH:64-95; Material: STEEL/300PLUS
Tekla Common - Bottom elevation: +2.720; Top elevation: +2.850; Phase: 1; Class: 4
Default - ASSEMBLY_POS: B/1
Tekla Quantity - Weight: 2.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 0 m2; Net surface area: 0.6 m2; Height: 64 mm; Width: 130 mm; Length: 1350 mm
Pset_BeamCommon - LoadBearing: no; Reference: B/1
BaseQuantities - Length: 1350 mm; OuterSurfaceArea: 6.15627e-07 m2; NetVolume: 0.000291003 m3; NetWeight: 2.28438 kg

# IfcBeam: TH:75-95, TH
In: Undefined
Description: TH:75-95; Material: STEEL/300PLUS
Default - ASSEMBLY_POS: B/2
Tekla Common - Bottom elevation: +2.422; Top elevation: +2.547; Phase: 1; Class: 4
Tekla Quantity - Weight: 2.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 0 m2; Net surface area: 0.6 m2; Height: 75 mm; Width: 125 mm; Length: 1350 mm
Pset_BeamCommon - LoadBearing: no; Reference: B/2
BaseQuantities - Length: 1350 mm; OuterSurfaceArea: 6.15627e-07 m2; NetVolume: 0.000313066 m3; NetWeight: 2.45757 kg

# IfcBeam: TH:96-95, TH
In: Undefined
Description: TH:96-95; Material: STEEL/300PLUS
Default - ASSEMBLY_POS: B/3
Tekla Common - Bottom elevation: +2.410; Top elevation: +2.560; Phase: 1; Class: 4
Tekla Quantity - Weight: 2.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 0 m2; Net surface area: 0.8 m2; Height: 96 mm; Width: 150 mm; Length: 1350 mm
Pset_BeamCommon - LoadBearing: no; Reference: B/3
BaseQuantities - Length: 1350 mm; OuterSurfaceArea: 6.15627e-07 m2; NetVolume: 0.000387683 m3; NetWeight: 3.04331 kg

# IfcColumn: C:150-24 (5)
In: Undefined
Description: C:150-24; Material: STEEL/G450
Default - ASSEMBLY_POS: Z/8
Tekla Common - Finish: 25 deg; Bottom elevation: +0.000; Top elevation: +3.400; Phase: 1; Class: 10
Tekla Quantity - Weight: 18.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 111.2 m2; Net surface area: 2.1 m2; Height: 152 mm; Width: 64 mm; Length: 3400 mm
Pset_ColumnCommon - LoadBearing: no; Reference: Z/8
BaseQuantities - Length: 3400 mm; OuterSurfaceArea: 2.10812 m2; NetVolume: 0.00250838 m3; NetWeight: 19.6908 kg

# IfcElementAssembly (34)
In: Undefined
PredefinedType: RIGID_FRAME
Name | ASSEMBLY_POSITION_CODE = Assembly/Cast unit position code | ASSEMBLY_POS = Assembly/Cast unit Mark | Assembly/Cast unit weight (kg) | Assembly/Cast unit bottom elevation | Assembly/Cast unit top elevation | Width (mm)
FASCIA BRACKET | C150TB/3> | FB/11 | 0.4 | +2.894 | +3.055 | 161
FASCIA BRACKET | C150TB/3> | FB/12 | 0.4 | +3.104 | +3.215 | 111
FASCIA | C150TB-C200TB/3> | F/8 | 4.7 | +2.899 | +3.051 | 64
FASCIA | C150TB-C200TB/3> | F/7 | 3.4 | +3.109 | +3.211 | 51
TH | C150TB-C200TB/3> | B/22 | 2.4 | +2.720 | +2.850 | 130
COLUMN | C150TB/3> | Z/8 | 18.9 | +0.000 | +3.400 | 64
FASCIA BRACKET | C150TB/2 | FB/10 | 0.4 | +2.894 | +3.055 | 161
FASCIA | C150TB-C200TB/2 | F/8 | 4.7 | +2.899 | +3.051 | 64
FASCIA BRACKET | C150TB/5 | FB/7 | 0.6 | +2.634 | +2.845 | 211
FASCIA BRACKET | C150TB/5 | FB/8 | 0.6 | +2.894 | +3.055 | 161
FASCIA BRACKET | C150TB/5 | FB/9 | 0.4 | +3.104 | +3.215 | 111
FASCIA BRACKET | C150TB/4 | FB/4 | 0.6 | +2.634 | +2.845 | 211
FASCIA BRACKET | C150TB/4 | FB/5 | 0.4 | +2.894 | +3.055 | 161
FASCIA BRACKET | C150TB/4 | FB/6 | 0.4 | +3.104 | +3.215 | 111
FASCIA BRACKET | C150TB/3 | FB/2 | 0.4 | +2.894 | +3.055 | 161
FASCIA BRACKET | C150TB/3 | FB/3 | 0.4 | +3.104 | +3.215 | 111
FASCIA BRACKET | C150TB/2 | FB/1 | 0.4 | +3.104 | +3.215 | 111
FASCIA | C150TB-C200TB/5 | F/9 | 5.9 | +2.638 | +2.841 | 76
FASCIA | C150TB-C200TB/5 | F/8 | 4.7 | +2.899 | +3.051 | 64
FASCIA | C150TB-C200TB/5 | F/7 | 3.4 | +3.109 | +3.211 | 51
TH | C150TB-C200TB/5 | B/4 | 2.4 | +2.402 | +2.567 | 165
COLUMN | C150TB/5 | Z/8 | 18.9 | +0.000 | +3.400 | 64
FASCIA | C150TB-C200TB/4 | F/9 | 5.9 | +2.638 | +2.841 | 76
FASCIA | C150TB-C200TB/4 | F/8 | 4.7 | +2.899 | +3.051 | 64
FASCIA | C150TB-C200TB/4 | F/7 | 3.4 | +3.109 | +3.211 | 51
TH | C150TB-C200TB/4 | B/3 | 2.4 | +2.410 | +2.560 | 150
COLUMN | C150TB/4 | Z/8 | 18.9 | +0.000 | +3.400 | 64
FASCIA | C150TB-C200TB/3 | F/8 | 4.7 | +2.899 | +3.051 | 64
FASCIA | C150TB-C200TB/3 | F/7 | 3.4 | +3.109 | +3.211 | 51
TH | C150TB-C200TB/3 | B/2 | 2.4 | +2.422 | +2.547 | 125
COLUMN | C150TB/3 | Z/8 | 18.9 | +0.000 | +3.400 | 64
FASCIA | C150TB-C200TB/2 | F/7 | 3.4 | +3.109 | +3.211 | 51
TH | C150TB-C200TB/2 | B/1 | 2.4 | +2.720 | +2.850 | 130
COLUMN | C150TB/2 | Z/8 | 18.9 | +0.000 | +3.400 | 64

# IfcMechanicalFastener: Bolt assembly (36)
In: Undefined
NominalDiameter: 5 mm; NominalLength: 25 mm; Material: TEK_16TPIM
Tekla Bolt - Washer diameter: 5 mm; Washer type: UNDEF_WASH; Washer name: UNDEFINED_WASHER5; Nut type: UNDEF_NUT; Nut name: UNDEFINED_NUTM5; Slotted hole y: 0 mm; Slotted hole x: 0 mm; Bolt hole diameter: 7 mm; Location: Site; Bolt size: 5 mm; Bolt length: 25 mm; Bolt standard: TEK_16TPIM; Bolt Name: TEKSCREW_M5*25
Name | Washer count | Nut count = Bolt count
24 x Bolt assembly | 4 | 2
12 x Bolt assembly | 8 | 4
