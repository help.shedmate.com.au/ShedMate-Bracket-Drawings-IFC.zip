Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView_V2.0, QuantityTakeOffAddOnView], Option [BaseQuantities:On], Option [GridExport:On], Option [Assemblies:On], Option [Bolts:On], Option [Rebars:On], Option [PourObjects:Off], Option [Welds:Off], Option [SurfaceTreatments:Off], Option [LocationBy:0], Option [ViewColors:Off], Option [SectionedSpine:Off], Option [PropertySets:On], Option [Export all:Off]
File name: Double C-Section Purlin&Girt Bracket.ifc
Time: 2026-04-17T09:14:47
Author: DESKTOP-BKNQL56\admin
Organization: Structural Designer
Written by: IFC Database Version: Work
Made in: Tekla Structures 2019 Service Pack 13, IFC Export Version: 4.0.0.0 Oct 18 2021

# IfcBuildingStorey, Undefined
In: Undefined
Elevation: 0 mm

# IfcBeam: C:100-15 (20)
In: Undefined
Description: C:100-15; Material: STEEL/450
Tekla Common - Bottom elevation: +0.249; Top elevation: +0.300; Phase: 1; Class: 99
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 102 mm; Width: 51 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
5 x GIRT | Z/1916 | 1.1 | 179.3 | 0.2 | 436 | 0.198183 | 0.00014715 | 1.15513
GIRT | Z/1997 | 1.1 | 179.3 | 0.2 | 436 | 0.198183 | 0.00014715 | 1.15513
GIRT | Z/1967 | 1.1 | 179.3 | 0.2 | 436 | 0.198183 | 0.00014715 | 1.15513
2 x GIRT | Z/1932 | 1.1 | 179.3 | 0.2 | 436 | 0.198183 | 0.00014715 | 1.15513
GIRT | Z/1898 | 1.1 | 179.3 | 0.2 | 436 | 0.198183 | 0.00014715 | 1.15513
GIRT | Z/2015 | 0.5 | 179.9 | 0.1 | 213 | 0.097164 | 0.0000718875 | 0.564317
GIRT | Z/1987 | 0.5 | 179.9 | 0.1 | 213 | 0.097164 | 0.0000718875 | 0.564317
GIRT | Z/1984 | 0.5 | 179.9 | 0.1 | 213 | 0.097164 | 0.0000718875 | 0.564317
GIRT | Z/1957 | 0.5 | 179.9 | 0.1 | 213 | 0.097164 | 0.0000718875 | 0.564317
2 x GIRT | Z/1949 | 0.5 | 179.9 | 0.1 | 213 | 0.097164 | 0.0000718875 | 0.564317
2 x GIRT | Z/1922 | 0.5 | 179.9 | 0.1 | 213 | 0.097164 | 0.0000718875 | 0.564317
GIRT | Z/1919 | 0.5 | 179.9 | 0.1 | 213 | 0.097164 | 0.0000718875 | 0.564317
GIRT | Z/1889 | 0.5 | 179.9 | 0.1 | 213 | 0.097164 | 0.0000718875 | 0.564317

# IfcBeam: C:150-15 (20)
In: Undefined
Description: C:150-15; Material: STEEL/450
Tekla Common - Bottom elevation: +0.936; Top elevation: +1.000; Phase: 1; Class: 99
Tekla Quantity - Volume: 0 m3; Height: 152 mm; Width: 64 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Weight (kg) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
5 x GIRT | Z/1917 | 1.5 | 0.1 | 176.9 | 0.3 | 436 | 0.268183 | 0.00019947 | 1.56584
GIRT | Z/1998 | 1.5 | 0.1 | 176.9 | 0.3 | 436 | 0.268183 | 0.00019947 | 1.56584
GIRT | Z/1968 | 1.5 | 0.1 | 176.9 | 0.3 | 436 | 0.268183 | 0.00019947 | 1.56584
2 x GIRT | Z/1933 | 1.5 | 0.1 | 176.9 | 0.3 | 436 | 0.268183 | 0.00019947 | 1.56584
GIRT | Z/1899 | 1.5 | 0.1 | 176.9 | 0.3 | 436 | 0.268183 | 0.00019947 | 1.56584
GIRT | Z/2016 | 0.6 | 0 | 177.5 | 0.1 | 213 | 0.131484 | 0.0000974475 | 0.764963
GIRT | Z/1988 | 0.6 | 0 | 177.5 | 0.1 | 213 | 0.131484 | 0.0000974475 | 0.764963
GIRT | Z/1985 | 0.6 | 0 | 177.5 | 0.1 | 213 | 0.131484 | 0.0000974475 | 0.764963
GIRT | Z/1958 | 0.6 | 0 | 177.5 | 0.1 | 213 | 0.131484 | 0.0000974475 | 0.764963
2 x GIRT | Z/1950 | 0.6 | 0 | 177.5 | 0.1 | 213 | 0.131484 | 0.0000974475 | 0.764963
2 x GIRT | Z/1923 | 0.6 | 0 | 177.5 | 0.1 | 213 | 0.131484 | 0.0000974475 | 0.764963
GIRT | Z/1920 | 0.6 | 0 | 177.5 | 0.1 | 213 | 0.131484 | 0.0000974475 | 0.764963
GIRT | Z/1890 | 0.6 | 0 | 177.5 | 0.1 | 213 | 0.131484 | 0.0000974475 | 0.764963

# IfcBeam: C:150-24 (6)
In: Undefined
Description: C:150-24; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Top elevation: +2.000; Phase: 1; Class: 12
Tekla Quantity - Weight: 11.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 111.3 m2; Net surface area: 1.2 m2; Height: 152 mm; Width: 64 mm; Length: 2000 mm
Pset_BeamCommon - LoadBearing: no
BaseQuantities - Length: 2000 mm; OuterSurfaceArea: 1.24068 m2; NetVolume: 0.00147552 m3; NetWeight: 11.5828 kg
Name | ASSEMBLY_POS = Reference
COLUMN | Z/1622
COLUMN | Z/1892
2 x COLUMN | Z/1893
2 x COLUMN | Z/1894

# IfcBeam: C:200-15 (20)
In: Undefined
Description: C:200-15; Material: STEEL/450
Tekla Common - Bottom elevation: +1.624; Top elevation: +1.700; Phase: 1; Class: 99
Tekla Quantity - Volume: 0 m3; Height: 203 mm; Width: 76 mm
Pset_BeamCommon - LoadBearing: no
Name | BaseQuantities, Length (mm) = Tekla Quantity, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg) | ASSEMBLY_POS = Reference | Weight (kg) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2)
5 x GIRT | 436 | 0.333808 | 0.00024852 | 1.95088 | Z/1918 | 1.9 | 0.1 | 175.7 | 0.3
GIRT | 436 | 0.333808 | 0.00024852 | 1.95088 | Z/1999 | 1.9 | 0.1 | 175.7 | 0.3
GIRT | 436 | 0.333808 | 0.00024852 | 1.95088 | Z/1969 | 1.9 | 0.1 | 175.7 | 0.3
2 x GIRT | 436 | 0.333808 | 0.00024852 | 1.95088 | Z/1934 | 1.9 | 0.1 | 175.7 | 0.3
GIRT | 436 | 0.333808 | 0.00024852 | 1.95088 | Z/1900 | 1.9 | 0.1 | 175.7 | 0.3
GIRT | 213 | 0.163659 | 0.00012141 | 0.953069 | Z/2017 | 0.9 | 0 | 176.4 | 0.2
GIRT | 213 | 0.163659 | 0.00012141 | 0.953068 | Z/1989 | 0.9 | 0 | 176.4 | 0.2
GIRT | 213 | 0.163659 | 0.00012141 | 0.953069 | Z/1986 | 0.9 | 0 | 176.4 | 0.2
GIRT | 213 | 0.163659 | 0.00012141 | 0.953068 | Z/1959 | 0.9 | 0 | 176.4 | 0.2
2 x GIRT | 213 | 0.163659 | 0.00012141 | 0.953069 | Z/1951 | 0.9 | 0 | 176.4 | 0.2
2 x GIRT | 213 | 0.163659 | 0.00012141 | 0.953068 | Z/1924 | 0.9 | 0 | 176.4 | 0.2
GIRT | 213 | 0.163659 | 0.00012141 | 0.953069 | Z/1921 | 0.9 | 0 | 176.4 | 0.2
GIRT | 213 | 0.163659 | 0.00012141 | 0.953068 | Z/1891 | 0.9 | 0 | 176.4 | 0.2

# IfcBeam: C:200-24 (6)
In: Undefined
Description: C:200-24; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Top elevation: +2.000; Phase: 1; Class: 12
Tekla Quantity - Weight: 14.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 110.1 m2; Net surface area: 1.6 m2; Height: 203 mm; Width: 76 mm; Length: 2000 mm
Pset_BeamCommon - LoadBearing: no
BaseQuantities - Length: 2000 mm; OuterSurfaceArea: 1.56106 m2; NetVolume: 0.00185952 m3; NetWeight: 14.5972 kg
Name | ASSEMBLY_POS = Reference
COLUMN | Z/1632
COLUMN | Z/1925
2 x COLUMN | Z/1926
2 x COLUMN | Z/1927

# IfcBeam: C:250-24 (6)
In: Undefined
Description: C:250-24; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Top elevation: +2.000; Phase: 1; Class: 12
Tekla Quantity - Weight: 16 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 109.8 m2; Net surface area: 1.8 m2; Height: 254 mm; Width: 76 mm; Length: 2000 mm
Pset_BeamCommon - LoadBearing: no
BaseQuantities - Length: 2000 mm; OuterSurfaceArea: 1.7613 m2; NetVolume: 0.00209952 m3; NetWeight: 16.4812 kg
Name | ASSEMBLY_POS = Reference
2 x COLUMN | Z/1952
2 x COLUMN | Z/1953
2 x COLUMN | Z/1954

# IfcBeam: C:300-24 (6)
In: Undefined
Description: C:300-24; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Top elevation: +2.000; Phase: 1; Class: 12
Tekla Quantity - Weight: 19.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 108.6 m2; Net surface area: 2.2 m2; Height: 300 mm; Width: 96 mm; Length: 2000 mm
Pset_BeamCommon - LoadBearing: no
BaseQuantities - Length: 2000 mm; OuterSurfaceArea: 2.16178 m2; NetVolume: 0.00257952 m3; NetWeight: 20.2492 kg
Name | ASSEMBLY_POS = Reference
2 x COLUMN | Z/1960
COLUMN | Z/1961
COLUMN | Z/1962
2 x COLUMN | Z/1963

# IfcBeam: C:350-30 (6)
In: Undefined
Description: C:350-30; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Top elevation: +2.000; Phase: 1; Class: 12
Tekla Quantity - Weight: 29.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.2 m2; Net surface area: 2.6 m2; Height: 350 mm; Width: 125 mm; Length: 2000 mm
Pset_BeamCommon - LoadBearing: no
BaseQuantities - Length: 2000 mm; OuterSurfaceArea: 2.60789 m2; NetVolume: 0.003888 m3; NetWeight: 30.5208 kg
Name | ASSEMBLY_POS = Reference
2 x COLUMN | Z/1990
2 x COLUMN | Z/1991
2 x COLUMN | Z/1992

# IfcBeam: Z:100-15 (20)
In: Undefined
Description: Z:100-15; Material: STEEL/450
Tekla Common - Phase: 1; Class: 99
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 102 mm; Width: 100.5 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
5 x GIRT | Z/1623 | +0.252 | +0.352 | 1.1 | 179.5 | 0.2 | 436 | 0.198183 | 0.00014715 | 1.15513
GIRT | Z/2009 | +0.252 | +0.352 | 2.4 | 179.3 | 0.3 | 950 | 0.431025 | 0.000320625 | 2.51691
GIRT | Z/1978 | +0.252 | +0.352 | 2.4 | 179.3 | 0.3 | 950 | 0.431025 | 0.000320625 | 2.51691
2 x GIRT | Z/1943 | +0.252 | +0.352 | 2.4 | 179.3 | 0.3 | 950 | 0.431025 | 0.000320625 | 2.51691
GIRT | Z/1910 | +0.252 | +0.352 | 2.4 | 179.3 | 0.3 | 950 | 0.431025 | 0.000320625 | 2.51691
GIRT | Z/2000 | +0.248 | +0.348 | 2.4 | 179.3 | 0.3 | 950 | 0.431025 | 0.000320625 | 2.51691
GIRT | Z/2012 | +0.252 | +0.352 | 2.4 | 179.3 | 0.3 | 950 | 0.431025 | 0.000320625 | 2.51691
GIRT | Z/1970 | +0.248 | +0.348 | 2.4 | 179.3 | 0.3 | 950 | 0.431025 | 0.000320625 | 2.51691
GIRT | Z/1981 | +0.252 | +0.352 | 2.4 | 179.3 | 0.3 | 950 | 0.431025 | 0.000320625 | 2.51691
2 x GIRT | Z/1935 | +0.248 | +0.348 | 2.4 | 179.3 | 0.3 | 950 | 0.431025 | 0.000320625 | 2.51691
2 x GIRT | Z/1946 | +0.252 | +0.352 | 2.4 | 179.3 | 0.3 | 950 | 0.431025 | 0.000320625 | 2.51691
GIRT | Z/1901 | +0.248 | +0.348 | 2.4 | 179.3 | 0.3 | 950 | 0.431025 | 0.000320625 | 2.51691
GIRT | Z/1913 | +0.252 | +0.352 | 2.4 | 179.3 | 0.3 | 950 | 0.431025 | 0.000320625 | 2.51691

# IfcBeam: Z:150-15 (20)
In: Undefined
Description: Z:150-15; Material: STEEL/450
Tekla Common - Phase: 1; Class: 99
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 152 mm; Width: 124.5 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
5 x GIRT | Z/1627 | +0.940 | +1.064 | 1.5 | 177.1 | 0.3 | 436 | 0.268183 | 0.00019947 | 1.56584
GIRT | Z/2010 | +0.940 | +1.064 | 3.3 | 176.7 | 0.7 | 950 | 0.583265 | 0.000434625 | 3.41181
GIRT | Z/1979 | +0.940 | +1.064 | 3.3 | 176.7 | 0.7 | 950 | 0.583265 | 0.000434625 | 3.41181
2 x GIRT | Z/1944 | +0.940 | +1.064 | 3.3 | 176.7 | 0.7 | 950 | 0.583265 | 0.000434625 | 3.41181
GIRT | Z/1911 | +0.940 | +1.064 | 3.3 | 176.7 | 0.7 | 950 | 0.583265 | 0.000434625 | 3.41181
GIRT | Z/2001 | +0.936 | +1.060 | 3.3 | 176.7 | 0.7 | 950 | 0.583265 | 0.000434625 | 3.41181
GIRT | Z/2013 | +0.940 | +1.064 | 3.3 | 176.7 | 0.7 | 950 | 0.583265 | 0.000434625 | 3.41181
GIRT | Z/1971 | +0.936 | +1.060 | 3.3 | 176.7 | 0.7 | 950 | 0.583265 | 0.000434625 | 3.41181
GIRT | Z/1982 | +0.940 | +1.064 | 3.3 | 176.7 | 0.7 | 950 | 0.583265 | 0.000434625 | 3.41181
2 x GIRT | Z/1936 | +0.936 | +1.060 | 3.3 | 176.7 | 0.7 | 950 | 0.583265 | 0.000434625 | 3.41181
2 x GIRT | Z/1947 | +0.940 | +1.064 | 3.3 | 176.7 | 0.7 | 950 | 0.583265 | 0.000434625 | 3.41181
GIRT | Z/1902 | +0.936 | +1.060 | 3.3 | 176.7 | 0.7 | 950 | 0.583265 | 0.000434625 | 3.41181
GIRT | Z/1914 | +0.940 | +1.064 | 3.3 | 176.7 | 0.7 | 950 | 0.583265 | 0.000434625 | 3.41181

# IfcBeam: Z:200-15 (20)
In: Undefined
Description: Z:200-15; Material: STEEL/450
Tekla Common - Phase: 1; Class: 99
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 203 mm; Width: 151.5 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
5 x GIRT | Z/1628 | +1.627 | +1.778 | 1.9 | 175.7 | 0.3 | 436 | 0.333808 | 0.00024852 | 1.95088
GIRT | Z/2011 | +1.627 | +1.778 | 4.1 | 175.4 | 0.7 | 950 | 0.72599 | 0.0005415 | 4.25078
GIRT | Z/1980 | +1.627 | +1.778 | 4.1 | 175.4 | 0.7 | 950 | 0.72599 | 0.0005415 | 4.25078
2 x GIRT | Z/1945 | +1.627 | +1.778 | 4.1 | 175.4 | 0.7 | 950 | 0.72599 | 0.0005415 | 4.25078
GIRT | Z/1912 | +1.627 | +1.778 | 4.1 | 175.4 | 0.7 | 950 | 0.72599 | 0.0005415 | 4.25078
GIRT | Z/2002 | +1.622 | +1.773 | 4.1 | 175.4 | 0.7 | 950 | 0.72599 | 0.0005415 | 4.25077
GIRT | Z/2014 | +1.627 | +1.778 | 4.1 | 175.4 | 0.7 | 950 | 0.72599 | 0.0005415 | 4.25078
GIRT | Z/1972 | +1.622 | +1.773 | 4.1 | 175.4 | 0.7 | 950 | 0.72599 | 0.0005415 | 4.25077
GIRT | Z/1983 | +1.627 | +1.778 | 4.1 | 175.4 | 0.7 | 950 | 0.72599 | 0.0005415 | 4.25078
2 x GIRT | Z/1937 | +1.622 | +1.773 | 4.1 | 175.4 | 0.7 | 950 | 0.72599 | 0.0005415 | 4.25077
2 x GIRT | Z/1948 | +1.627 | +1.778 | 4.1 | 175.4 | 0.7 | 950 | 0.72599 | 0.0005415 | 4.25078
GIRT | Z/1903 | +1.622 | +1.773 | 4.1 | 175.4 | 0.7 | 950 | 0.72599 | 0.0005415 | 4.25077
GIRT | Z/1915 | +1.627 | +1.778 | 4.1 | 175.4 | 0.7 | 950 | 0.72599 | 0.0005415 | 4.25078

# IfcColumn: C:150-24 (6)
In: Undefined
Description: C:150-24; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Top elevation: +2.000; Phase: 1; Class: 12
Tekla Quantity - Weight: 11.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 111.3 m2; Net surface area: 1.2 m2; Height: 152 mm; Width: 64 mm; Length: 2000 mm
BaseQuantities - Length: 2000 mm; OuterSurfaceArea: 1.24068 m2; NetVolume: 0.00147552 m3; NetWeight: 11.5828 kg
Pset_ColumnCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference
COLUMN | Z/1622
COLUMN | Z/1892
COLUMN | Z/1904
2 x COLUMN | Z/1905
COLUMN | Z/1683

# IfcColumn: C:200-24 (6)
In: Undefined
Description: C:200-24; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Top elevation: +2.000; Phase: 1; Class: 12
Tekla Quantity - Weight: 14.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 110.1 m2; Net surface area: 1.6 m2; Height: 203 mm; Width: 76 mm; Length: 2000 mm
BaseQuantities - Length: 2000 mm; OuterSurfaceArea: 1.56106 m2; NetVolume: 0.00185952 m3; NetWeight: 14.5972 kg
Pset_ColumnCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference
COLUMN | Z/1632
COLUMN | Z/1925
2 x COLUMN | Z/1938
2 x COLUMN | Z/1939

# IfcColumn: C:250-24 (6)
In: Undefined
Description: C:250-24; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Top elevation: +2.000; Phase: 1; Class: 12
Tekla Quantity - Weight: 16 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 109.8 m2; Net surface area: 1.8 m2; Height: 254 mm; Width: 76 mm; Length: 2000 mm
BaseQuantities - Length: 2000 mm; OuterSurfaceArea: 1.7613 m2; NetVolume: 0.00209952 m3; NetWeight: 16.4812 kg
Pset_ColumnCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference
2 x COLUMN | Z/1952
2 x COLUMN | Z/1955
2 x COLUMN | Z/1956

# IfcColumn: C:300-24 (6)
In: Undefined
Description: C:300-24; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Top elevation: +2.000; Phase: 1; Class: 12
Tekla Quantity - Weight: 19.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 108.6 m2; Net surface area: 2.2 m2; Height: 300 mm; Width: 96 mm; Length: 2000 mm
BaseQuantities - Length: 2000 mm; OuterSurfaceArea: 2.16178 m2; NetVolume: 0.00257952 m3; NetWeight: 20.2492 kg
Pset_ColumnCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference
2 x COLUMN | Z/1960
2 x COLUMN | Z/1974
2 x COLUMN | Z/1975

# IfcColumn: C:350-30 (6)
In: Undefined
Description: C:350-30; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Top elevation: +2.000; Phase: 1; Class: 12
Tekla Quantity - Weight: 29.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.2 m2; Net surface area: 2.6 m2; Height: 350 mm; Width: 125 mm; Length: 2000 mm
BaseQuantities - Length: 2000 mm; OuterSurfaceArea: 2.60789 m2; NetVolume: 0.003888 m3; NetWeight: 30.5208 kg
Pset_ColumnCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference
2 x COLUMN | Z/1990
COLUMN | Z/2005
COLUMN | Z/2006
2 x COLUMN | Z/2007

# IfcElementAssembly (270)
In: Undefined
PredefinedType: RIGID_FRAME
Name | ASSEMBLY_POSITION_CODE = Assembly/Cast unit position code | ASSEMBLY_POS = Assembly/Cast unit Mark | Assembly/Cast unit weight (kg) | Assembly/Cast unit bottom elevation | Assembly/Cast unit top elevation | Width (mm)
4 x COLUMN | C350/Double C type3 | Z/1990 | 29.9 | +0.000 | +2.000 | 125
4 x COLUMN | C300/Double C type3 | Z/1960 | 19.9 | +0.000 | +2.000 | 96
4 x COLUMN | C250/Double C type3 | Z/1952 | 16 | +0.000 | +2.000 | 76
2 x COLUMN | C200/Double C type3 | Z/1632 | 14.2 | +0.000 | +2.000 | 76
2 x COLUMN | C150/Double C type3 | Z/1622 | 11.1 | +0.000 | +2.000 | 64
GIRT | C350/Double C type3 | Z/1628 | 1.9 | +1.627 | +1.778 | 151.5
GIRT | C350/Double C type3 | Z/1627 | 1.5 | +0.940 | +1.064 | 124.5
GIRT | C350/Double C type3 | Z/1623 | 1.1 | +0.252 | +0.352 | 100.5
GIRT | C300/Double C type3 | Z/1628 | 1.9 | +1.627 | +1.778 | 151.5
GIRT | C300/Double C type3 | Z/1627 | 1.5 | +0.940 | +1.064 | 124.5
GIRT | C300/Double C type3 | Z/1623 | 1.1 | +0.252 | +0.352 | 100.5
GIRT | C250/Double C type3 | Z/1628 | 1.9 | +1.627 | +1.778 | 151.5
GIRT | C250/Double C type3 | Z/1627 | 1.5 | +0.940 | +1.064 | 124.5
GIRT | C250/Double C type3 | Z/1623 | 1.1 | +0.252 | +0.352 | 100.5
GIRT | C200/Double C type3 | Z/1628 | 1.9 | +1.627 | +1.778 | 151.5
GIRT | C200/Double C type3 | Z/1627 | 1.5 | +0.940 | +1.064 | 124.5
GIRT | C200/Double C type3 | Z/1623 | 1.1 | +0.252 | +0.352 | 100.5
GIRT | C150/Double C type3 | Z/1628 | 1.9 | +1.627 | +1.778 | 151.5
GIRT | C150/Double C type3 | Z/1627 | 1.5 | +0.940 | +1.064 | 124.5
GIRT | C150/Double C type3 | Z/1623 | 1.1 | +0.252 | +0.352 | 100.5
GIRT/PURLIN BRACKETS | C350/Double C type3 | PL/813 | 0.6 | +1.634 | +1.699 | 65
GIRT/PURLIN BRACKETS | C350/Double C type3 | PL/812 | 0.5 | +0.934 | +0.999 | 65
GIRT/PURLIN BRACKETS | C350/Double C type3 | PL/811 | 0.5 | +0.234 | +0.299 | 65
GIRT/PURLIN BRACKETS | C300/Double C type3 | PL/810 | 0.6 | +1.634 | +1.699 | 65
GIRT/PURLIN BRACKETS | C300/Double C type3 | PL/809 | 0.5 | +0.934 | +0.999 | 65
GIRT/PURLIN BRACKETS | C300/Double C type3 | PL/808 | 0.5 | +0.234 | +0.299 | 65
GIRT/PURLIN BRACKETS | C250/Double C type3 | PL/807 | 0.5 | +1.634 | +1.699 | 65
GIRT/PURLIN BRACKETS | C250/Double C type3 | PL/806 | 0.5 | +0.934 | +0.999 | 65
GIRT/PURLIN BRACKETS | C250/Double C type3 | PL/805 | 0.5 | +0.234 | +0.299 | 65
GIRT/PURLIN BRACKETS | C200/Double C type3 | PL/807 | 0.5 | +1.634 | +1.699 | 65
GIRT/PURLIN BRACKETS | C200/Double C type3 | PL/806 | 0.5 | +0.934 | +0.999 | 65
2 x GIRT/PURLIN BRACKETS | C200/Double C type3 | PL/805 | 0.5 | +0.300 | +0.365 | 65
GIRT/PURLIN BRACKETS | C150/Double C type3 | PL/804 | 0.5 | +1.634 | +1.699 | 65
GIRT/PURLIN BRACKETS | C150/Double C type3 | PL/801 | 0.5 | +0.934 | +0.999 | 65
2 x GIRT/PURLIN BRACKETS | C150/Double C type3 | PL/796 | 0.5 | +0.300 | +0.365 | 65
GIRT | C350/Double Z type1 | Z/2010 | 3.3 | +0.940 | +1.064 | 124.5
COLUMN | C350/Double Z type1 | Z/1991 | 29.9 | +0.000 | +2.000 | 125
COLUMN | C350/Double Z type1 | Z/2005 | 29.9 | +0.000 | +2.000 | 125
GIRT/PURLIN BRACKETS | C350/Double Z type1 | PL/803 | 0.5 | +0.934 | +0.999 | 65
COLUMN | C200/Double Z type2 | Z/1926 | 14.2 | +0.000 | +2.000 | 76
GIRT | C200/Double Z type2 | Z/1935 | 2.4 | +0.248 | +0.348 | 100.5
COLUMN | C200/Double Z type2 | Z/1938 | 14.2 | +0.000 | +2.000 | 76
GIRT/PURLIN BRACKETS | C200/Double Z type2 | PL/795 | 0.5 | +0.234 | +0.299 | 65
2 x COLUMN | C200/Double C type3 | Z/1925 | 14.2 | +0.000 | +2.000 | 76
2 x COLUMN | C150/Double C type3 | Z/1892 | 11.1 | +0.000 | +2.000 | 64
GIRT | C350/Double C type3 | Z/1918 | 1.9 | +1.624 | +1.700 | 76
GIRT | C350/Double C type3 | Z/1917 | 1.5 | +0.936 | +1.000 | 64
GIRT | C350/Double C type3 | Z/1916 | 1.1 | +0.249 | +0.300 | 51
GIRT/PURLIN BRACKETS | C350/Double C type3 | PL/813 | 0.6 | +1.700 | +1.765 | 65
GIRT/PURLIN BRACKETS | C350/Double C type3 | PL/812 | 0.5 | +1.000 | +1.065 | 65
GIRT/PURLIN BRACKETS | C350/Double C type3 | PL/811 | 0.5 | +0.300 | +0.365 | 65
GIRT | C300/Double C type3 | Z/1918 | 1.9 | +1.624 | +1.700 | 76
GIRT | C300/Double C type3 | Z/1917 | 1.5 | +0.936 | +1.000 | 64
GIRT | C300/Double C type3 | Z/1916 | 1.1 | +0.249 | +0.300 | 51
GIRT/PURLIN BRACKETS | C300/Double C type3 | PL/810 | 0.6 | +1.700 | +1.765 | 65
GIRT/PURLIN BRACKETS | C300/Double C type3 | PL/809 | 0.5 | +1.000 | +1.065 | 65
GIRT/PURLIN BRACKETS | C300/Double C type3 | PL/808 | 0.5 | +0.300 | +0.365 | 65
GIRT | C250/Double C type3 | Z/1918 | 1.9 | +1.624 | +1.700 | 76
GIRT | C250/Double C type3 | Z/1917 | 1.5 | +0.936 | +1.000 | 64
GIRT | C250/Double C type3 | Z/1916 | 1.1 | +0.249 | +0.300 | 51
GIRT/PURLIN BRACKETS | C250/Double C type3 | PL/807 | 0.5 | +1.700 | +1.765 | 65
GIRT/PURLIN BRACKETS | C250/Double C type3 | PL/806 | 0.5 | +1.000 | +1.065 | 65
GIRT/PURLIN BRACKETS | C250/Double C type3 | PL/805 | 0.5 | +0.300 | +0.365 | 65
GIRT | C200/Double C type3 | Z/1918 | 1.9 | +1.624 | +1.700 | 76
GIRT | C200/Double C type3 | Z/1917 | 1.5 | +0.936 | +1.000 | 64
GIRT | C200/Double C type3 | Z/1916 | 1.1 | +0.249 | +0.300 | 51
GIRT/PURLIN BRACKETS | C200/Double C type3 | PL/807 | 0.5 | +1.700 | +1.765 | 65
GIRT/PURLIN BRACKETS | C200/Double C type3 | PL/806 | 0.5 | +1.000 | +1.065 | 65
GIRT | C150/Double C type3 | Z/1918 | 1.9 | +1.624 | +1.700 | 76
GIRT | C150/Double C type3 | Z/1917 | 1.5 | +0.936 | +1.000 | 64
GIRT | C150/Double C type3 | Z/1916 | 1.1 | +0.249 | +0.300 | 51
GIRT/PURLIN BRACKETS | C150/Double C type3 | PL/804 | 0.5 | +1.700 | +1.765 | 65
GIRT/PURLIN BRACKETS | C150/Double C type3 | PL/801 | 0.5 | +1.000 | +1.065 | 65
COLUMN | C350/Double C type1 | Z/1992 | 29.9 | +0.000 | +2.000 | 125
COLUMN | C350/Double C type1 | Z/2007 | 29.9 | +0.000 | +2.000 | 125
COLUMN | C300/Double C type1 | Z/1963 | 19.9 | +0.000 | +2.000 | 96
COLUMN | C300/Double C type1 | Z/1975 | 19.9 | +0.000 | +2.000 | 96
COLUMN | C250/Double C type1 | Z/1954 | 16 | +0.000 | +2.000 | 76
COLUMN | C250/Double C type1 | Z/1956 | 16 | +0.000 | +2.000 | 76
COLUMN | C200/Double C type1 | Z/1927 | 14.2 | +0.000 | +2.000 | 76
COLUMN | C200/Double C type1 | Z/1939 | 14.2 | +0.000 | +2.000 | 76
COLUMN | C350/Double C type2 | Z/1992 | 29.9 | +0.000 | +2.000 | 125
COLUMN | C350/Double C type2 | Z/2007 | 29.9 | +0.000 | +2.000 | 125
COLUMN | C300/Double C type2 | Z/1963 | 19.9 | +0.000 | +2.000 | 96
COLUMN | C300/Double C type2 | Z/1975 | 19.9 | +0.000 | +2.000 | 96
COLUMN | C250/Double C type2 | Z/1954 | 16 | +0.000 | +2.000 | 76
COLUMN | C250/Double C type2 | Z/1956 | 16 | +0.000 | +2.000 | 76
COLUMN | C200/Double C type2 | Z/1927 | 14.2 | +0.000 | +2.000 | 76
COLUMN | C200/Double C type2 | Z/1939 | 14.2 | +0.000 | +2.000 | 76
COLUMN | C150/Double C type1 | Z/1894 | 11.1 | +0.000 | +2.000 | 64
COLUMN | C150/Double C type1 | Z/1905 | 11.1 | +0.000 | +2.000 | 64
COLUMN | C150/Double C type2 | Z/1894 | 11.1 | +0.000 | +2.000 | 64
COLUMN | C150/Double C type2 | Z/1905 | 11.1 | +0.000 | +2.000 | 64
GIRT | C300/Double Z type1 | Z/1978 | 2.4 | +0.252 | +0.352 | 100.5
COLUMN | C300/Double Z type1 | Z/1961 | 19.9 | +0.000 | +2.000 | 96
COLUMN | C250/Double Z type1 | Z/1953 | 16 | +0.000 | +2.000 | 76
COLUMN | C200/Double Z type1 | Z/1926 | 14.2 | +0.000 | +2.000 | 76
COLUMN | C150/Double Z type1 | Z/1893 | 11.1 | +0.000 | +2.000 | 64
GIRT | C350/Double Z type1 | Z/2011 | 4.1 | +1.627 | +1.778 | 151.5
GIRT | C350/Double Z type1 | Z/2009 | 2.4 | +0.252 | +0.352 | 100.5
COLUMN | C300/Double Z type1 | Z/1974 | 19.9 | +0.000 | +2.000 | 96
GIRT | C300/Double Z type1 | Z/1980 | 4.1 | +1.627 | +1.778 | 151.5
GIRT | C300/Double Z type1 | Z/1979 | 3.3 | +0.940 | +1.064 | 124.5
COLUMN | C250/Double Z type1 | Z/1955 | 16 | +0.000 | +2.000 | 76
GIRT | C250/Double Z type1 | Z/1945 | 4.1 | +1.627 | +1.778 | 151.5
GIRT | C250/Double Z type1 | Z/1944 | 3.3 | +0.940 | +1.064 | 124.5
GIRT | C250/Double Z type1 | Z/1943 | 2.4 | +0.252 | +0.352 | 100.5
COLUMN | C200/Double Z type1 | Z/1938 | 14.2 | +0.000 | +2.000 | 76
GIRT | C200/Double Z type1 | Z/1945 | 4.1 | +1.627 | +1.778 | 151.5
GIRT | C200/Double Z type1 | Z/1944 | 3.3 | +0.940 | +1.064 | 124.5
GIRT | C200/Double Z type1 | Z/1943 | 2.4 | +0.252 | +0.352 | 100.5
COLUMN | C150/Double Z type1 | Z/1904 | 11.1 | +0.000 | +2.000 | 64
GIRT | C150/Double Z type1 | Z/1911 | 3.3 | +0.940 | +1.064 | 124.5
GIRT | C150/Double Z type1 | Z/1912 | 4.1 | +1.627 | +1.778 | 151.5
GIRT | C150/Double Z type1 | Z/1910 | 2.4 | +0.252 | +0.352 | 100.5
GIRT/PURLIN BRACKETS | C350/Double Z type1 | PL/800 | 0.6 | +1.634 | +1.699 | 65
GIRT/PURLIN BRACKETS | C350/Double Z type1 | PL/802 | 0.5 | +0.234 | +0.299 | 65
GIRT/PURLIN BRACKETS | C300/Double Z type1 | PL/797 | 0.5 | +1.634 | +1.699 | 65
GIRT/PURLIN BRACKETS | C300/Double Z type1 | PL/798 | 0.5 | +0.934 | +0.999 | 65
GIRT/PURLIN BRACKETS | C300/Double Z type1 | PL/799 | 0.5 | +0.234 | +0.299 | 65
GIRT/PURLIN BRACKETS | C250/Double Z type1 | PL/793 | 0.5 | +1.634 | +1.699 | 65
GIRT/PURLIN BRACKETS | C250/Double Z type1 | PL/794 | 0.5 | +0.934 | +0.999 | 65
GIRT/PURLIN BRACKETS | C250/Double Z type1 | PL/795 | 0.5 | +0.234 | +0.299 | 65
GIRT/PURLIN BRACKETS | C200/Double Z type1 | PL/793 | 0.5 | +1.634 | +1.699 | 65
GIRT/PURLIN BRACKETS | C200/Double Z type1 | PL/794 | 0.5 | +0.934 | +0.999 | 65
GIRT/PURLIN BRACKETS | C200/Double Z type1 | PL/795 | 0.5 | +0.234 | +0.299 | 65
GIRT/PURLIN BRACKETS | C150/Double Z type1 | PL/790 | 0.5 | +1.634 | +1.699 | 65
GIRT/PURLIN BRACKETS | C150/Double Z type1 | PL/791 | 0.5 | +0.934 | +0.999 | 65
GIRT/PURLIN BRACKETS | C150/Double Z type1 | PL/792 | 0.3 | +0.234 | +0.299 | 65
GIRT | C350/Double Z type2 | Z/2012 | 2.4 | +0.252 | +0.352 | 100.5
GIRT | C350/Double Z type2 | Z/2013 | 3.3 | +0.940 | +1.064 | 124.5
GIRT | C350/Double Z type2 | Z/2014 | 4.1 | +1.627 | +1.778 | 151.5
COLUMN | C350/Double Z type2 | Z/1991 | 29.9 | +0.000 | +2.000 | 125
GIRT | C300/Double Z type2 | Z/1981 | 2.4 | +0.252 | +0.352 | 100.5
GIRT | C300/Double Z type2 | Z/1982 | 3.3 | +0.940 | +1.064 | 124.5
GIRT | C300/Double Z type2 | Z/1983 | 4.1 | +1.627 | +1.778 | 151.5
COLUMN | C300/Double Z type2 | Z/1962 | 19.9 | +0.000 | +2.000 | 96
GIRT | C250/Double Z type2 | Z/1946 | 2.4 | +0.252 | +0.352 | 100.5
GIRT | C250/Double Z type2 | Z/1947 | 3.3 | +0.940 | +1.064 | 124.5
GIRT | C250/Double Z type2 | Z/1948 | 4.1 | +1.627 | +1.778 | 151.5
COLUMN | C250/Double Z type2 | Z/1953 | 16 | +0.000 | +2.000 | 76
GIRT | C200/Double Z type2 | Z/1946 | 2.4 | +0.252 | +0.352 | 100.5
GIRT | C200/Double Z type2 | Z/1947 | 3.3 | +0.940 | +1.064 | 124.5
GIRT | C200/Double Z type2 | Z/1948 | 4.1 | +1.627 | +1.778 | 151.5
GIRT | C150/Double Z type2 | Z/1913 | 2.4 | +0.252 | +0.352 | 100.5
GIRT | C150/Double Z type2 | Z/1902 | 3.3 | +0.936 | +1.060 | 124.5
GIRT | C150/Double Z type2 | Z/1915 | 4.1 | +1.627 | +1.778 | 151.5
COLUMN | C150/Double Z type2 | Z/1893 | 11.1 | +0.000 | +2.000 | 64
GIRT | C350/Double Z type2 | Z/2000 | 2.4 | +0.248 | +0.348 | 100.5
GIRT | C350/Double Z type2 | Z/2001 | 3.3 | +0.936 | +1.060 | 124.5
GIRT | C350/Double Z type2 | Z/2002 | 4.1 | +1.622 | +1.773 | 151.5
COLUMN | C350/Double Z type2 | Z/2006 | 29.9 | +0.000 | +2.000 | 125
GIRT/PURLIN BRACKETS | C350/Double Z type2 | PL/800 | 0.6 | +1.634 | +1.699 | 65
GIRT/PURLIN BRACKETS | C350/Double Z type2 | PL/803 | 0.5 | +0.934 | +0.999 | 65
GIRT/PURLIN BRACKETS | C350/Double Z type2 | PL/802 | 0.3 | +0.234 | +0.299 | 65
GIRT | C300/Double Z type2 | Z/1970 | 2.4 | +0.248 | +0.348 | 100.5
GIRT | C300/Double Z type2 | Z/1971 | 3.3 | +0.936 | +1.060 | 124.5
GIRT | C300/Double Z type2 | Z/1972 | 4.1 | +1.622 | +1.773 | 151.5
COLUMN | C300/Double Z type2 | Z/1974 | 19.9 | +0.000 | +2.000 | 96
GIRT/PURLIN BRACKETS | C300/Double Z type2 | PL/797 | 0.5 | +1.634 | +1.699 | 65
GIRT/PURLIN BRACKETS | C300/Double Z type2 | PL/798 | 0.5 | +0.934 | +0.999 | 65
GIRT/PURLIN BRACKETS | C300/Double Z type2 | PL/799 | 0.3 | +0.234 | +0.299 | 65
GIRT | C250/Double Z type2 | Z/1935 | 2.4 | +0.248 | +0.348 | 100.5
GIRT | C250/Double Z type2 | Z/1936 | 3.3 | +0.936 | +1.060 | 124.5
GIRT | C250/Double Z type2 | Z/1937 | 4.1 | +1.622 | +1.773 | 151.5
COLUMN | C250/Double Z type2 | Z/1955 | 16 | +0.000 | +2.000 | 76
GIRT/PURLIN BRACKETS | C250/Double Z type2 | PL/793 | 0.5 | +1.634 | +1.699 | 65
GIRT/PURLIN BRACKETS | C250/Double Z type2 | PL/794 | 0.3 | +0.934 | +0.999 | 65
GIRT/PURLIN BRACKETS | C250/Double Z type2 | PL/795 | 0.3 | +0.234 | +0.299 | 65
GIRT | C200/Double Z type2 | Z/1936 | 3.3 | +0.936 | +1.060 | 124.5
GIRT | C200/Double Z type2 | Z/1937 | 4.1 | +1.622 | +1.773 | 151.5
GIRT/PURLIN BRACKETS | C200/Double Z type2 | PL/793 | 0.5 | +1.634 | +1.699 | 65
GIRT/PURLIN BRACKETS | C200/Double Z type2 | PL/794 | 0.3 | +0.934 | +0.999 | 65
GIRT | C350/Double C type1 | Z/1999 | 1.9 | +1.624 | +1.700 | 76
GIRT | C350/Double C type1 | Z/1998 | 1.5 | +0.936 | +1.000 | 64
GIRT | C350/Double C type1 | Z/1997 | 1.1 | +0.249 | +0.300 | 51
GIRT | C300/Double C type1 | Z/1969 | 1.9 | +1.624 | +1.700 | 76
GIRT | C300/Double C type1 | Z/1968 | 1.5 | +0.936 | +1.000 | 64
GIRT | C300/Double C type1 | Z/1967 | 1.1 | +0.249 | +0.300 | 51
GIRT | C250/Double C type1 | Z/1934 | 1.9 | +1.624 | +1.700 | 76
GIRT | C250/Double C type1 | Z/1933 | 1.5 | +0.936 | +1.000 | 64
GIRT | C250/Double C type1 | Z/1932 | 1.1 | +0.249 | +0.300 | 51
GIRT | C200/Double C type1 | Z/1934 | 1.9 | +1.624 | +1.700 | 76
GIRT | C200/Double C type1 | Z/1933 | 1.5 | +0.936 | +1.000 | 64
GIRT | C200/Double C type1 | Z/1932 | 1.1 | +0.249 | +0.300 | 51
GIRT | C150/Double C type1 | Z/1900 | 1.9 | +1.624 | +1.700 | 76
GIRT | C150/Double C type1 | Z/1899 | 1.5 | +0.936 | +1.000 | 64
GIRT | C150/Double C type1 | Z/1898 | 1.1 | +0.249 | +0.300 | 51
GIRT/PURLIN BRACKETS | C350/Double C type1 | PL/800 | 0.6 | +1.700 | +1.765 | 65
GIRT/PURLIN BRACKETS | C350/Double C type1 | PL/803 | 0.5 | +1.000 | +1.065 | 65
GIRT/PURLIN BRACKETS | C350/Double C type1 | PL/802 | 0.3 | +0.300 | +0.365 | 65
GIRT/PURLIN BRACKETS | C300/Double C type1 | PL/797 | 0.5 | +1.700 | +1.765 | 65
GIRT/PURLIN BRACKETS | C300/Double C type1 | PL/798 | 0.5 | +1.000 | +1.065 | 65
GIRT/PURLIN BRACKETS | C300/Double C type1 | PL/799 | 0.3 | +0.300 | +0.365 | 65
GIRT/PURLIN BRACKETS | C250/Double C type1 | PL/793 | 0.5 | +1.700 | +1.765 | 65
GIRT/PURLIN BRACKETS | C250/Double C type1 | PL/794 | 0.3 | +1.000 | +1.065 | 65
GIRT/PURLIN BRACKETS | C250/Double C type1 | PL/795 | 0.3 | +0.300 | +0.365 | 65
GIRT/PURLIN BRACKETS | C200/Double C type1 | PL/793 | 0.5 | +1.700 | +1.765 | 65
GIRT/PURLIN BRACKETS | C200/Double C type1 | PL/794 | 0.3 | +1.000 | +1.065 | 65
GIRT/PURLIN BRACKETS | C200/Double C type1 | PL/795 | 0.3 | +0.300 | +0.365 | 65
GIRT/PURLIN BRACKETS | C150/Double C type1 | PL/790 | 0.5 | +1.700 | +1.765 | 65
GIRT/PURLIN BRACKETS | C150/Double C type1 | PL/791 | 0.3 | +1.000 | +1.065 | 65
GIRT/PURLIN BRACKETS | C150/Double C type1 | PL/792 | 0.3 | +0.300 | +0.365 | 65
GIRT | C350/Double C type2 | Z/2017 | 0.9 | +1.624 | +1.700 | 76
GIRT | C350/Double C type2 | Z/2016 | 0.6 | +0.936 | +1.000 | 64
GIRT | C350/Double C type2 | Z/2015 | 0.5 | +0.249 | +0.300 | 51
GIRT | C350/Double C type2 | Z/1989 | 0.9 | +1.624 | +1.700 | 76
GIRT | C350/Double C type2 | Z/1988 | 0.6 | +0.936 | +1.000 | 64
GIRT | C350/Double C type2 | Z/1987 | 0.5 | +0.249 | +0.300 | 51
GIRT/PURLIN BRACKETS | C350/Double C type2 | PL/787 | 1.2 | +1.700 | +1.765 | 65
GIRT/PURLIN BRACKETS | C350/Double C type2 | PL/788 | 0.9 | +1.000 | +1.065 | 65
GIRT/PURLIN BRACKETS | C350/Double C type2 | PL/789 | 0.6 | +0.300 | +0.365 | 65
GIRT | C300/Double C type2 | Z/1986 | 0.9 | +1.624 | +1.700 | 76
GIRT | C300/Double C type2 | Z/1985 | 0.6 | +0.936 | +1.000 | 64
GIRT | C300/Double C type2 | Z/1984 | 0.5 | +0.249 | +0.300 | 51
GIRT | C300/Double C type2 | Z/1959 | 0.9 | +1.624 | +1.700 | 76
GIRT | C300/Double C type2 | Z/1958 | 0.6 | +0.936 | +1.000 | 64
GIRT | C300/Double C type2 | Z/1957 | 0.5 | +0.249 | +0.300 | 51
GIRT/PURLIN BRACKETS | C300/Double C type2 | PL/784 | 0.9 | +1.700 | +1.765 | 65
GIRT/PURLIN BRACKETS | C300/Double C type2 | PL/785 | 0.9 | +1.000 | +1.065 | 65
GIRT/PURLIN BRACKETS | C300/Double C type2 | PL/786 | 0.6 | +0.300 | +0.365 | 65
GIRT | C250/Double C type2 | Z/1951 | 0.9 | +1.624 | +1.700 | 76
GIRT | C250/Double C type2 | Z/1950 | 0.6 | +0.936 | +1.000 | 64
GIRT | C250/Double C type2 | Z/1949 | 0.5 | +0.249 | +0.300 | 51
GIRT | C250/Double C type2 | Z/1924 | 0.9 | +1.624 | +1.700 | 76
GIRT | C250/Double C type2 | Z/1923 | 0.6 | +0.936 | +1.000 | 64
GIRT | C250/Double C type2 | Z/1922 | 0.5 | +0.249 | +0.300 | 51
GIRT/PURLIN BRACKETS | C250/Double C type2 | PL/781 | 0.9 | +1.700 | +1.765 | 65
GIRT/PURLIN BRACKETS | C250/Double C type2 | PL/782 | 0.6 | +1.000 | +1.065 | 65
GIRT/PURLIN BRACKETS | C250/Double C type2 | PL/783 | 0.5 | +0.300 | +0.365 | 65
GIRT | C200/Double C type2 | Z/1951 | 0.9 | +1.624 | +1.700 | 76
GIRT | C200/Double C type2 | Z/1950 | 0.6 | +0.936 | +1.000 | 64
GIRT | C200/Double C type2 | Z/1949 | 0.5 | +0.249 | +0.300 | 51
GIRT | C200/Double C type2 | Z/1924 | 0.9 | +1.624 | +1.700 | 76
GIRT | C200/Double C type2 | Z/1923 | 0.6 | +0.936 | +1.000 | 64
GIRT | C200/Double C type2 | Z/1922 | 0.5 | +0.249 | +0.300 | 51
GIRT/PURLIN BRACKETS | C200/Double C type2 | PL/781 | 0.9 | +1.700 | +1.765 | 65
GIRT/PURLIN BRACKETS | C200/Double C type2 | PL/782 | 0.6 | +1.000 | +1.065 | 65
GIRT/PURLIN BRACKETS | C200/Double C type2 | PL/783 | 0.5 | +0.300 | +0.365 | 65
GIRT | C150/Double Z type2 | Z/1901 | 2.4 | +0.248 | +0.348 | 100.5
GIRT | C150/Double Z type2 | Z/1914 | 3.3 | +0.940 | +1.064 | 124.5
GIRT | C150/Double Z type2 | Z/1903 | 4.1 | +1.622 | +1.773 | 151.5
COLUMN | C150/Double Z type2 | Z/1683 | 11.1 | +0.000 | +2.000 | 64
GIRT/PURLIN BRACKETS | C150/Double Z type2 | PL/790 | 0.5 | +1.634 | +1.699 | 65
GIRT/PURLIN BRACKETS | C150/Double Z type2 | PL/791 | 0.3 | +0.934 | +0.999 | 65
GIRT/PURLIN BRACKETS | C150/Double Z type2 | PL/792 | 0.3 | +0.234 | +0.299 | 65
GIRT | C150/Double C type2 | Z/1921 | 0.9 | +1.624 | +1.700 | 76
GIRT | C150/Double C type2 | Z/1920 | 0.6 | +0.936 | +1.000 | 64
GIRT | C150/Double C type2 | Z/1919 | 0.5 | +0.249 | +0.300 | 51
GIRT | C150/Double C type2 | Z/1891 | 0.9 | +1.624 | +1.700 | 76
GIRT | C150/Double C type2 | Z/1890 | 0.6 | +0.936 | +1.000 | 64
GIRT | C150/Double C type2 | Z/1889 | 0.5 | +0.249 | +0.300 | 51
GIRT/PURLIN BRACKETS | C150/Double C type2 | PL/778 | 0.9 | +1.700 | +1.765 | 65
GIRT/PURLIN BRACKETS | C150/Double C type2 | PL/779 | 0.6 | +1.000 | +1.065 | 65
GIRT/PURLIN BRACKETS | C150/Double C type2 | PL/780 | 0.5 | +0.300 | +0.365 | 65

# IfcMechanicalFastener: Bolt assembly (435)
In: Undefined
NominalDiameter: 12 mm
Tekla Bolt - Washer diameter: 12 mm; Slotted hole y: 0 mm; Slotted hole x: 0 mm; Bolt hole diameter: 18 mm; Location: Site; Bolt size: 12 mm
Name | NominalLength (mm) = Bolt length (mm) | Material = Bolt standard | Washer count = Nut count = Bolt count | Washer type | Washer name | Nut type | Nut name | Bolt Name
6 x Bolt assembly | 35 | 8.8S | 1 | HARD | WASHERM12-HARD | 8.8-HEX | NUTM12-8.8-HEX | BOLTM12*35
293 x Bolt assembly | 30 | PB1230 | 1 | FLAT | WASHERM12-FLAT | 4.6-HEX | NUTM12-4.6-HEX | BOLTPB1230
135 x Bolt assembly | 30 | PB1230 | 2 | FLAT | WASHERM12-FLAT | 4.6-HEX | NUTM12-4.6-HEX | BOLTPB1230
Bolt assembly | 100 | PB1230 | 1 | FLAT | WASHERM12-FLAT | 4.6-HEX | NUTM12-4.6-HEX

# IfcPlate: PLT3*130 (12)
In: Undefined
Description: PLT3*130; Material: STEEL/250
Tekla Common - Phase: 1; Class: 10
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 130 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 130 mm; CrossSectionArea: 0.000009 m2
Name | Bottom elevation | Top elevation | ASSEMBLY_POS = Reference | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) | GrossVolume (m3)
2 x GIRT/PURLIN BRACKETS | +1.634 | +1.699 | PL/790 | 0.5 | 89.8 | 0 | 243.6 | 0.0435457 | 0.0316639 | 0.0000617969 | 0.0000955443
GIRT/PURLIN BRACKETS | +0.934 | +0.999 | PL/791 | 0.5 | 90 | 0 | 193.1 | 0.0361727 | 0.0250989 | 0.0000511919 | 0.0000758493
2 x GIRT/PURLIN BRACKETS | +0.234 | +0.299 | PL/792 | 0.3 | 90.3 | 0 | 153.1 | 0.0303327 | 0.0198989 | 0.0000427919 | 0.0000602493
GIRT/PURLIN BRACKETS | +1.700 | +1.765 | PL/790 | 0.5 | 89.8 | 0 | 243.6 | 0.0435457 | 0.0316639 | 0.0000617969 | 0.0000955443
GIRT/PURLIN BRACKETS | +1.000 | +1.065 | PL/791 | 0.3 | 90 | 0 | 193.1 | 0.0361727 | 0.0250989 | 0.0000511919 | 0.0000758493
GIRT/PURLIN BRACKETS | +0.300 | +0.365 | PL/792 | 0.3 | 90.3 | 0 | 153.1 | 0.0303327 | 0.0198989 | 0.0000427919 | 0.0000602493
GIRT/PURLIN BRACKETS | +0.934 | +0.999 | PL/791 | 0.3 | 90 | 0 | 193.1 | 0.0361727 | 0.0250989 | 0.0000511919 | 0.0000758493
GIRT/PURLIN BRACKETS | +1.700 | +1.765 | PL/778 | 0.9 | 88.2 | 0.1 | 243.6 | 0.0661279 | 0.0316639 | 0.0000955443 | 0.0000955443
GIRT/PURLIN BRACKETS | +1.000 | +1.065 | PL/779 | 0.6 | 88.5 | 0.1 | 193.1 | 0.0526949 | 0.0250989 | 0.0000758493 | 0.0000758493
GIRT/PURLIN BRACKETS | +0.300 | +0.365 | PL/780 | 0.5 | 88.9 | 0 | 153.1 | 0.0420549 | 0.0198989 | 0.0000602493 | 0.0000602493

# IfcPlate: PLT3*150 (24)
In: Undefined
Description: PLT3*150; Material: STEEL/250
Tekla Common - Phase: 1; Class: 10
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 150 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 150 mm; CrossSectionArea: 0.000009 m2
Name | Bottom elevation | Top elevation | ASSEMBLY_POS = Reference | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) | GrossVolume (m3)
3 x GIRT/PURLIN BRACKETS | +0.234 | +0.299 | PL/795 | 0.5 | 90.2 | 0 | 153.1 | 0.0327527 | 0.0229603 | 0.0000462419 | 0.0000695184
4 x GIRT/PURLIN BRACKETS | +1.634 | +1.699 | PL/793 | 0.5 | 89.6 | 0 | 243.6 | 0.0459657 | 0.0365353 | 0.0000652469 | 0.000110243
2 x GIRT/PURLIN BRACKETS | +0.934 | +0.999 | PL/794 | 0.5 | 90 | 0 | 193.1 | 0.0385927 | 0.0289603 | 0.0000546419 | 0.0000875184
2 x GIRT/PURLIN BRACKETS | +0.934 | +0.999 | PL/794 | 0.3 | 90 | 0 | 193.1 | 0.0385927 | 0.0289603 | 0.0000546419 | 0.0000875184
GIRT/PURLIN BRACKETS | +0.234 | +0.299 | PL/795 | 0.3 | 90.2 | 0 | 153.1 | 0.0327527 | 0.0229603 | 0.0000462419 | 0.0000695184
2 x GIRT/PURLIN BRACKETS | +1.700 | +1.765 | PL/793 | 0.5 | 89.6 | 0 | 243.6 | 0.0459657 | 0.0365353 | 0.0000652469 | 0.000110243
2 x GIRT/PURLIN BRACKETS | +1.000 | +1.065 | PL/794 | 0.3 | 90 | 0 | 193.1 | 0.0385927 | 0.0289603 | 0.0000546419 | 0.0000875184
2 x GIRT/PURLIN BRACKETS | +0.300 | +0.365 | PL/795 | 0.3 | 90.2 | 0 | 153.1 | 0.0327527 | 0.0229603 | 0.0000462419 | 0.0000695184
2 x GIRT/PURLIN BRACKETS | +1.700 | +1.765 | PL/781 | 0.9 | 87.8 | 0.1 | 243.6 | 0.0760752 | 0.0365353 | 0.000110243 | 0.000110243
2 x GIRT/PURLIN BRACKETS | +1.000 | +1.065 | PL/782 | 0.6 | 88.2 | 0.1 | 193.1 | 0.0606222 | 0.0289603 | 0.0000875184 | 0.0000875184
2 x GIRT/PURLIN BRACKETS | +0.300 | +0.365 | PL/783 | 0.5 | 88.7 | 0 | 153.1 | 0.0483822 | 0.0229603 | 0.0000695184 | 0.0000695184

# IfcPlate: PLT3*153.1 (8)
In: Undefined
Description: PLT3*153.1; Material: STEEL/250
Tekla Common - Phase: 1; Class: 10
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 153.1 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 153.069 mm; CrossSectionArea: 0.000009 m2
Name | Bottom elevation | Top elevation | ASSEMBLY_POS = Reference | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) | GrossVolume (m3)
GIRT/PURLIN BRACKETS | +0.234 | +0.299 | PL/802 | 0.5 | 90.2 | 0 | 200 | 0.0388027 | 0.0306137 | 0.0000548669 | 0.0000926912
GIRT/PURLIN BRACKETS | +0.234 | +0.299 | PL/799 | 0.5 | 90.2 | 0 | 170 | 0.0351727 | 0.0260217 | 0.0000496919 | 0.0000787875
GIRT/PURLIN BRACKETS | +0.234 | +0.299 | PL/802 | 0.3 | 90.2 | 0 | 200 | 0.0388027 | 0.0306137 | 0.0000548669 | 0.0000926912
GIRT/PURLIN BRACKETS | +0.234 | +0.299 | PL/799 | 0.3 | 90.2 | 0 | 170 | 0.0351727 | 0.0260217 | 0.0000496919 | 0.0000787875
GIRT/PURLIN BRACKETS | +0.300 | +0.365 | PL/802 | 0.3 | 90.2 | 0 | 200 | 0.0388027 | 0.0306137 | 0.0000548669 | 0.0000926912
GIRT/PURLIN BRACKETS | +0.300 | +0.365 | PL/799 | 0.3 | 90.2 | 0 | 170 | 0.0351727 | 0.0260217 | 0.0000496919 | 0.0000787875
GIRT/PURLIN BRACKETS | +0.300 | +0.365 | PL/789 | 0.6 | 88.2 | 0.1 | 200 | 0.0642007 | 0.0306137 | 0.0000926912 | 0.0000926912
GIRT/PURLIN BRACKETS | +0.300 | +0.365 | PL/786 | 0.6 | 88.5 | 0.1 | 170 | 0.0547096 | 0.0260217 | 0.0000787875 | 0.0000787875

# IfcPlate: PLT3*170 (8)
In: Undefined
Description: PLT3*170; Material: STEEL/250
Tekla Common - Phase: 1; Class: 10
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 170 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 170 mm; CrossSectionArea: 0.000009 m2
Name | Bottom elevation | Top elevation | ASSEMBLY_POS = Reference | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) | GrossVolume (m3)
2 x GIRT/PURLIN BRACKETS | +1.634 | +1.699 | PL/797 | 0.5 | 89.6 | 0 | 243.6 | 0.0483857 | 0.0414067 | 0.0000686969 | 0.000124942
2 x GIRT/PURLIN BRACKETS | +0.934 | +0.999 | PL/798 | 0.5 | 89.8 | 0 | 193.1 | 0.0410127 | 0.0328217 | 0.0000580919 | 0.0000991875
GIRT/PURLIN BRACKETS | +1.700 | +1.765 | PL/797 | 0.5 | 89.6 | 0 | 243.6 | 0.0483857 | 0.0414067 | 0.0000686969 | 0.000124942
GIRT/PURLIN BRACKETS | +1.000 | +1.065 | PL/798 | 0.5 | 89.8 | 0 | 193.1 | 0.0410127 | 0.0328217 | 0.0000580919 | 0.0000991875
GIRT/PURLIN BRACKETS | +1.700 | +1.765 | PL/784 | 0.9 | 87.7 | 0.1 | 243.6 | 0.0860226 | 0.0414067 | 0.000124942 | 0.000124942
GIRT/PURLIN BRACKETS | +1.000 | +1.065 | PL/785 | 0.9 | 88 | 0.1 | 193.1 | 0.0685496 | 0.0328217 | 0.0000991875 | 0.0000991875

# IfcPlate: PLT3*193.1 (4)
In: Undefined
Description: PLT3*193.1; Material: STEEL/250
Tekla Common - Phase: 1; Class: 10
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 193.1 mm; Width: 3 mm; Length: 200 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 193.069 mm; GrossArea: 0.0386137 m2; CrossSectionArea: 0.000009 m2; GrossVolume: 0.000116691 m3
Name | Bottom elevation | Top elevation | ASSEMBLY_POS = Reference | Weight (kg) | Area per tons (m2) | Net surface area (m2) | NetArea (m2) | NetVolume (m3)
2 x GIRT/PURLIN BRACKETS | +0.934 | +0.999 | PL/803 | 0.5 | 89.8 | 0 | 0.0446427 | 0.0000632669
GIRT/PURLIN BRACKETS | +1.000 | +1.065 | PL/803 | 0.5 | 89.8 | 0 | 0.0446427 | 0.0000632669
GIRT/PURLIN BRACKETS | +1.000 | +1.065 | PL/788 | 0.9 | 87.8 | 0.1 | 0.0804407 | 0.000116691

# IfcPlate: PLT3*200 (4)
In: Undefined
Description: PLT3*200; Material: STEEL/250
Tekla Common - Phase: 1; Class: 10
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.1 m2; Height: 200 mm; Width: 3 mm; Length: 243.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 200 mm; GrossArea: 0.0487137 m2; CrossSectionArea: 0.000009 m2; GrossVolume: 0.000146991 m3
Name | Bottom elevation | Top elevation | ASSEMBLY_POS = Reference | Weight (kg) | Area per tons (m2) | NetArea (m2) | NetVolume (m3)
2 x GIRT/PURLIN BRACKETS | +1.634 | +1.699 | PL/800 | 0.6 | 89.6 | 0.0520157 | 0.0000738719
GIRT/PURLIN BRACKETS | +1.700 | +1.765 | PL/800 | 0.6 | 89.6 | 0.0520157 | 0.0000738719
GIRT/PURLIN BRACKETS | +1.700 | +1.765 | PL/787 | 1.2 | 87.5 | 0.100944 | 0.000146991

# IfcPlate: PLT3*70 (30)
In: Undefined
Description: PLT3*70; Material: STEEL/250
Tekla Common - Phase: 1; Class: 10
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 70 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 70 mm; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
GIRT/PURLIN BRACKETS | PL/813 | +1.634 | +1.699 | 0.6 | 89.4 | 0.1 | 365.6 | 0.0540977 | 0.0255898 | 0.0000770669
GIRT/PURLIN BRACKETS | PL/812 | +0.934 | +0.999 | 0.5 | 89.6 | 0 | 315.1 | 0.0467247 | 0.0220548 | 0.0000664619
GIRT/PURLIN BRACKETS | PL/811 | +0.234 | +0.299 | 0.5 | 89.6 | 0 | 275.1 | 0.0408847 | 0.0192548 | 0.0000580619
GIRT/PURLIN BRACKETS | PL/810 | +1.634 | +1.699 | 0.6 | 89.4 | 0 | 337.2 | 0.0499513 | 0.0236018 | 0.0000711029
GIRT/PURLIN BRACKETS | PL/809 | +0.934 | +0.999 | 0.5 | 89.6 | 0 | 286.7 | 0.0425783 | 0.0200668 | 0.0000604979
GIRT/PURLIN BRACKETS | PL/808 | +0.234 | +0.299 | 0.5 | 89.8 | 0 | 246.7 | 0.0367383 | 0.0172668 | 0.0000520979
2 x GIRT/PURLIN BRACKETS | PL/807 | +1.634 | +1.699 | 0.5 | 89.6 | 0 | 317.2 | 0.0470313 | 0.0222018 | 0.0000669029
2 x GIRT/PURLIN BRACKETS | PL/806 | +0.934 | +0.999 | 0.5 | 89.6 | 0 | 266.7 | 0.0396583 | 0.0186668 | 0.0000562979
GIRT/PURLIN BRACKETS | PL/805 | +0.234 | +0.299 | 0.5 | 89.8 | 0 | 226.7 | 0.0338183 | 0.0158668 | 0.0000478979
3 x GIRT/PURLIN BRACKETS | PL/805 | +0.300 | +0.365 | 0.5 | 89.8 | 0 | 226.7 | 0.0338183 | 0.0158668 | 0.0000478979
GIRT/PURLIN BRACKETS | PL/804 | +1.634 | +1.699 | 0.5 | 89.6 | 0 | 305.2 | 0.0452793 | 0.0213618 | 0.0000643829
GIRT/PURLIN BRACKETS | PL/801 | +0.934 | +0.999 | 0.5 | 89.8 | 0 | 254.7 | 0.0379063 | 0.0178268 | 0.0000537779
2 x GIRT/PURLIN BRACKETS | PL/796 | +0.300 | +0.365 | 0.5 | 90 | 0 | 214.7 | 0.0320663 | 0.0150268 | 0.0000453779
GIRT/PURLIN BRACKETS | PL/813 | +1.700 | +1.765 | 0.6 | 89.4 | 0.1 | 365.6 | 0.0540977 | 0.0255898 | 0.0000770669
GIRT/PURLIN BRACKETS | PL/812 | +1.000 | +1.065 | 0.5 | 89.6 | 0 | 315.1 | 0.0467247 | 0.0220548 | 0.0000664619
GIRT/PURLIN BRACKETS | PL/811 | +0.300 | +0.365 | 0.5 | 89.6 | 0 | 275.1 | 0.0408847 | 0.0192548 | 0.0000580619
GIRT/PURLIN BRACKETS | PL/810 | +1.700 | +1.765 | 0.6 | 89.4 | 0 | 337.2 | 0.0499513 | 0.0236018 | 0.0000711029
GIRT/PURLIN BRACKETS | PL/809 | +1.000 | +1.065 | 0.5 | 89.6 | 0 | 286.7 | 0.0425783 | 0.0200668 | 0.0000604979
GIRT/PURLIN BRACKETS | PL/808 | +0.300 | +0.365 | 0.5 | 89.8 | 0 | 246.7 | 0.0367383 | 0.0172668 | 0.0000520979
2 x GIRT/PURLIN BRACKETS | PL/807 | +1.700 | +1.765 | 0.5 | 89.6 | 0 | 317.2 | 0.0470313 | 0.0222018 | 0.0000669029
2 x GIRT/PURLIN BRACKETS | PL/806 | +1.000 | +1.065 | 0.5 | 89.6 | 0 | 266.7 | 0.0396583 | 0.0186668 | 0.0000562979
GIRT/PURLIN BRACKETS | PL/804 | +1.700 | +1.765 | 0.5 | 89.6 | 0 | 305.2 | 0.0452793 | 0.0213618 | 0.0000643829
GIRT/PURLIN BRACKETS | PL/801 | +1.000 | +1.065 | 0.5 | 89.8 | 0 | 254.7 | 0.0379063 | 0.0178268 | 0.0000537779
