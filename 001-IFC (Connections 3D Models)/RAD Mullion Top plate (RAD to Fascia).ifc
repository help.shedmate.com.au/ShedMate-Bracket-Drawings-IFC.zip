Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView_V2.0, QuantityTakeOffAddOnView], Option [BaseQuantities:On], Option [GridExport:On], Option [Assemblies:On], Option [Bolts:On], Option [Rebars:On], Option [PourObjects:Off], Option [Welds:Off], Option [SurfaceTreatments:Off], Option [LocationBy:0], Option [ViewColors:Off], Option [SectionedSpine:Off], Option [PropertySets:On], Option [Export all:Off]
File name: RAD Mullion Top plate (RAD to Fascia).ifc
Time: 2026-06-11T12:52:40
Author: MSI\User
Organization: Structural Designer
Written by: IFC Database Version: Work
Made in: Tekla Structures 2019 Service Pack 13, IFC Export Version: 4.0.0.0 Oct 18 2021

# IfcBuildingStorey, Undefined
In: Undefined
Elevation: 0 mm

# IfcBeam: C:100-15, FASCIA
In: Undefined
Description: C:100-15; Material: STEEL/300PLUS
Default - ASSEMBLY_POS: F/37
Tekla Common - Bottom elevation: +4.000; Top elevation: +4.102; Phase: 1; Class: 13
Tekla Quantity - Weight: 5.1 kg; Volume: 0 m3; Gross footprint area: 0.1 m2; Area per tons: 178.8 m2; Net surface area: 0.9 m2; Height: 102 mm; Width: 51 mm; Length: 2002 mm
Pset_BeamCommon - LoadBearing: no; Reference: F/37
BaseQuantities - Length: 2002 mm; OuterSurfaceArea: 0.907581 m2; NetVolume: 0.000675675 m3; NetWeight: 5.30405 kg

# IfcBeam: C:150-24, FASCIA
In: Undefined
Description: C:150-24; Material: STEEL/300PLUS
Default - ASSEMBLY_POS: F/38
Tekla Common - Bottom elevation: +4.000; Top elevation: +4.152; Phase: 1; Class: 13
Tekla Quantity - Weight: 11.2 kg; Volume: 0 m3; Gross footprint area: 0.1 m2; Area per tons: 111.3 m2; Net surface area: 1.2 m2; Height: 152 mm; Width: 64 mm; Length: 2002 mm
Pset_BeamCommon - LoadBearing: no; Reference: F/38
BaseQuantities - Length: 2002 mm; OuterSurfaceArea: 1.24191 m2; NetVolume: 0.001477 m3; NetWeight: 11.5944 kg

# IfcBeam: C:200-15, FASCIA
In: Undefined
Description: C:200-15; Material: STEEL/300PLUS
Default - ASSEMBLY_POS: F/39
Tekla Common - Bottom elevation: +4.000; Top elevation: +4.203; Phase: 1; Class: 13
Tekla Quantity - Weight: 8.7 kg; Volume: 0 m3; Gross footprint area: 0.2 m2; Area per tons: 175.3 m2; Net surface area: 1.5 m2; Height: 203 mm; Width: 76 mm; Length: 2002 mm
Pset_BeamCommon - LoadBearing: no; Reference: F/39
BaseQuantities - Length: 2002 mm; OuterSurfaceArea: 1.52867 m2; NetVolume: 0.00114114 m3; NetWeight: 8.95795 kg

# IfcColumn: C:100-19 (3)
In: Undefined
Description: C:100-19; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Top elevation: +3.995; Phase: 1; Class: 2
Tekla Quantity - Weight: 12.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 141.7 m2; Net surface area: 1.8 m2; Height: 102 mm; Width: 51 mm; Length: 3994.7 mm
Pset_ColumnCommon - LoadBearing: no
BaseQuantities - Length: 3994.71 mm; OuterSurfaceArea: 1.81685 m2; NetVolume: 0.00171077 m3; NetWeight: 13.4296 kg
Name | ASSEMBLY_POS = Reference
2 x MULLION | Z/2281
MULLION | Z/2279

# IfcColumn: C:150-24 (3)
In: Undefined
Description: C:150-24; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Top elevation: +3.995; Phase: 1; Class: 2
Tekla Quantity - Weight: 22.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 111.2 m2; Net surface area: 2.5 m2; Height: 152 mm; Width: 64 mm; Length: 3994.7 mm
Pset_ColumnCommon - LoadBearing: no
BaseQuantities - Length: 3994.71 mm; OuterSurfaceArea: 2.4766 m2; NetVolume: 0.00294714 m3; NetWeight: 23.135 kg
Name | ASSEMBLY_POS = Reference
2 x MULLION | Z/2278
MULLION | Z/2280

# IfcColumn: C:200-24 (3)
In: Undefined
Description: C:200-24; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Top elevation: +3.995; Phase: 1; Class: 2
Tekla Quantity - Weight: 28.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 110 m2; Net surface area: 3.1 m2; Height: 203 mm; Width: 76 mm; Length: 3994.7 mm
Pset_ColumnCommon - LoadBearing: no
BaseQuantities - Length: 3994.71 mm; OuterSurfaceArea: 3.11614 m2; NetVolume: 0.00371412 m3; NetWeight: 29.1559 kg
Name | ASSEMBLY_POS = Reference
2 x MULLION | Z/2277
MULLION | Z/2282

# IfcElementAssembly (24)
In: Undefined
PredefinedType: RIGID_FRAME
Name | ASSEMBLY_POSITION_CODE = Assembly/Cast unit position code | ASSEMBLY_POS = Assembly/Cast unit Mark | Assembly/Cast unit weight (kg) | Assembly/Cast unit bottom elevation | Assembly/Cast unit top elevation | Width (mm)
RAD TOP PLATE | C100/RAD HEADER | PL/1566 | 0.1 | +3.905 | +4.000 | 47.6
RAD TOP PLATE |  | PL/1573 | 0.2 | +3.905 | +4.000 | 58.6
RAD TOP PLATE | C200/RAD HEADER> | PL/1574 | 0.1 | +3.905 | +4.000 | 46.1
RAD TOP PLATE |  | PL/1568 | 0.3 | +3.905 | +4.000 | 70.6
RAD TOP PLATE | C150/RAD HEADER> | PL/1570 | 0.1 | +3.905 | +4.000 | 46.1
RAD TOP PLATE |  | PL/1564 | 0.3 | +3.905 | +4.000 | 72.1
RAD TOP PLATE | C100/RAD HEADER> | PL/1565 | 0.2 | +3.905 | +4.000 | 60.1
RAD TOP PLATE | C200/RAD HEADER | PL/1572 | 0.3 | +3.905 | +4.000 | 70.6
RAD TOP PLATE | C150/RAD HEADER | PL/1569 | 0.2 | +3.905 | +4.000 | 58.6
MULLION |  | Z/2278 | 22.3 | +0.000 | +3.995 | 64
MULLION | C200/RAD HEADER> | Z/2281 | 12.8 | +0.000 | +3.995 | 51
MULLION | C150/RAD HEADER> | Z/2277 | 28.3 | +0.000 | +3.995 | 76
MULLION | C150/RAD HEADER> | Z/2281 | 12.8 | +0.000 | +3.995 | 51
MULLION | C100/RAD HEADER> | Z/2277 | 28.3 | +0.000 | +3.995 | 76
MULLION | C100/RAD HEADER> | Z/2278 | 22.3 | +0.000 | +3.995 | 64
FASCIA | C200/<RAD HEADER-RAD HEADER> | F/39 | 8.7 | +4.000 | +4.203 | 76
FASCIA | C150/<RAD HEADER-RAD HEADER> | F/38 | 11.2 | +4.000 | +4.152 | 64
FASCIA | C100/<RAD HEADER-RAD HEADER> | F/37 | 5.1 | +4.000 | +4.102 | 51
RAD HEADER PLATE | C200/RAD HEADER | PL/1575 | 0.2 | +3.421 | +3.579 | 60
RAD HEADER PLATE | C150/RAD HEADER | PL/1571 | 0.2 | +3.446 | +3.554 | 60
RAD HEADER PLATE | C100/RAD HEADER | PL/1567 | 0.1 | +3.456 | +3.544 | 47
MULLION | C200/RAD HEADER | Z/2282 | 28.3 | +0.000 | +3.995 | 76
MULLION | C150/RAD HEADER | Z/2280 | 22.3 | +0.000 | +3.995 | 64
MULLION | C100/RAD HEADER | Z/2279 | 12.8 | +0.000 | +3.995 | 51

# IfcMechanicalFastener: Bolt assembly (21)
In: Undefined
Tekla Bolt - Nut count: 2; Slotted hole x: 0 mm; Location: Site; Bolt count: 2
Name | NominalDiameter (mm) = Washer diameter (mm) = Bolt size (mm) | NominalLength (mm) = Bolt length (mm) | Material = Bolt standard | Washer count | Washer type | Washer name | Nut type | Nut name | Slotted hole y (mm) | Bolt hole diameter (mm) | Bolt Name
9 x Bolt assembly | 12 | 30 | PB1230 | 2 | FLAT | WASHERM12-FLAT | 4.6-HEX | NUTM12-4.6-HEX | 61 | 14 | BOLTPB1230
9 x Bolt assembly | 5 | 25 | TEK_16TPIM | 8 | UNDEF_WASH | UNDEFINED_WASHER5 | UNDEF_NUT | UNDEFINED_NUTM5 | 0 | 7 | TEKSCREW_M5*25
3 x Bolt assembly | 12 | 30 | PB1230 | 2 | FLAT | WASHERM12-FLAT | 4.6-HEX | NUTM12-4.6-HEX | 0 | 14 | BOLTPB1230

# IfcPlate: PLT1.6*146 (3)
In: Undefined
Description: PLT1.6*146; Material: STEEL/250
Tekla Common - Bottom elevation: +3.905; Top elevation: +4.000; Phase: 1; Class: 3
Tekla Quantity - Weight: 0.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 163.2 m2; Net surface area: 0 m2; Height: 146 mm; Width: 1.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 146 mm; CrossSectionArea: 0.00000256 m2
Name | ASSEMBLY_POS = Reference | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
RAD TOP PLATE | PL/1572 | 160.3 | 0.0480744 | 0.0233971 | 0.0000375167
RAD TOP PLATE | PL/1568 | 160.3 | 0.0480744 | 0.0233971 | 0.0000375167
RAD TOP PLATE | PL/1564 | 161.8 | 0.0485172 | 0.0236161 | 0.0000378671

# IfcPlate: PLT1.6*76 (3)
In: Undefined
Description: PLT1.6*76; Material: STEEL/250
Tekla Common - Bottom elevation: +3.905; Top elevation: +4.000; Phase: 1; Class: 3
Tekla Quantity - Weight: 0.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 165.3 m2; Net surface area: 0 m2; Height: 76 mm; Width: 1.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 76 mm; CrossSectionArea: 0.00000256 m2
Name | ASSEMBLY_POS = Reference | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
RAD TOP PLATE | PL/1574 | 135.8 | 0.021469 | 0.0103173 | 0.0000165501
RAD TOP PLATE | PL/1570 | 135.8 | 0.021469 | 0.0103173 | 0.0000165501
RAD TOP PLATE | PL/1566 | 137.3 | 0.0217018 | 0.0104313 | 0.0000167325

# IfcPlate: PLT1.6*96 (3)
In: Undefined
Description: PLT1.6*96; Material: STEEL/250
Tekla Common - Bottom elevation: +3.905; Top elevation: +4.000; Phase: 1; Class: 3
Tekla Quantity - Weight: 0.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 164.3 m2; Net surface area: 0 m2; Height: 96 mm; Width: 1.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 96 mm; CrossSectionArea: 0.00000256 m2
Name | ASSEMBLY_POS = Reference | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
RAD TOP PLATE | PL/1573 | 148.3 | 0.0294442 | 0.0142324 | 0.0000228253
RAD TOP PLATE | PL/1569 | 148.3 | 0.0294442 | 0.0142324 | 0.0000228253
RAD TOP PLATE | PL/1565 | 149.8 | 0.029737 | 0.0143764 | 0.0000230557
