Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView_V2.0, QuantityTakeOffAddOnView], Option [BaseQuantities:On], Option [GridExport:On], Option [Assemblies:On], Option [Bolts:On], Option [Rebars:On], Option [PourObjects:Off], Option [Welds:Off], Option [SurfaceTreatments:Off], Option [LocationBy:0], Option [ViewColors:Off], Option [SectionedSpine:Off], Option [PropertySets:On], Option [Export all:Off]
File name: RAD Header plate.ifc
Time: 2026-05-22T15:23:41
Author: DESKTOP-BKNQL56\admin
Organization: Structural Designer
Written by: IFC Database Version: Work
Made in: Tekla Structures 2019 Service Pack 13, IFC Export Version: 4.0.0.0 Oct 18 2021

# IfcBuildingStorey, Undefined
In: Undefined
Elevation: 0 mm

# IfcBeam: C:100-19, DOOR HEADER
In: Undefined
Description: C:100-19; Material: STEEL/300PLUS
Default - ASSEMBLY_POS: DH/4
Tekla Common - Bottom elevation: +3.449; Top elevation: +3.551; Phase: 1; Class: 5
Tekla Quantity - Weight: 1.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 142.1 m2; Net surface area: 0.2 m2; Height: 102 mm; Width: 51 mm; Length: 500 mm
Pset_BeamCommon - LoadBearing: no; Reference: DH/4
BaseQuantities - Length: 500 mm; OuterSurfaceArea: 0.228157 m2; NetVolume: 0.00021413 m3; NetWeight: 1.68092 kg

# IfcBeam: C:150-24, DOOR HEADER
In: Undefined
Description: C:150-24; Material: STEEL/300PLUS
Default - ASSEMBLY_POS: DH/5
Tekla Common - Bottom elevation: +3.424; Top elevation: +3.576; Phase: 1; Class: 5
Tekla Quantity - Weight: 2.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 111.7 m2; Net surface area: 0.4 m2; Height: 152 mm; Width: 64 mm; Length: 500 mm
Pset_BeamCommon - LoadBearing: no; Reference: DH/5
BaseQuantities - Length: 500 mm; OuterSurfaceArea: 0.311276 m2; NetVolume: 0.00036888 m3; NetWeight: 2.89571 kg

# IfcBeam: C:200-24, DOOR HEADER
In: Undefined
Description: C:200-24; Material: STEEL/300PLUS
Default - ASSEMBLY_POS: DH/6
Tekla Common - Bottom elevation: +3.398; Top elevation: +3.601; Phase: 1; Class: 5
Tekla Quantity - Weight: 3.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 110.5 m2; Net surface area: 0.4 m2; Height: 203 mm; Width: 76 mm; Length: 500 mm
Pset_BeamCommon - LoadBearing: no; Reference: DH/6
BaseQuantities - Length: 500 mm; OuterSurfaceArea: 0.39166 m2; NetVolume: 0.00046488 m3; NetWeight: 3.64931 kg

# IfcColumn: C:100-19, MULLION
In: Undefined
Description: C:100-19; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Top elevation: +3.995; Phase: 1; Class: 2
Default - ASSEMBLY_POS: Z/2279
Tekla Quantity - Weight: 12.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 141.7 m2; Net surface area: 1.8 m2; Height: 102 mm; Width: 51 mm; Length: 3994.7 mm
Pset_ColumnCommon - LoadBearing: no; Reference: Z/2279
BaseQuantities - Length: 3994.71 mm; OuterSurfaceArea: 1.81685 m2; NetVolume: 0.00171077 m3; NetWeight: 13.4296 kg

# IfcColumn: C:150-24, MULLION
In: Undefined
Description: C:150-24; Material: STEEL/G450
Tekla Common - Bottom elevation: +0.000; Top elevation: +3.995; Phase: 1; Class: 2
Default - ASSEMBLY_POS: Z/2280
Tekla Quantity - Weight: 22.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 111.2 m2; Net surface area: 2.5 m2; Height: 152 mm; Width: 64 mm; Length: 3994.7 mm
Pset_ColumnCommon - LoadBearing: no; Reference: Z/2280
BaseQuantities - Length: 3994.71 mm; OuterSurfaceArea: 2.4766 m2; NetVolume: 0.00294714 m3; NetWeight: 23.135 kg

# IfcColumn: C:200-24, MULLION
In: Undefined
Description: C:200-24; Material: STEEL/G450
Default - ASSEMBLY_POS: Z/2282
Tekla Common - Bottom elevation: +0.000; Top elevation: +3.995; Phase: 1; Class: 2
Tekla Quantity - Weight: 28.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 110 m2; Net surface area: 3.1 m2; Height: 203 mm; Width: 76 mm; Length: 3994.7 mm
Pset_ColumnCommon - LoadBearing: no; Reference: Z/2282
BaseQuantities - Length: 3994.71 mm; OuterSurfaceArea: 3.11614 m2; NetVolume: 0.00371412 m3; NetWeight: 29.1559 kg

# IfcElementAssembly (12)
In: Undefined
PredefinedType: RIGID_FRAME
Name | ASSEMBLY_POSITION_CODE = Assembly/Cast unit position code | ASSEMBLY_POS = Assembly/Cast unit Mark | Assembly/Cast unit weight (kg) | Assembly/Cast unit bottom elevation | Assembly/Cast unit top elevation | Width (mm)
RAD TOP PLATE | C200/RAD HEADER | PL/1572 | 0.3 | +3.905 | +4.000 | 70.6
RAD TOP PLATE | C150/RAD HEADER | PL/1569 | 0.2 | +3.905 | +4.000 | 58.6
RAD TOP PLATE | C100/RAD HEADER | PL/1566 | 0.1 | +3.905 | +4.000 | 47.6
RAD HEADER PLATE | C200/RAD HEADER | PL/1575 | 0.2 | +3.421 | +3.579 | 60
RAD HEADER PLATE | C150/RAD HEADER | PL/1571 | 0.2 | +3.446 | +3.554 | 60
RAD HEADER PLATE | C100/RAD HEADER | PL/1567 | 0.1 | +3.456 | +3.544 | 47
DOOR HEADER | C200/<RAD HEADER | DH/6 | 3.5 | +3.398 | +3.601 | 76
MULLION | C200/RAD HEADER | Z/2282 | 28.3 | +0.000 | +3.995 | 76
DOOR HEADER | C150/<RAD HEADER | DH/5 | 2.8 | +3.424 | +3.576 | 64
MULLION | C150/RAD HEADER | Z/2280 | 22.3 | +0.000 | +3.995 | 64
DOOR HEADER | C100/<RAD HEADER | DH/4 | 1.6 | +3.449 | +3.551 | 51
MULLION | C100/RAD HEADER | Z/2279 | 12.8 | +0.000 | +3.995 | 51

# IfcMechanicalFastener: Bolt assembly (9)
In: Undefined
NominalDiameter: 12 mm; NominalLength: 30 mm
Tekla Bolt - Washer count: 2; Washer diameter: 12 mm; Washer type: FLAT; Washer name: WASHERM12-FLAT; Nut count: 2; Nut type: 4.6-HEX; Nut name: NUTM12-4.6-HEX; Slotted hole x: 0 mm; Bolt hole diameter: 14 mm; Location: Site; Bolt count: 2; Bolt size: 12 mm; Bolt length: 30 mm
Name | Material = Bolt standard | Slotted hole y (mm) | Bolt Name
3 x Bolt assembly | PB1230 | 61 | BOLTPB1230
3 x Bolt assembly | PB1230 | 0 | BOLTPB1230
3 x Bolt assembly | FB1230Z | 0 | BOLTFB1230

# IfcPlate: PLT1.6*108, RAD HEADER PLATE
In: Undefined
Description: PLT1.6*108; Material: STEEL/250
Default - ASSEMBLY_POS: PL/1571
Tekla Common - Bottom elevation: +3.446; Top elevation: +3.554; Phase: 1; Class: 3
Tekla Quantity - Weight: 0.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 164.7 m2; Net surface area: 0 m2; Height: 108 mm; Width: 1.6 mm; Length: 114.7 mm
Pset_PlateCommon - LoadBearing: no; Reference: PL/1571
BaseQuantities - Width: 108 mm; NetArea: 0.0257001 m2; GrossArea: 0.0123826 m2; CrossSectionArea: 0.00000256 m2; NetVolume: 0.0000198724 m3; GrossVolume: 0.0000198724 m3

# IfcPlate: PLT1.6*114.7, RAD HEADER PLATE
In: Undefined
Description: PLT1.6*114.7; Material: STEEL/250
Default - ASSEMBLY_POS: PL/1575
Tekla Common - Bottom elevation: +3.421; Top elevation: +3.579; Phase: 1; Class: 3
Tekla Quantity - Weight: 0.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 164 m2; Net surface area: 0 m2; Height: 114.7 mm; Width: 1.6 mm; Length: 158 mm
Pset_PlateCommon - LoadBearing: no; Reference: PL/1575
BaseQuantities - Width: 114.654 mm; NetArea: 0.0374279 m2; GrossArea: 0.0181153 m2; CrossSectionArea: 0.00000256 m2; NetVolume: 0.0000290726 m3; GrossVolume: 0.0000290726 m3

# IfcPlate: PLT1.6*88, RAD HEADER PLATE
In: Undefined
Description: PLT1.6*88; Material: STEEL/250
Default - ASSEMBLY_POS: PL/1567
Tekla Common - Bottom elevation: +3.456; Top elevation: +3.544; Phase: 1; Class: 3
Tekla Quantity - Weight: 0.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 165.7 m2; Net surface area: 0 m2; Height: 88 mm; Width: 1.6 mm; Length: 101.7 mm
Pset_PlateCommon - LoadBearing: no; Reference: PL/1567
BaseQuantities - Width: 88 mm; NetArea: 0.0186794 m2; GrossArea: 0.00894555 m2; CrossSectionArea: 0.00000256 m2; NetVolume: 0.0000143619 m3; GrossVolume: 0.0000143619 m3
