Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView_V2.0, QuantityTakeOffAddOnView], Option [BaseQuantities:On], Option [GridExport:On], Option [Assemblies:On], Option [Bolts:On], Option [Rebars:On], Option [PourObjects:Off], Option [Welds:Off], Option [SurfaceTreatments:Off], Option [LocationBy:0], Option [ViewColors:Off], Option [SectionedSpine:Off], Option [PropertySets:On], Option [Export all:Off]
File name: Double C-Section Column Embedded Baseplate.ifc
Time: 2026-03-26T06:36:58
Author: DESKTOP-BKNQL56\admin
Organization: Structural Designer
Written by: IFC Database Version: Work
Made in: Tekla Structures 2019 Service Pack 13, IFC Export Version: 4.0.0.0 Oct 18 2021

# IfcBuildingStorey, Undefined
In: Undefined
Elevation: 0 mm

# IfcBeam: C:150-24, COLUMN
In: Undefined
Description: C:150-24; Material: STEEL/G450
Default - ASSEMBLY_POS: Z/12
Tekla Common - Finish: 1mm ggap +4; Bottom elevation: +0.000; Top elevation: +1.500; Phase: 1; Class: 12
Tekla Quantity - Weight: 8.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 111.3 m2; Net surface area: 0.9 m2; Height: 152 mm; Width: 64 mm; Length: 1499.7 mm
Pset_BeamCommon - LoadBearing: no; Reference: Z/12
BaseQuantities - Length: 1499.71 mm; OuterSurfaceArea: 0.930694 m2; NetVolume: 0.00110642 m3; NetWeight: 8.68543 kg

# IfcBeam: C:200-24, COLUMN
In: Undefined
Description: C:200-24; Material: STEEL/G450
Tekla Common - Finish: 1mm ggap +4; Bottom elevation: +0.000; Top elevation: +1.500; Phase: 1; Class: 12
Default - ASSEMBLY_POS: Z/24
Tekla Quantity - Weight: 10.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 110.2 m2; Net surface area: 1.2 m2; Height: 203 mm; Width: 76 mm; Length: 1499.7 mm
Pset_BeamCommon - LoadBearing: no; Reference: Z/24
BaseQuantities - Length: 1499.71 mm; OuterSurfaceArea: 1.17103 m2; NetVolume: 0.00139437 m3; NetWeight: 10.9458 kg

# IfcBeam: C:250-24, COLUMN
In: Undefined
Description: C:250-24; Material: STEEL/G450
Tekla Common - Finish: 1mm ggap +4; Bottom elevation: +0.000; Top elevation: +1.500; Phase: 1; Class: 12
Default - ASSEMBLY_POS: Z/47
Tekla Quantity - Weight: 12 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 109.8 m2; Net surface area: 1.2 m2; Height: 254 mm; Width: 76 mm; Length: 1499.7 mm
Pset_BeamCommon - LoadBearing: no; Reference: Z/47
BaseQuantities - Length: 1499.61 mm; OuterSurfaceArea: 1.32115 m2; NetVolume: 0.00157423 m3; NetWeight: 12.3577 kg

# IfcBeam: C:300-30, COLUMN
In: Undefined
Description: C:300-30; Material: STEEL/G450
Tekla Common - Finish: 1mm ggap +4; Bottom elevation: +0.000; Top elevation: +1.500; Phase: 1; Class: 12
Default - ASSEMBLY_POS: Z/183
Tekla Quantity - Weight: 18.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.5 m2; Net surface area: 1.6 m2; Height: 300 mm; Width: 96 mm; Length: 1500 mm
Pset_BeamCommon - LoadBearing: no; Reference: Z/183
BaseQuantities - Length: 1500 mm; OuterSurfaceArea: 1.64125 m2; NetVolume: 0.0024435 m3; NetWeight: 19.1814 kg

# IfcBeam: C:350-30, COLUMN
In: Undefined
Description: C:350-30; Material: STEEL/G450
Tekla Common - Finish: 1mm ggap +4; Bottom elevation: +0.000; Top elevation: +1.500; Phase: 1; Class: 12
Default - ASSEMBLY_POS: Z/193
Tekla Quantity - Weight: 22.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.2 m2; Net surface area: 2 m2; Height: 350 mm; Width: 125 mm; Length: 1500 mm
Pset_BeamCommon - LoadBearing: no; Reference: Z/193
BaseQuantities - Length: 1500 mm; OuterSurfaceArea: 1.95688 m2; NetVolume: 0.00291599 m3; NetWeight: 22.8906 kg

# IfcBeam: FL6*130, EMBEDDED BASE PLATE
In: Undefined
Description: FL6*130; Material: STEEL/450
Tekla Common - Finish: GALVANIZE; Bottom elevation: -0.450; Top elevation: +0.225; Phase: 1; Class: 5
Default - ASSEMBLY_POS: PL/711
Tekla Quantity - Weight: 9.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 44.6 m2; Net surface area: 0.5 m2; Height: 130 mm; Width: 6 mm; Length: 1491.7 mm
Pset_BeamCommon - LoadBearing: no; Reference: PL/711
BaseQuantities - Length: 1491.71 mm; OuterSurfaceArea: 0.40978 m2; NetVolume: 0.00117 m3; NetWeight: 9.1845 kg

# IfcBeam: PLT6*155 (2)
In: Undefined
Description: PLT6*155; Material: STEEL/450
Tekla Common - Finish: GALVANIZE; Bottom elevation: -0.450; Top elevation: +0.225; Phase: 1; Class: 5
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 44.3 m2; Net surface area: 0.5 m2; Height: 155 mm; Width: 6 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Weight (kg) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
EMBEDDED BASE PLATE | PL/715 | 11.7 | 1593.7 | 1593.71 | 0.517966 | 0.00148986 | 11.6954
EMBEDDED BASE PLATE | PL/713 | 11.3 | 1542.7 | 1542.71 | 0.501544 | 0.00144243 | 11.3231

# IfcBeam: PLT6*195, EMBEDDED BASE PLATE
In: Undefined
Description: PLT6*195; Material: STEEL/450
Tekla Common - Finish: GALVANIZE; Bottom elevation: -0.450; Top elevation: +0.236; Phase: 1; Class: 5
Default - ASSEMBLY_POS: PL/717
Tekla Quantity - Weight: 15.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 43.9 m2; Net surface area: 0.7 m2; Height: 195 mm; Width: 6 mm; Length: 1661.7 mm
Pset_BeamCommon - LoadBearing: no; Reference: PL/717
BaseQuantities - Length: 1661.71 mm; OuterSurfaceArea: 0.67401 m2; NetVolume: 0.0019539 m3; NetWeight: 15.3381 kg

# IfcBeam: PLT6*255, EMBEDDED BASE PLATE
In: Undefined
Description: PLT6*255; Material: STEEL/450
Default - ASSEMBLY_POS: PL/719
Tekla Common - Finish: GALVANIZE; Bottom elevation: -0.450; Top elevation: +0.236; Phase: 1; Class: 5
Tekla Quantity - Weight: 20.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 43.6 m2; Net surface area: 0.9 m2; Height: 255 mm; Width: 6 mm; Length: 1711.7 mm
Pset_BeamCommon - LoadBearing: no; Reference: PL/719
BaseQuantities - Length: 1711.71 mm; OuterSurfaceArea: 0.901332 m2; NetVolume: 0.0026316 m3; NetWeight: 20.6581 kg

# IfcColumn: C:150-24, COLUMN
In: Undefined
Description: C:150-24; Material: STEEL/G450
Default - ASSEMBLY_POS: Z/12
Tekla Common - Finish: 1mm ggap +4; Bottom elevation: +0.000; Top elevation: +1.500; Phase: 1; Class: 12
Tekla Quantity - Weight: 8.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 111.3 m2; Net surface area: 0.9 m2; Height: 152 mm; Width: 64 mm; Length: 1499.7 mm
Pset_ColumnCommon - LoadBearing: no; Reference: Z/12
BaseQuantities - Length: 1499.71 mm; OuterSurfaceArea: 0.930694 m2; NetVolume: 0.00110642 m3; NetWeight: 8.68543 kg

# IfcColumn: C:200-24, COLUMN
In: Undefined
Description: C:200-24; Material: STEEL/G450
Tekla Common - Finish: 1mm ggap +4; Bottom elevation: +0.000; Top elevation: +1.500; Phase: 1; Class: 12
Default - ASSEMBLY_POS: Z/24
Tekla Quantity - Weight: 10.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 110.2 m2; Net surface area: 1.2 m2; Height: 203 mm; Width: 76 mm; Length: 1499.7 mm
BaseQuantities - Length: 1499.71 mm; OuterSurfaceArea: 1.17103 m2; NetVolume: 0.00139437 m3; NetWeight: 10.9458 kg
Pset_ColumnCommon - LoadBearing: no; Reference: Z/24

# IfcColumn: C:250-24, COLUMN
In: Undefined
Description: C:250-24; Material: STEEL/G450
Tekla Common - Finish: 1mm ggap +4; Bottom elevation: +0.000; Top elevation: +1.500; Phase: 1; Class: 12
Default - ASSEMBLY_POS: Z/47
Tekla Quantity - Weight: 12 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 109.8 m2; Net surface area: 1.2 m2; Height: 254 mm; Width: 76 mm; Length: 1499.7 mm
BaseQuantities - Length: 1499.61 mm; OuterSurfaceArea: 1.32115 m2; NetVolume: 0.00157423 m3; NetWeight: 12.3577 kg
Pset_ColumnCommon - LoadBearing: no; Reference: Z/47

# IfcColumn: C:300-30, COLUMN
In: Undefined
Description: C:300-30; Material: STEEL/G450
Tekla Common - Finish: 1mm ggap +4; Bottom elevation: +0.000; Top elevation: +1.500; Phase: 1; Class: 12
Default - ASSEMBLY_POS: Z/183
Tekla Quantity - Weight: 18.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.5 m2; Net surface area: 1.6 m2; Height: 300 mm; Width: 96 mm; Length: 1500 mm
BaseQuantities - Length: 1500 mm; OuterSurfaceArea: 1.64125 m2; NetVolume: 0.0024435 m3; NetWeight: 19.1814 kg
Pset_ColumnCommon - LoadBearing: no; Reference: Z/183

# IfcColumn: C:350-30, COLUMN
In: Undefined
Description: C:350-30; Material: STEEL/G450
Tekla Common - Finish: 1mm ggap +4; Bottom elevation: +0.000; Top elevation: +1.500; Phase: 1; Class: 12
Default - ASSEMBLY_POS: Z/193
Tekla Quantity - Weight: 22.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.2 m2; Net surface area: 2 m2; Height: 350 mm; Width: 125 mm; Length: 1500 mm
BaseQuantities - Length: 1500 mm; OuterSurfaceArea: 1.95688 m2; NetVolume: 0.00291599 m3; NetWeight: 22.8906 kg
Pset_ColumnCommon - LoadBearing: no; Reference: Z/193

# IfcElementAssembly (15)
In: Undefined
PredefinedType: RIGID_FRAME
Name | ASSEMBLY_POSITION_CODE = Assembly/Cast unit position code | ASSEMBLY_POS = Assembly/Cast unit Mark | Assembly/Cast unit weight (kg) | Assembly/Cast unit bottom elevation | Assembly/Cast unit top elevation | Width (mm)
EMBEDDED BASE PLATE | C200SD/3 | PL/713 | 11.3 | -0.450 | +0.225 | 221
2 x COLUMN | C200SD/3 | Z/24 | 10.6 | +0.000 | +1.500 | 76
2 x COLUMN | C250SD/3 | Z/47 | 12 | +0.000 | +1.500 | 76
EMBEDDED BASE PLATE | C250SD/3 | PL/715 | 11.7 | -0.450 | +0.225 | 272
EMBEDDED BASE PLATE | C300SD/3 | PL/717 | 15.3 | -0.450 | +0.236 | 318
2 x COLUMN | C300SD/3 | Z/183 | 18.8 | +0.000 | +1.500 | 96
EMBEDDED BASE PLATE | C350SD/3 | PL/719 | 20.7 | -0.450 | +0.236 | 368
2 x COLUMN | C350SD/3 | Z/193 | 22.4 | +0.000 | +1.500 | 125
EMBEDDED BASE PLATE | C150SD/3 | PL/711 | 9.2 | -0.450 | +0.225 | 170
2 x COLUMN | C150SD/3 | Z/12 | 8.4 | +0.000 | +1.500 | 64

# IfcMechanicalFastener: Bolt assembly (34)
In: Undefined
Material: 8.8S
Tekla Bolt - Washer type: HARD; Nut type: 8.8-HEX; Slotted hole y: 0 mm; Slotted hole x: 0 mm; Location: Site; Bolt standard: 8.8S
Name | NominalDiameter (mm) = Washer diameter (mm) = Bolt size (mm) | NominalLength (mm) = Bolt length (mm) | Washer count = Nut count | Washer name | Nut name | Bolt hole diameter (mm) | Bolt count | Bolt Name
14 x Bolt assembly | 20 | 16 | 0 | WASHERM20-HARD | NUTM20-8.8-HEX | 20 | 2 | BOLTM20*25
4 x Bolt assembly | 12 | 30 | 3 | WASHERM12-HARD | NUTM12-8.8-HEX | 14 | 3 | BOLTM12*30
12 x Bolt assembly | 16 | 45 | 3 | WASHERM16-HARD | NUTM16-8.8-HEX | 18 | 3 | BOLTM16*45
4 x Bolt assembly | 12 | 35 | 3 | WASHERM12-HARD | NUTM12-8.8-HEX | 14 | 3 | BOLTM12*35
