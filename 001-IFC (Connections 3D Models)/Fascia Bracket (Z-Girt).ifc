Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView_V2.0, QuantityTakeOffAddOnView], Option [BaseQuantities:On], Option [GridExport:On], Option [Assemblies:Off], Option [Bolts:On], Option [Rebars:On], Option [PourObjects:Off], Option [Welds:Off], Option [SurfaceTreatments:Off], Option [LocationBy:0], Option [ViewColors:Off], Option [SectionedSpine:Off], Option [PropertySets:On], Option [Export all:Off]
File name: Fascia Bracket (Z-Girt).ifc
Time: 2026-08-08T12:30:19
Author: DESKTOP-BKNQL56\admin
Organization: Structural Designer
Written by: IFC Database Version: Work
Made in: Tekla Structures 2019 Service Pack 13, IFC Export Version: 4.0.0.0 Oct 18 2021

# IfcBuildingStorey, Undefined
In: Undefined
Elevation: 0 mm

# IfcBeam: C:100-15 (3)
In: Undefined
Description: C:100-15; Material: STEEL/300PLUS
Default - ASSEMBLY_POS: F/7
Tekla Common - Bottom elevation: +3.129; Top elevation: +3.231; Phase: 1; Class: 13
Tekla Quantity - Weight: 3.4 kg; Volume: 0 m3; Gross footprint area: 0.1 m2; Area per tons: 178.9 m2; Net surface area: 0.6 m2; Height: 102 mm; Width: 51 mm; Length: 1350 mm
Pset_BeamCommon - LoadBearing: no; Reference: F/7
BaseQuantities - Length: 1350 mm; OuterSurfaceArea: 0.612225 m2; NetVolume: 0.000455625 m3; NetWeight: 3.57666 kg

# IfcBeam: C:150-15 (3)
In: Undefined
Description: C:150-15; Material: STEEL/300PLUS
Default - ASSEMBLY_POS: F/8
Tekla Common - Bottom elevation: +2.719; Top elevation: +2.871; Phase: 1; Class: 13
Tekla Quantity - Weight: 4.7 kg; Volume: 0 m3; Gross footprint area: 0.1 m2; Area per tons: 176.5 m2; Net surface area: 0.8 m2; Height: 152 mm; Width: 64 mm; Length: 1350 mm
Pset_BeamCommon - LoadBearing: no; Reference: F/8
BaseQuantities - Length: 1350 mm; OuterSurfaceArea: 0.828465 m2; NetVolume: 0.000617625 m3; NetWeight: 4.84836 kg

# IfcBeam: C:200-15 (3)
In: Undefined
Description: C:200-15; Material: STEEL/300PLUS
Default - ASSEMBLY_POS: F/9
Tekla Common - Bottom elevation: +2.228; Top elevation: +2.431; Phase: 1; Class: 13
Tekla Quantity - Weight: 5.9 kg; Volume: 0 m3; Gross footprint area: 0.1 m2; Area per tons: 175.3 m2; Net surface area: 1 m2; Height: 203 mm; Width: 76 mm; Length: 1350 mm
Pset_BeamCommon - LoadBearing: no; Reference: F/9
BaseQuantities - Length: 1350 mm; OuterSurfaceArea: 1.03119 m2; NetVolume: 0.0007695 m3; NetWeight: 6.04058 kg

# IfcBeam: PLT3*60 (9)
In: Undefined
Description: PLT3*60; Material: STEEL/250
Tekla Common - Phase: 1; Class: 12
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 60 mm; Width: 3 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
FASCIA BRACKET | FB/19 | +3.124 | +3.235 | 0.4 | 90.2 | 0 | 296.8 | 296.85 | 0.0383182 | 0.00005409 | 0.424606
FASCIA BRACKET | FB/20 | +2.714 | +2.875 | 0.4 | 90.2 | 0 | 333.8 | 333.85 | 0.0429802 | 0.00006075 | 0.476887
FASCIA BRACKET | FB/21 | +2.223 | +2.435 | 0.4 | 90 | 0 | 372.8 | 372.85 | 0.0478942 | 0.00006777 | 0.531994
FASCIA BRACKET | FB/16 | +3.124 | +3.235 | 0.7 | 89.8 | 0.1 | 498.8 | 498.85 | 0.0637702 | 0.00009045 | 0.710032
FASCIA BRACKET | FB/17 | +2.714 | +2.875 | 0.7 | 89.8 | 0.1 | 535.8 | 535.85 | 0.0684322 | 0.00009711 | 0.762313
FASCIA BRACKET | FB/18 | +2.223 | +2.435 | 0.7 | 89.7 | 0.1 | 574.8 | 574.85 | 0.0733462 | 0.00010413 | 0.81742
FASCIA BRACKET | FB/13 | +3.124 | +3.235 | 0.7 | 90 | 0.1 | 396.8 | 396.85 | 0.0509182 | 0.00007209 | 0.565906
FASCIA BRACKET | FB/14 | +2.714 | +2.875 | 0.7 | 89.8 | 0.1 | 433.8 | 433.85 | 0.0555802 | 0.00007875 | 0.618187
FASCIA BRACKET | FB/15 | +2.223 | +2.435 | 0.7 | 89.8 | 0.1 | 472.8 | 472.85 | 0.0604942 | 0.00008577 | 0.673294

# IfcBeam: Z:100-15, TH
In: Undefined
Description: Z:100-15; Material: STEEL/300PLUS
Default - ASSEMBLY_POS: B/124
Tekla Common - Bottom elevation: +2.007; Top elevation: +2.107; Phase: 1; Class: 4
Tekla Quantity - Weight: 3.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 179.1 m2; Net surface area: 0.6 m2; Height: 102 mm; Width: 100.5 mm; Length: 1350 mm
Pset_BeamCommon - LoadBearing: no; Reference: B/124
BaseQuantities - Length: 1350 mm; OuterSurfaceArea: 0.612225 m2; NetVolume: 0.000455625 m3; NetWeight: 3.57666 kg

# IfcBeam: Z:150-15, TH
In: Undefined
Description: Z:150-15; Material: STEEL/300PLUS
Default - ASSEMBLY_POS: B/122
Tekla Common - Bottom elevation: +1.995; Top elevation: +2.119; Phase: 1; Class: 4
Tekla Quantity - Weight: 4.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 176.7 m2; Net surface area: 0.8 m2; Height: 152 mm; Width: 124.5 mm; Length: 1350 mm
Pset_BeamCommon - LoadBearing: no; Reference: B/122
BaseQuantities - Length: 1350 mm; OuterSurfaceArea: 0.828465 m2; NetVolume: 0.000617625 m3; NetWeight: 4.84836 kg

# IfcBeam: Z:200-15, TH
In: Undefined
Description: Z:200-15; Material: STEEL/300PLUS
Default - ASSEMBLY_POS: B/123
Tekla Common - Bottom elevation: +1.982; Top elevation: +2.133; Phase: 1; Class: 4
Tekla Quantity - Weight: 5.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 175.3 m2; Net surface area: 1 m2; Height: 203 mm; Width: 151.5 mm; Length: 1350 mm
Pset_BeamCommon - LoadBearing: no; Reference: B/123
BaseQuantities - Length: 1350 mm; OuterSurfaceArea: 1.03119 m2; NetVolume: 0.0007695 m3; NetWeight: 6.04057 kg

# IfcColumn: C:150-24 (3)
In: Undefined
Description: C:150-24; Material: STEEL/G450
Default - ASSEMBLY_POS: Z/8
Tekla Common - Finish: 25 deg; Bottom elevation: +0.000; Top elevation: +3.400; Phase: 1; Class: 10
Tekla Quantity - Weight: 18.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 111.2 m2; Net surface area: 2.1 m2; Height: 152 mm; Width: 64 mm; Length: 3400 mm
Pset_ColumnCommon - LoadBearing: no; Reference: Z/8
BaseQuantities - Length: 3400 mm; OuterSurfaceArea: 2.10812 m2; NetVolume: 0.00250838 m3; NetWeight: 19.6908 kg

# IfcMechanicalFastener: Bolt assembly (27)
In: Undefined
NominalDiameter: 5 mm; NominalLength: 25 mm; Material: TEK_16TPIM
Tekla Bolt - Washer diameter: 5 mm; Washer type: UNDEF_WASH; Washer name: UNDEFINED_WASHER5; Nut type: UNDEF_NUT; Nut name: UNDEFINED_NUTM5; Slotted hole y: 0 mm; Slotted hole x: 0 mm; Bolt hole diameter: 7 mm; Location: Site; Bolt size: 5 mm; Bolt length: 25 mm; Bolt standard: TEK_16TPIM; Bolt Name: TEKSCREW_M5*25
Name | Washer count | Nut count = Bolt count
18 x Bolt assembly | 4 | 2
9 x Bolt assembly | 8 | 4
