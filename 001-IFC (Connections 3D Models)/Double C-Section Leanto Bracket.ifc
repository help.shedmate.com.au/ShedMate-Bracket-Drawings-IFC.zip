Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView_V2.0, QuantityTakeOffAddOnView], Option [BaseQuantities:On], Option [GridExport:On], Option [Assemblies:On], Option [Bolts:On], Option [Rebars:On], Option [PourObjects:Off], Option [Welds:Off], Option [SurfaceTreatments:Off], Option [LocationBy:0], Option [ViewColors:Off], Option [SectionedSpine:Off], Option [PropertySets:On], Option [Export all:Off]
File name: Double C-Section Leanto Bracket.ifc
Time: 2026-02-26T09:35:53
Author: DESKTOP-BKNQL56\admin
Organization: Structural Designer
Written by: IFC Database Version: Work
Made in: Tekla Structures 2019 Service Pack 13, IFC Export Version: 4.0.0.0 Oct 18 2021

# IfcBuildingStorey, Undefined
In: Undefined
Elevation: 0 mm

# IfcBeam: C:150-24 (3)
In: Undefined
Description: C:150-24; Material: STEEL/G450
Tekla Common - Phase: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 152 mm; Width: 64 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Finish | Bottom elevation | Top elevation | Class | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x RAFTER | Z/0(?) | 3 deg | +3.497 | +3.697 | 10 | 5 | 111.5 | 0.6 | 905.9 | 905.92 | 0.562784 | 0.000668352 | 5.24656
COLUMN | Z/84(?) | 12 deg | +0.000 | +5.063 | 12 | 28.2 | 111.2 | 3.1 | 5063.1 | 5063.14 | 3.1386 | 0.00373538 | 29.3228

# IfcBeam: C:200-24 (2)
In: Undefined
Description: C:200-24; Material: STEEL/G450
Tekla Common - Finish: 3 deg; Bottom elevation: +3.498; Top elevation: +3.745; Phase: 1; Class: 10
Tekla Quantity - Weight: 5.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 110.3 m2; Net surface area: 0.6 m2; Height: 203 mm; Width: 76 mm; Length: 837.6 mm
Pset_BeamCommon - LoadBearing: no
BaseQuantities - Length: 837.65 mm; OuterSurfaceArea: 0.654891 m2; NetVolume: 0.000778813 m3; NetWeight: 6.11369 kg
Name | ASSEMBLY_POS = Reference
RAFTER | Z/528
RAFTER | Z/551

# IfcBeam: C:250-24 (2)
In: Undefined
Description: C:250-24; Material: STEEL/G450
Tekla Common - Finish: 3 deg; Bottom elevation: +3.448; Top elevation: +3.744; Phase: 1; Class: 10
Tekla Quantity - Weight: 6.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 110 m2; Net surface area: 0.6 m2; Height: 254 mm; Width: 76 mm; Length: 809.4 mm
Pset_BeamCommon - LoadBearing: no
BaseQuantities - Length: 809.45 mm; OuterSurfaceArea: 0.714092 m2; NetVolume: 0.000849728 m3; NetWeight: 6.67037 kg
Name | ASSEMBLY_POS = Reference
RAFTER | Z/567
RAFTER | Z/594

# IfcBeam: C:300-30 (2)
In: Undefined
Description: C:300-30; Material: STEEL/G450
Tekla Common - Finish: 3 deg; Bottom elevation: +3.381; Top elevation: +3.742; Phase: 1; Class: 10
Tekla Quantity - Weight: 14.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.4 m2; Net surface area: 1.3 m2; Height: 300 mm; Width: 96 mm; Length: 1186 mm
Pset_BeamCommon - LoadBearing: no
BaseQuantities - Length: 1186.01 mm; OuterSurfaceArea: 1.29838 m2; NetVolume: 0.00193201 m3; NetWeight: 15.1663 kg
Name | ASSEMBLY_POS = Reference
RAFTER | Z/609
RAFTER | Z/632

# IfcBeam: C:350-30 (3)
In: Undefined
Description: C:350-30; Material: STEEL/G450
Tekla Common - Phase: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 350 mm; Width: 125 mm
Pset_BeamCommon - LoadBearing: no
Name | ASSEMBLY_POS = Reference | Finish | Bottom elevation | Top elevation | Class | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
RAFTER | Z/644 | 3 deg | +3.331 | +3.741 | 10 | 17.3 | 87.4 | 1.5 | 1156.3 | 1156.35 | 1.50946 | 0.00224794 | 17.6464
COLUMN | Z/647 | 12 deg | +0.011 | +5.063 | 12 | 75.5 | 87.2 | 6.6 | 5052 | 5052.04 | 6.58164 | 0.00982116 | 77.0961
RAFTER | Z/671 | 3 deg | +3.331 | +3.741 | 10 | 17.3 | 87.4 | 1.5 | 1156.3 | 1156.35 | 1.50946 | 0.00224794 | 17.6464

# IfcBeam: TH:75-95 (5)
In: Undefined
Description: TH:75-95; Material: STEEL/300PLUS
Pset_BeamCommon - LoadBearing: no
Tekla Common - Finish: 3 deg; Phase: 1; Class: 4
Tekla Quantity - Weight: 1.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 0 m2; Net surface area: 0.5 m2; Height: 75 mm; Width: 125 mm; Length: 1000 mm
BaseQuantities - Length: 1000 mm; OuterSurfaceArea: 4.5602e-07 m2; NetVolume: 0.000231901 m3; NetWeight: 1.82042 kg
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation
TH | Z/0(?) | +3.659 | +3.738
4 x TH | Z/560 | +3.711 | +3.790

# IfcColumn: C:150-24, COLUMN
In: Undefined
Description: C:150-24; Material: STEEL/G450
Default - ASSEMBLY_POS: Z/84(?)
Tekla Common - Finish: 12 deg; Bottom elevation: +0.000; Top elevation: +5.063; Phase: 1; Class: 12
Tekla Quantity - Weight: 28.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 111.2 m2; Net surface area: 3.1 m2; Height: 152 mm; Width: 64 mm; Length: 5063.1 mm
BaseQuantities - Length: 5063.14 mm; OuterSurfaceArea: 3.1386 m2; NetVolume: 0.00373538 m3; NetWeight: 29.3228 kg
Pset_ColumnCommon - LoadBearing: no; Reference: Z/84(?)

# IfcColumn: C:200-24 (2)
In: Undefined
Description: C:200-24; Material: STEEL/G450
Tekla Common - Finish: 12 deg; Bottom elevation: +0.000; Top elevation: +5.063; Phase: 1; Class: 12
Tekla Quantity - Weight: 35.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 110 m2; Net surface area: 3.9 m2; Height: 203 mm; Width: 76 mm; Length: 5063.2 mm
Pset_ColumnCommon - LoadBearing: no
BaseQuantities - Length: 5063.16 mm; OuterSurfaceArea: 3.9491 m2; NetVolume: 0.00470752 m3; NetWeight: 36.9541 kg
Name | ASSEMBLY_POS = Reference
COLUMN | Z/530
COLUMN | Z/552

# IfcColumn: C:250-24 (2)
In: Undefined
Description: C:250-24; Material: STEEL/G450
Tekla Common - Finish: 12 deg; Bottom elevation: +0.000; Top elevation: +5.063; Phase: 1; Class: 12
Tekla Quantity - Weight: 40.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 109.7 m2; Net surface area: 4.5 m2; Height: 254 mm; Width: 76 mm; Length: 5063.2 mm
Pset_ColumnCommon - LoadBearing: no
BaseQuantities - Length: 5063.25 mm; OuterSurfaceArea: 4.45573 m2; NetVolume: 0.0053152 m3; NetWeight: 41.7243 kg
Name | ASSEMBLY_POS = Reference
COLUMN | Z/573
COLUMN | Z/599

# IfcColumn: C:300-30 (2)
In: Undefined
Description: C:300-30; Material: STEEL/G450
Tekla Common - Finish: 12 deg; Bottom elevation: +0.011; Top elevation: +5.063; Phase: 1; Class: 12
Tekla Quantity - Weight: 63.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.4 m2; Net surface area: 5.5 m2; Height: 300 mm; Width: 96 mm; Length: 5051.8 mm
Pset_ColumnCommon - LoadBearing: no
BaseQuantities - Length: 5051.81 mm; OuterSurfaceArea: 5.51983 m2; NetVolume: 0.0082294 m3; NetWeight: 64.6008 kg
Name | ASSEMBLY_POS = Reference
COLUMN | Z/612
COLUMN | Z/633

# IfcColumn: C:350-30, COLUMN
In: Undefined
Description: C:350-30; Material: STEEL/G450
Tekla Common - Finish: 12 deg; Bottom elevation: +0.011; Top elevation: +5.063; Phase: 1; Class: 12
Tekla Quantity - Weight: 75.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.2 m2; Net surface area: 6.6 m2; Height: 350 mm; Width: 125 mm; Length: 5052 mm
BaseQuantities - Length: 5052.04 mm; OuterSurfaceArea: 6.58164 m2; NetVolume: 0.00982116 m3; NetWeight: 77.0961 kg
Default - ASSEMBLY_POS: Z/672
Pset_ColumnCommon - LoadBearing: no; Reference: Z/672

# IfcElementAssembly (55)
In: Undefined
PredefinedType: RIGID_FRAME
Name | ASSEMBLY_POSITION_CODE = Assembly/Cast unit position code | ASSEMBLY_POS = Assembly/Cast unit Mark | Assembly/Cast unit weight (kg) | Assembly/Cast unit bottom elevation | Assembly/Cast unit top elevation | Width (mm)
2 x LEANTO COLUMN STIFFEN | C200SD/3deg | Z/0(?) | 1.8 | +3.213 | +3.593 | 3
2 x LEANTO COLUMN STIFFEN | C250SD/3deg | Z/0(?) | 2.6 | +3.111 | +3.541 | 3
2 x LEANTO COLUMN STIFFEN | C300SD/3deg | Z/0(?) | 3.4 | +3.012 | +3.492 | 3
2 x LEANTO COLUMN STIFFEN | C350SD/3deg | Z/0(?) | 4.4 | +2.911 | +3.441 | 3
2 x LEANTO COLUMN STIFFEN | C150SD/3deg | Z/0(?) | 1.1 | +3.283 | +3.593 | 3
2 x COLUMN | C150SD/3deg | Z/84(?) | 28.2 | +0.000 | +5.063 | 64
2 x LEANTO BRACKET | C150SD/<3deg | Z/0(?) | 2.2 | +3.333 | +3.673 | 65
2 x RAFTER | C150SD/<3deg | Z/0(?) | 5 | +3.497 | +3.697 | 64
TH | C150SD-C200SD/<3deg | Z/0(?) | 1.8 | +3.659 | +3.738 | 125
BHL-12-150 | C150SD/3deg-3deg | Z/0(?) | 6.5 | +4.093 | +5.240 | 64
PLATE | C150SD/3deg | Z/0(?) | 2.5 | +4.777 | +5.080 | 67
LEANTO BRACKET | C350SD/<3deg | Z/663(?) | 8.3 | +2.961 | +3.720 | 736.63
LEANTO BRACKET | C350SD/<3deg | Z/660(?) | 8.3 | +2.961 | +3.720 | 736.63
COLUMN | C350SD/3deg | Z/647 | 75.5 | +0.011 | +5.063 | 125
2 x BASEPLATE | C350SD/3deg | Z/646 | 3 | +0.006 | +0.166 | 346
RAFTER | C350SD/<3deg | Z/644 | 17.3 | +3.331 | +3.741 | 125
COLUMN | C350SD/3deg | Z/672 | 75.5 | +0.011 | +5.063 | 125
TH | C350SD>/<3deg | Z/560 | 1.8 | +3.711 | +3.790 | 125
RAFTER | C350SD/<3deg | Z/671 | 17.3 | +3.331 | +3.741 | 125
COLUMN | C300SD/3deg | Z/612 | 63.2 | +0.011 | +5.063 | 96
COLUMN | C300SD/3deg | Z/633 | 63.2 | +0.011 | +5.063 | 96
LEANTO BRACKET | C300SD/<3deg | Z/626(?) | 6.5 | +3.062 | +3.722 | 81
LEANTO BRACKET | C300SD/<3deg | Z/627(?) | 6.5 | +3.062 | +3.722 | 81
RAFTER | C300SD/<3deg | Z/609 | 14.8 | +3.381 | +3.742 | 96
TH | C300SD-C350SD/<3deg | Z/560 | 1.8 | +3.711 | +3.790 | 125
RAFTER | C300SD/<3deg | Z/632 | 14.8 | +3.381 | +3.742 | 96
BHL-12-300 | C300SD/3deg-3deg | Z/620 | 7.5 | +3.892 | +5.202 | 64
PLATE | C300SD/3deg-3deg | Z/623(?) | 8.8 | +4.577 | +5.153 | 99
COLUMN | C200SD/3deg | Z/530 | 35.9 | +0.000 | +5.063 | 76
LEANTO BRACKET | C200SD/<3deg | Z/542(?) | 3.7 | +3.263 | +3.723 | 71
RAFTER | C200SD/<3deg | Z/528 | 5.9 | +3.498 | +3.745 | 76
COLUMN | C200SD/3deg | Z/552 | 35.9 | +0.000 | +5.063 | 76
LEANTO BRACKET | C200SD/<3deg | Z/545(?) | 3.7 | +3.263 | +3.723 | 71
TH | C200SD-C250SD/<3deg | Z/560 | 1.8 | +3.711 | +3.790 | 125
RAFTER | C200SD/<3deg | Z/551 | 5.9 | +3.498 | +3.745 | 76
BHL-12-200 | C200SD/3deg-3deg | Z/538 | 6.7 | +4.034 | +5.216 | 64
PLATE | C200SD/3deg | Z/227(?) | 3.1 | +4.777 | +5.091 | 79
COLUMN | C250SD/3deg | Z/573 | 40.6 | +0.000 | +5.063 | 76
COLUMN | C250SD/3deg | Z/599 | 40.6 | +0.000 | +5.063 | 76
BHL-12-250 | C250SD/3deg-3deg | Z/581 | 7 | +3.964 | +5.203 | 64
PLATE | C250SD/3deg | Z/584(?) | 5.2 | +4.692 | +5.119 | 79
LEANTO BRACKET | C250SD/<3deg | Z/585(?) | 5 | +3.161 | +3.721 | 71
RAFTER | C250SD/<3deg | Z/567 | 6.5 | +3.448 | +3.744 | 76
LEANTO BRACKET | C250SD/<3deg | Z/589(?) | 5 | +3.161 | +3.721 | 71
TH | C250SD-C300SD/<3deg | Z/560 | 1.8 | +3.711 | +3.790 | 125
RAFTER | C250SD/<3deg | Z/594 | 6.5 | +3.448 | +3.744 | 76

# IfcMechanicalFastener: Bolt assembly (84)
In: Undefined
Tekla Bolt - Location: Site
Name | NominalDiameter (mm) = Washer diameter (mm) | NominalLength (mm) = Bolt length (mm) | Material = Bolt standard | Washer count = Nut count | Washer type | Washer name | Nut type | Nut name | Slotted hole y (mm) | Slotted hole x (mm) | Bolt hole diameter (mm) | Bolt count | Bolt size (mm) | Bolt Name
12 x Bolt assembly | 5 | 3 | TEK_16TPIM | 0 | UNDEF_WASH | UNDEFINED_WASHER5 | UNDEF_NUT | UNDEFINED_NUTM5 | 0 | 0 | 7 | 4 | 7 | TEKSCREW_M5*25
4 x Bolt assembly | 5 | 3 | TEK_16TPIM | 0 | UNDEF_WASH | UNDEFINED_WASHER5 | UNDEF_NUT | UNDEFINED_NUTM5 | 0 | 0 | 7 | 5 | 7 | TEKSCREW_M5*25
4 x Bolt assembly | 5 | 3 | TEK_16TPIM | 0 | UNDEF_WASH | UNDEFINED_WASHER5 | UNDEF_NUT | UNDEFINED_NUTM5 | 0 | 0 | 7 | 3 | 7 | TEKSCREW_M5*25
2 x Bolt assembly | 12 | 30 | 8.8S | 3 | HARD | WASHERM12-HARD | 8.8-HEX | NUTM12-8.8-HEX | 0 | 0 | 14 | 3 | 12 | BOLTM12*30
4 x Bolt assembly | 12 | 35 | 8.8S | 2 | HARD | WASHERM12-HARD | 8.8-HEX | NUTM12-8.8-HEX | 4 | 8 | 14 | 2 | 12 | BOLTM12*35
20 x Bolt assembly | 12 | 30 | PB1230 | 4 | FLAT | WASHERM12-FLAT | 4.6-HEX | NUTM12-4.6-HEX | 4 | 8 | 14 | 4 | 12 | BOLTPB1230
Bolt assembly | 12 | 35 | 8.8S | 4 | HARD | WASHERM12-HARD | 8.8-HEX | NUTM12-8.8-HEX | 8 | 4 | 14 | 4 | 12 | BOLTM12*35
4 x Bolt assembly | 12 | 30 | PB1230 | 4 | FLAT | WASHERM12-FLAT | 4.6-HEX | NUTM12-4.6-HEX | 4 | 0 | 18 | 4 | 12 | BOLTPB1230
3 x Bolt assembly | 12 | 35 | 8.8S | 4 | HARD | WASHERM12-HARD | 8.8-HEX | NUTM12-8.8-HEX | 4 | 8 | 14 | 4 | 12 | BOLTM12*35
4 x Bolt assembly | 12 | 30 | 8.8S | 5 | HARD | WASHERM12-HARD | 8.8-HEX | NUTM12-8.8-HEX | 4 | 8 | 14 | 5 | 12 | BOLTM12*30
8 x Bolt assembly | 16 | 50 | 8.8S | 2 | HARD | WASHERM16-HARD | 8.8-HEX | NUTM16-8.8-HEX | 0 | 6 | 18 | 2 | 16 | BOLTM16*50
2 x Bolt assembly | 12 | 40 | 8.8S | 8 | HARD | WASHERM12-HARD | 8.8-HEX | NUTM12-8.8-HEX | 8 | 4 | 14 | 8 | 12 | BOLTM12*40
Bolt assembly | 12 | 30 | 8.8S | 6 | HARD | WASHERM12-HARD | 8.8-HEX | NUTM12-8.8-HEX | 4 | 8 | 14 | 6 | 12 | BOLTM12*30
Bolt assembly | 12 | 40 | 8.8S | 6 | HARD | WASHERM12-HARD | 8.8-HEX | NUTM12-8.8-HEX | 4 | 8 | 14 | 6 | 12 | BOLTM12*40
4 x Bolt assembly | 12 | 30 | 8.8S | 4 | HARD | WASHERM12-HARD | 8.8-HEX | NUTM12-8.8-HEX | 4 | 8 | 14 | 4 | 12 | BOLTM12*30
2 x Bolt assembly | 12 | 35 | 8.8S | 6 | HARD | WASHERM12-HARD | 8.8-HEX | NUTM12-8.8-HEX | 8 | 4 | 14 | 6 | 12 | BOLTM12*35
8 x Bolt assembly | 12 | 30 | 8.8S | 2 | HARD | WASHERM12-HARD | 8.8-HEX | NUTM12-8.8-HEX | 4 | 8 | 14 | 2 | 12 | BOLTM12*30

# IfcPlate: PLT3*152 (2)
In: Undefined
Description: PLT3*152; Material: STEEL/450
Default - ASSEMBLY_POS: Z/0(?)
Pset_PlateCommon - LoadBearing: no; Reference: Z/0(?)
Tekla Common - Bottom elevation: +3.283; Top elevation: +3.593; Phase: 1; Class: 9
Tekla Quantity - Weight: 1.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.4 m2; Net surface area: 0.1 m2; Height: 152 mm; Width: 3 mm; Length: 310 mm
BaseQuantities - Width: 152 mm; NetArea: 0.097012 m2; GrossArea: 0.04712 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00014136 m3; GrossVolume: 0.00014136 m3

# IfcPlate: PLT3*203 (2)
In: Undefined
Description: PLT3*203; Material: STEEL/450
Default - ASSEMBLY_POS: Z/0(?)
Tekla Common - Bottom elevation: +3.213; Top elevation: +3.593; Phase: 1; Class: 9
Tekla Quantity - Weight: 1.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.9 m2; Net surface area: 0.2 m2; Height: 203 mm; Width: 3 mm; Length: 380 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/0(?)
BaseQuantities - Width: 203 mm; NetArea: 0.157778 m2; GrossArea: 0.07714 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00023142 m3; GrossVolume: 0.00023142 m3

# IfcPlate: PLT3*219 (2)
In: Undefined
Description: PLT3*219; Material: STEEL/450
Default - ASSEMBLY_POS: Z/0(?)
Pset_PlateCommon - LoadBearing: no; Reference: Z/0(?)
Tekla Common - Bottom elevation: +3.333; Top elevation: +3.673; Phase: 1; Class: 11
Tekla Quantity - Weight: 2.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.2 m2; Net surface area: 0.2 m2; Height: 219 mm; Width: 3 mm; Length: 619.9 mm
BaseQuantities - Width: 219.005 mm; NetArea: 0.190058 m2; GrossArea: 0.135764 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000277593 m3; GrossVolume: 0.000277593 m3

# IfcPlate: PLT3*254 (2)
In: Undefined
Description: PLT3*254; Material: STEEL/450
Default - ASSEMBLY_POS: Z/0(?)
Pset_PlateCommon - LoadBearing: no; Reference: Z/0(?)
Tekla Common - Bottom elevation: +3.111; Top elevation: +3.541; Phase: 1; Class: 9
Tekla Quantity - Weight: 2.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.5 m2; Net surface area: 0.2 m2; Height: 254 mm; Width: 3 mm; Length: 430 mm
BaseQuantities - Width: 254 mm; NetArea: 0.222544 m2; GrossArea: 0.10922 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00032766 m3; GrossVolume: 0.00032766 m3

# IfcPlate: PLT3*300 (2)
In: Undefined
Description: PLT3*300; Material: STEEL/450
Default - ASSEMBLY_POS: Z/0(?)
Pset_PlateCommon - LoadBearing: no; Reference: Z/0(?)
Tekla Common - Bottom elevation: +3.012; Top elevation: +3.492; Phase: 1; Class: 9
Tekla Quantity - Weight: 3.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.3 m2; Height: 300 mm; Width: 3 mm; Length: 480 mm
BaseQuantities - Width: 300 mm; NetArea: 0.29268 m2; GrossArea: 0.144 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000432 m3; GrossVolume: 0.000432 m3

# IfcPlate: PLT3*350 (2)
In: Undefined
Description: PLT3*350; Material: STEEL/450
Default - ASSEMBLY_POS: Z/0(?)
Pset_PlateCommon - LoadBearing: no; Reference: Z/0(?)
Tekla Common - Bottom elevation: +2.911; Top elevation: +3.441; Phase: 1; Class: 9
Tekla Quantity - Weight: 4.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.1 m2; Net surface area: 0.3 m2; Height: 350 mm; Width: 3 mm; Length: 530 mm
BaseQuantities - Width: 350 mm; NetArea: 0.37628 m2; GrossArea: 0.1855 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.0005565 m3; GrossVolume: 0.0005565 m3

# IfcPlate: PLT3*476 (2)
In: Undefined
Description: PLT3*476; Material: STEEL/450
Tekla Common - Bottom elevation: +3.263; Top elevation: +3.723; Phase: 1; Class: 11
Tekla Quantity - Weight: 3.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.6 m2; Net surface area: 0.3 m2; Height: 476 mm; Width: 3 mm; Length: 632.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 475.995 mm; NetArea: 0.322026 m2; GrossArea: 0.301132 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000473607 m3; GrossVolume: 0.000473607 m3
Name | ASSEMBLY_POS = Reference
LEANTO BRACKET | Z/542(?)
LEANTO BRACKET | Z/545(?)

# IfcPlate: PLT3*575.9 (2)
In: Undefined
Description: PLT3*575.9; Material: STEEL/450
Tekla Common - Bottom elevation: +3.161; Top elevation: +3.721; Phase: 1; Class: 11
Tekla Quantity - Weight: 5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.3 m2; Height: 575.9 mm; Width: 3 mm; Length: 682.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 575.939 mm; NetArea: 0.430208 m2; GrossArea: 0.393162 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00063458 m3; GrossVolume: 0.00063458 m3
Name | ASSEMBLY_POS = Reference
LEANTO BRACKET | Z/585(?)
LEANTO BRACKET | Z/589(?)

# IfcPlate: PLT3*676.4 (2)
In: Undefined
Description: PLT3*676.4; Material: STEEL/450
Tekla Common - Bottom elevation: +3.062; Top elevation: +3.722; Phase: 1; Class: 11
Tekla Quantity - Weight: 6.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.1 m2; Net surface area: 0.6 m2; Height: 676.4 mm; Width: 3 mm; Length: 742.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 676.394 mm; NetArea: 0.560926 m2; GrossArea: 0.502312 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000829265 m3; GrossVolume: 0.000829265 m3
Name | ASSEMBLY_POS = Reference
LEANTO BRACKET | Z/627(?)
LEANTO BRACKET | Z/626(?)

# IfcPlate: PLT3*759.6 (2)
In: Undefined
Description: PLT3*759.6; Material: STEEL/450
Tekla Common - Bottom elevation: +2.961; Top elevation: +3.720; Phase: 1; Class: 11
Tekla Quantity - Weight: 8.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.6 m2; Height: 759.6 mm; Width: 3 mm; Length: 824.2 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 759.588 mm; GrossArea: 0.626051 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.0010555 m3; GrossVolume: 0.0010555 m3
Name | ASSEMBLY_POS = Reference | NetArea (m2)
LEANTO BRACKET | Z/663(?) | 0.712704
LEANTO BRACKET | Z/660(?) | 0.712705
