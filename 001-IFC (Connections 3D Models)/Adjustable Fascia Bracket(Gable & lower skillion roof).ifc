Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView_V2.0, QuantityTakeOffAddOnView], Option [BaseQuantities:On], Option [GridExport:On], Option [Assemblies:On], Option [Bolts:On], Option [Rebars:On], Option [PourObjects:Off], Option [Welds:Off], Option [SurfaceTreatments:Off], Option [LocationBy:0], Option [ViewColors:Off], Option [SectionedSpine:Off], Option [PropertySets:On], Option [Export all:Off]
File name: Adjustable Fascia Bracket(Gable & lower skillion roof).ifc
Time: 2026-07-14T15:24:07
Author: DESKTOP-BKNQL56\admin
Organization: Structural Designer
Written by: IFC Database Version: Work
Made in: Tekla Structures 2019 Service Pack 13, IFC Export Version: 4.0.0.0 Oct 18 2021

# IfcBuildingStorey, Undefined
In: Undefined
Elevation: 0 mm

# IfcBeam: C:100-15 (3)
In: Undefined
Description: C:100-15; Material: STEEL/300PLUS
Default - ASSEMBLY_POS: Z/1653
Tekla Common - Phase: 1; Class: 13
Tekla Quantity - Weight: 18.4 kg; Volume: 0 m3; Gross footprint area: 0.5 m2; Area per tons: 178.7 m2; Net surface area: 3.3 m2; Height: 102 mm; Width: 51 mm; Length: 7262.5 mm
Pset_BeamCommon - LoadBearing: no; Reference: Z/1653
BaseQuantities - Length: 7262.5 mm; OuterSurfaceArea: 3.29059 m2; NetVolume: 0.00245109 m3; NetWeight: 19.2411 kg
Name | Bottom elevation | Top elevation
FASCIA | +3.027 | +3.129
FASCIA | +3.995 | +4.097
FASCIA | +4.963 | +5.065

# IfcBeam: C:150-15 (3)
In: Undefined
Description: C:150-15; Material: STEEL/300PLUS
Default - ASSEMBLY_POS: Z/1652
Tekla Common - Phase: 1; Class: 13
Tekla Quantity - Weight: 25.3 kg; Volume: 0 m3; Gross footprint area: 0.5 m2; Area per tons: 176.3 m2; Net surface area: 4.4 m2; Height: 152 mm; Width: 64 mm; Length: 7262.5 mm
Pset_BeamCommon - LoadBearing: no; Reference: Z/1652
BaseQuantities - Length: 7262.5 mm; OuterSurfaceArea: 4.45283 m2; NetVolume: 0.00332259 m3; NetWeight: 26.0824 kg
Name | Bottom elevation | Top elevation
FASCIA | +2.977 | +3.129
FASCIA | +3.945 | +4.097
FASCIA | +4.913 | +5.065

# IfcBeam: C:150-24 (3)
In: Undefined
Description: C:150-24; Material: STEEL/G450
Tekla Common - Finish: 25 deg; Bottom elevation: +0.000; Top elevation: +5.050; Phase: 1; Class: 10
Default - ASSEMBLY_POS: Z/319
Tekla Quantity - Weight: 28.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 111.2 m2; Net surface area: 3.1 m2; Height: 152 mm; Width: 64 mm; Length: 5050.1 mm
Pset_BeamCommon - LoadBearing: no; Reference: Z/319
BaseQuantities - Length: 5050.09 mm; OuterSurfaceArea: 3.13051 m2; NetVolume: 0.00372575 m3; NetWeight: 29.2472 kg

# IfcBeam: C:200-15 (3)
In: Undefined
Description: C:200-15; Material: STEEL/300PLUS
Default - ASSEMBLY_POS: Z/1651
Tekla Common - Phase: 1; Class: 13
Tekla Quantity - Weight: 31.6 kg; Volume: 0 m3; Gross footprint area: 0.6 m2; Area per tons: 175.2 m2; Net surface area: 5.5 m2; Height: 203 mm; Width: 76 mm; Length: 7262.5 mm
Pset_BeamCommon - LoadBearing: no; Reference: Z/1651
BaseQuantities - Length: 7262.5 mm; OuterSurfaceArea: 5.54243 m2; NetVolume: 0.00413963 m3; NetWeight: 32.4961 kg
Name | Bottom elevation | Top elevation
FASCIA | +2.926 | +3.129
FASCIA | +3.894 | +4.097
FASCIA | +4.862 | +5.065

# IfcBeam: C:200-24 (3)
In: Undefined
Description: C:200-24; Material: STEEL/G450
Tekla Common - Finish: 25 deg; Bottom elevation: +0.000; Top elevation: +5.050; Phase: 1; Class: 10
Default - ASSEMBLY_POS: Z/330
Tekla Quantity - Weight: 35.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 109.9 m2; Net surface area: 3.9 m2; Height: 203 mm; Width: 76 mm; Length: 5050.1 mm
Pset_BeamCommon - LoadBearing: no; Reference: Z/330
BaseQuantities - Length: 5050.09 mm; OuterSurfaceArea: 3.93891 m2; NetVolume: 0.00469537 m3; NetWeight: 36.8587 kg

# IfcBeam: C:250-24 (3)
In: Undefined
Description: C:250-24; Material: STEEL/G450
Tekla Common - Finish: 25 deg; Bottom elevation: +0.000; Top elevation: +5.050; Phase: 1; Class: 10
Default - ASSEMBLY_POS: Z/340
Tekla Quantity - Weight: 40.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 109.7 m2; Net surface area: 4.4 m2; Height: 254 mm; Width: 76 mm; Length: 5050.1 mm
Pset_BeamCommon - LoadBearing: no; Reference: Z/340
BaseQuantities - Length: 5050.08 mm; OuterSurfaceArea: 4.44415 m2; NetVolume: 0.00530137 m3; NetWeight: 41.6158 kg

# IfcBeam: C:300-30 (3)
In: Undefined
Description: C:300-30; Material: STEEL/G450
Tekla Common - Finish: 25 deg; Bottom elevation: +0.000; Top elevation: +5.050; Phase: 1; Class: 10
Default - ASSEMBLY_POS: Z/1520
Tekla Quantity - Weight: 63.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.4 m2; Net surface area: 5.5 m2; Height: 300 mm; Width: 96 mm; Length: 5050.1 mm
Pset_BeamCommon - LoadBearing: no; Reference: Z/1520
BaseQuantities - Length: 5050.09 mm; OuterSurfaceArea: 5.51796 m2; NetVolume: 0.0082266 m3; NetWeight: 64.5788 kg

# IfcBeam: C:350-30 (3)
In: Undefined
Description: C:350-30; Material: STEEL/G450
Default - ASSEMBLY_POS: Z/1643
Tekla Common - Finish: 25 deg; Bottom elevation: +0.000; Top elevation: +5.050; Phase: 1; Class: 10
Tekla Quantity - Weight: 75.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.1 m2; Net surface area: 6.6 m2; Height: 350 mm; Width: 125 mm; Length: 5050.1 mm
Pset_BeamCommon - LoadBearing: no; Reference: Z/1643
BaseQuantities - Length: 5050.09 mm; OuterSurfaceArea: 6.5791 m2; NetVolume: 0.00981737 m3; NetWeight: 77.0663 kg

# IfcBeam: Z:100-15 (6)
In: Undefined
Description: Z:100-15
Tekla Common - Phase: 1; Class: 4
Tekla Quantity - Volume: 0 m3; Area per tons: 179 m2; Net surface area: 3.4 m2; Height: 102 mm; Width: 100.5 mm
Pset_BeamCommon - LoadBearing: no
Name | Material | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Gross footprint area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
3 x PURLIN | STEEL/300PLUS | B/33 | +5.477 | +5.612 | 19 | 0 | 7500 | 3.39817 | 0.00253125 | 19.8703
3 x GIRT | STEEL/G450 | B/37 | +4.524 | +4.625 | 19.1 | 0.1 | 7550 | 3.42082 | 0.00254813 | 20.0028

# IfcBeam: Z:150-15 (6)
In: Undefined
Description: Z:150-15
Tekla Common - Phase: 1; Class: 4
Tekla Quantity - Volume: 0 m3; Area per tons: 176.5 m2; Net surface area: 4.6 m2; Height: 152 mm; Width: 124.5 mm
Pset_BeamCommon - LoadBearing: no
Name | Material | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Gross footprint area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
3 x PURLIN | STEEL/300PLUS | B/32 | +4.472 | +4.663 | 26.1 | 0 | 7500 | 4.59841 | 0.00343125 | 26.9353
3 x GIRT | STEEL/G450 | B/36 | +3.512 | +3.637 | 26.2 | 0.1 | 7550 | 4.62906 | 0.00345413 | 27.1149

# IfcBeam: Z:200-15 (6)
In: Undefined
Description: Z:200-15
Tekla Common - Phase: 1; Class: 4
Tekla Quantity - Volume: 0 m3; Area per tons: 175.2 m2; Height: 203 mm; Width: 151.5 mm
Pset_BeamCommon - LoadBearing: no
Name | Material | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Gross footprint area (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
3 x PURLIN | STEEL/300PLUS | B/10 | +3.467 | +3.715 | 32.7 | 0 | 5.7 | 7500 | 5.72364 | 0.004275 | 33.5587
3 x GIRT | STEEL/G450 | B/34 | +2.499 | +2.651 | 32.9 | 0.1 | 5.8 | 7550 | 5.76179 | 0.0043035 | 33.7825

# IfcColumn: C:150-24 (3)
In: Undefined
Description: C:150-24; Material: STEEL/G450
Tekla Common - Finish: 25 deg; Bottom elevation: +0.000; Top elevation: +5.050; Phase: 1; Class: 10
Default - ASSEMBLY_POS: Z/319
Tekla Quantity - Weight: 28.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 111.2 m2; Net surface area: 3.1 m2; Height: 152 mm; Width: 64 mm; Length: 5050.1 mm
BaseQuantities - Length: 5050.09 mm; OuterSurfaceArea: 3.13051 m2; NetVolume: 0.00372575 m3; NetWeight: 29.2472 kg
Pset_ColumnCommon - LoadBearing: no; Reference: Z/319

# IfcColumn: C:200-24 (3)
In: Undefined
Description: C:200-24; Material: STEEL/G450
Tekla Common - Finish: 25 deg; Bottom elevation: +0.000; Top elevation: +5.050; Phase: 1; Class: 10
Default - ASSEMBLY_POS: Z/330
Tekla Quantity - Weight: 35.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 109.9 m2; Net surface area: 3.9 m2; Height: 203 mm; Width: 76 mm; Length: 5050.1 mm
BaseQuantities - Length: 5050.09 mm; OuterSurfaceArea: 3.93891 m2; NetVolume: 0.00469537 m3; NetWeight: 36.8587 kg
Pset_ColumnCommon - LoadBearing: no; Reference: Z/330

# IfcColumn: C:250-24 (3)
In: Undefined
Description: C:250-24; Material: STEEL/G450
Tekla Common - Finish: 25 deg; Bottom elevation: +0.000; Top elevation: +5.050; Phase: 1; Class: 10
Default - ASSEMBLY_POS: Z/340
Tekla Quantity - Weight: 40.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 109.7 m2; Net surface area: 4.4 m2; Height: 254 mm; Width: 76 mm; Length: 5050.1 mm
BaseQuantities - Length: 5050.08 mm; OuterSurfaceArea: 4.44415 m2; NetVolume: 0.00530137 m3; NetWeight: 41.6158 kg
Pset_ColumnCommon - LoadBearing: no; Reference: Z/340

# IfcColumn: C:300-30 (3)
In: Undefined
Description: C:300-30; Material: STEEL/G450
Tekla Common - Finish: 25 deg; Bottom elevation: +0.000; Top elevation: +5.050; Phase: 1; Class: 10
Default - ASSEMBLY_POS: Z/1520
Tekla Quantity - Weight: 63.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.4 m2; Net surface area: 5.5 m2; Height: 300 mm; Width: 96 mm; Length: 5050.1 mm
BaseQuantities - Length: 5050.09 mm; OuterSurfaceArea: 5.51796 m2; NetVolume: 0.0082266 m3; NetWeight: 64.5788 kg
Pset_ColumnCommon - LoadBearing: no; Reference: Z/1520

# IfcColumn: C:350-30 (3)
In: Undefined
Description: C:350-30; Material: STEEL/G450
Default - ASSEMBLY_POS: Z/1643
Tekla Common - Finish: 25 deg; Bottom elevation: +0.000; Top elevation: +5.050; Phase: 1; Class: 10
Tekla Quantity - Weight: 75.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.1 m2; Net surface area: 6.6 m2; Height: 350 mm; Width: 125 mm; Length: 5050.1 mm
BaseQuantities - Length: 5050.09 mm; OuterSurfaceArea: 6.5791 m2; NetVolume: 0.00981737 m3; NetWeight: 77.0663 kg
Pset_ColumnCommon - LoadBearing: no; Reference: Z/1643

# IfcElementAssembly (327)
In: Undefined
PredefinedType: RIGID_FRAME
Name | ASSEMBLY_POSITION_CODE = Assembly/Cast unit position code | ASSEMBLY_POS = Assembly/Cast unit Mark | Assembly/Cast unit weight (kg) | Assembly/Cast unit bottom elevation | Assembly/Cast unit top elevation | Width (mm)
FASCIA | C150AF-C350AF>/Gable roof | Z/1653 | 18.4 | +3.027 | +3.129 | 51
FASCIA | C150AF-C350AF>/Gable roof | Z/1653 | 18.4 | +3.995 | +4.097 | 51
FASCIA | C150AF-C350AF>/Gable roof | Z/1653 | 18.4 | +4.963 | +5.065 | 51
FASCIA | C150AF-C350AF>/Gable roof | Z/1652 | 25.3 | +2.977 | +3.129 | 64
FASCIA | C150AF-C350AF>/Gable roof | Z/1652 | 25.3 | +3.945 | +4.097 | 64
FASCIA | C150AF-C350AF>/Gable roof | Z/1652 | 25.3 | +4.913 | +5.065 | 64
FASCIA | C150AF-C350AF>/Gable roof | Z/1651 | 31.6 | +2.926 | +3.129 | 76
FASCIA | C150AF-C350AF>/Gable roof | Z/1651 | 31.6 | +3.894 | +4.097 | 76
FASCIA | C150AF-C350AF>/Gable roof | Z/1651 | 31.6 | +4.862 | +5.065 | 76
ADJUSTABLE FASCIA BRA | C350AF>/Gable roof | PL/1666 | 2.4 | +2.823 | +3.058 | 133
ADJUSTABLE FASCIA BRA | C350AF>/Gable roof | PL/1669 | 1.9 | +3.845 | +4.025 | 133
ADJUSTABLE FASCIA BRA | C350AF>/Gable roof | PL/1670 | 1.4 | +4.858 | +4.993 | 133
2 x RAFTER | C350AF>/Gable roof-Gable roof | Z/1644 | 15 | +2.850 | +3.590 | 125
2 x RAFTER | C350AF>/Gable roof-Gable roof | Z/1644 | 15 | +3.850 | +4.590 | 125
2 x RAFTER | C350AF>/Gable roof-Gable roof | Z/1644 | 15 | +4.850 | +5.590 | 125
3 x COLUMN | C350AF>/Gable roof | Z/1643 | 75.5 | +0.000 | +5.050 | 125
ADJUSTABLE FASCIA BRA | C350AF>/Gable roof | PL/1666 | 2.4 | +2.848 | +3.083 | 133
ADJUSTABLE FASCIA BRA | C350AF>/Gable roof | PL/1669 | 1.9 | +3.871 | +4.051 | 133
ADJUSTABLE FASCIA BRA | C350AF>/Gable roof | PL/1670 | 1.4 | +4.884 | +5.019 | 133
ADJUSTABLE FASCIA BRA | C350AF>/Gable roof | PL/1666 | 2.4 | +2.873 | +3.108 | 133
ADJUSTABLE FASCIA BRA | C350AF>/Gable roof | PL/1669 | 1.9 | +3.896 | +4.076 | 133
ADJUSTABLE FASCIA BRA | C350AF>/Gable roof | PL/1670 | 1.4 | +4.909 | +5.044 | 133
RAFTER | C350AF>/Gable roof> | Z/1644 | 15 | +2.850 | +3.590 | 125
RAFTER | C350AF>/Gable roof> | Z/1644 | 15 | +3.850 | +4.590 | 125
RAFTER | C350AF>/Gable roof> | Z/1644 | 15 | +4.850 | +5.590 | 125
2 x PLATE | C350AF>/Gable roof-Gable roof | Z/1656 | 11.8 | +2.577 | +3.345 | 128
2 x PLATE | C350AF>/Gable roof-Gable roof | Z/1656 | 11.8 | +3.577 | +4.345 | 128
2 x PLATE | C350AF>/Gable roof-Gable roof | Z/1656 | 11.8 | +4.577 | +5.345 | 128
PLATE | C350AF>/Gable roof> | Z/1656 | 11.8 | +2.577 | +3.345 | 128
PLATE | C350AF>/Gable roof> | Z/1656 | 11.8 | +3.577 | +4.345 | 128
PLATE | C350AF>/Gable roof> | Z/1656 | 11.8 | +4.577 | +5.345 | 128
ADJUSTABLE FASCIA BRA | C300AF-C350AF/Gable roof | PL/755 | 2.1 | +2.823 | +3.058 | 125
ADJUSTABLE FASCIA BRA | C300AF-C350AF/Gable roof | PL/756 | 1.7 | +3.845 | +4.025 | 125
ADJUSTABLE FASCIA BRA | C300AF-C350AF/Gable roof | PL/1665 | 1.3 | +4.858 | +4.993 | 125
2 x RAFTER | C300AF-C350AF/Gable roof-Gable roof | Z/1522 | 12.5 | +2.872 | +3.567 | 96
2 x RAFTER | C300AF-C350AF/Gable roof-Gable roof | Z/1522 | 12.5 | +3.872 | +4.567 | 96
2 x RAFTER | C300AF-C350AF/Gable roof-Gable roof | Z/1522 | 12.5 | +4.872 | +5.567 | 96
3 x COLUMN | C300AF-C350AF/Gable roof | Z/1520 | 63.2 | +0.000 | +5.050 | 96
ADJUSTABLE FASCIA BRA | C300AF-C350AF/Gable roof | PL/755 | 2.1 | +2.848 | +3.083 | 125
ADJUSTABLE FASCIA BRA | C300AF-C350AF/Gable roof | PL/756 | 1.7 | +3.871 | +4.051 | 125
ADJUSTABLE FASCIA BRA | C300AF-C350AF/Gable roof | PL/1665 | 1.3 | +4.884 | +5.019 | 125
ADJUSTABLE FASCIA BRA | C300AF-C350AF/Gable roof | PL/755 | 2.1 | +2.873 | +3.108 | 125
ADJUSTABLE FASCIA BRA | C300AF-C350AF/Gable roof | PL/756 | 1.7 | +3.896 | +4.076 | 125
ADJUSTABLE FASCIA BRA | C300AF-C350AF/Gable roof | PL/1665 | 1.3 | +4.909 | +5.044 | 125
RAFTER | C300AF-C350AF/Gable roof> | Z/1522 | 12.5 | +2.872 | +3.567 | 96
RAFTER | C300AF-C350AF/Gable roof> | Z/1522 | 12.5 | +3.872 | +4.567 | 96
RAFTER | C300AF-C350AF/Gable roof> | Z/1522 | 12.5 | +4.872 | +5.567 | 96
2 x PLATE | C300AF-C350AF/Gable roof-Gable roof | Z/1655 | 10.1 | +2.577 | +3.322 | 99
2 x PLATE | C300AF-C350AF/Gable roof-Gable roof | Z/1655 | 10.1 | +3.577 | +4.322 | 99
2 x PLATE | C300AF-C350AF/Gable roof-Gable roof | Z/1655 | 10.1 | +4.577 | +5.322 | 99
PLATE | C300AF-C350AF/Gable roof> | Z/1655 | 10.1 | +2.577 | +3.322 | 99
PLATE | C300AF-C350AF/Gable roof> | Z/1655 | 10.1 | +3.577 | +4.322 | 99
PLATE | C300AF-C350AF/Gable roof> | Z/1655 | 10.1 | +4.577 | +5.322 | 99
ADJUSTABLE FASCIA BRA | C250AF-C300AF/Gable roof | PL/752 | 1.7 | +2.823 | +3.058 | 105
ADJUSTABLE FASCIA BRA | C250AF-C300AF/Gable roof | PL/753 | 1.4 | +3.845 | +4.025 | 105
ADJUSTABLE FASCIA BRA | C250AF-C300AF/Gable roof | PL/754 | 1.1 | +4.858 | +4.993 | 105
2 x RAFTER | C250AF-C300AF/Gable roof-Gable roof | Z/341 | 8 | +2.893 | +3.545 | 76
2 x RAFTER | C250AF-C300AF/Gable roof-Gable roof | Z/341 | 8 | +3.893 | +4.545 | 76
2 x RAFTER | C250AF-C300AF/Gable roof-Gable roof | Z/341 | 8 | +4.893 | +5.545 | 76
3 x COLUMN | C250AF-C300AF/Gable roof | Z/340 | 40.5 | +0.000 | +5.050 | 76
ADJUSTABLE FASCIA BRA | C250AF-C300AF/Gable roof | PL/752 | 1.7 | +2.848 | +3.083 | 105
ADJUSTABLE FASCIA BRA | C250AF-C300AF/Gable roof | PL/753 | 1.4 | +3.871 | +4.051 | 105
ADJUSTABLE FASCIA BRA | C250AF-C300AF/Gable roof | PL/754 | 1.1 | +4.884 | +5.019 | 105
ADJUSTABLE FASCIA BRA | C250AF-C300AF/Gable roof | PL/752 | 1.7 | +2.873 | +3.108 | 105
ADJUSTABLE FASCIA BRA | C250AF-C300AF/Gable roof | PL/753 | 1.4 | +3.896 | +4.076 | 105
ADJUSTABLE FASCIA BRA | C250AF-C300AF/Gable roof | PL/754 | 1.1 | +4.909 | +5.044 | 105
RAFTER | C250AF-C300AF/Gable roof> | Z/341 | 8 | +2.893 | +3.545 | 76
RAFTER | C250AF-C300AF/Gable roof> | Z/341 | 8 | +3.893 | +4.545 | 76
RAFTER | C250AF-C300AF/Gable roof> | Z/341 | 8 | +4.893 | +5.545 | 76
2 x PLATE | C250AF-C300AF/Gable roof-Gable roof | Z/1654 | 6.1 | +2.692 | +3.252 | 79
2 x PLATE | C250AF-C300AF/Gable roof-Gable roof | Z/1654 | 6.1 | +3.692 | +4.252 | 79
2 x PLATE | C250AF-C300AF/Gable roof-Gable roof | Z/1654 | 6.1 | +4.692 | +5.252 | 79
PLATE | C250AF-C300AF/Gable roof> | Z/1654 | 6.1 | +2.692 | +3.252 | 79
PLATE | C250AF-C300AF/Gable roof> | Z/1654 | 6.1 | +3.692 | +4.252 | 79
PLATE | C250AF-C300AF/Gable roof> | Z/1654 | 6.1 | +4.692 | +5.252 | 79
ADJUSTABLE FASCIA BRA | C200AF-C250AF/Gable roof | PL/749 | 1.4 | +2.823 | +3.058 | 105
ADJUSTABLE FASCIA BRA | C200AF-C250AF/Gable roof | PL/750 | 1.3 | +3.845 | +4.025 | 105
ADJUSTABLE FASCIA BRA | C200AF-C250AF/Gable roof | PL/751 | 0.9 | +4.858 | +4.993 | 105
2 x RAFTER | C200AF-C250AF/Gable roof-Gable roof | Z/331 | 7.1 | +2.915 | +3.522 | 76
2 x RAFTER | C200AF-C250AF/Gable roof-Gable roof | Z/331 | 7.1 | +3.915 | +4.522 | 76
2 x RAFTER | C200AF-C250AF/Gable roof-Gable roof | Z/331 | 7.1 | +4.915 | +5.522 | 76
3 x COLUMN | C200AF-C250AF/Gable roof | Z/330 | 35.8 | +0.000 | +5.050 | 76
ADJUSTABLE FASCIA BRA | C200AF-C250AF/Gable roof | PL/749 | 1.4 | +2.848 | +3.083 | 105
ADJUSTABLE FASCIA BRA | C200AF-C250AF/Gable roof | PL/750 | 1.3 | +3.871 | +4.051 | 105
ADJUSTABLE FASCIA BRA | C200AF-C250AF/Gable roof | PL/751 | 0.9 | +4.884 | +5.019 | 105
ADJUSTABLE FASCIA BRA | C200AF-C250AF/Gable roof | PL/749 | 1.4 | +2.873 | +3.108 | 105
ADJUSTABLE FASCIA BRA | C200AF-C250AF/Gable roof | PL/750 | 1.3 | +3.896 | +4.076 | 105
ADJUSTABLE FASCIA BRA | C200AF-C250AF/Gable roof | PL/751 | 0.9 | +4.909 | +5.044 | 105
RAFTER | C200AF-C250AF/Gable roof> | Z/331 | 7.1 | +2.915 | +3.522 | 76
RAFTER | C200AF-C250AF/Gable roof> | Z/331 | 7.1 | +3.915 | +4.522 | 76
RAFTER | C200AF-C250AF/Gable roof> | Z/331 | 7.1 | +4.915 | +5.522 | 76
2 x PLATE | C200AF-C250AF/Gable roof-Gable roof | Z/1650 | 3.7 | +2.775 | +3.192 | 79
2 x PLATE | C200AF-C250AF/Gable roof-Gable roof | Z/1650 | 3.7 | +3.775 | +4.192 | 79
2 x PLATE | C200AF-C250AF/Gable roof-Gable roof | Z/1650 | 3.7 | +4.775 | +5.192 | 79
PLATE | C200AF-C250AF/Gable roof> | Z/1650 | 3.7 | +2.775 | +3.192 | 79
PLATE | C200AF-C250AF/Gable roof> | Z/1650 | 3.7 | +3.775 | +4.192 | 79
PLATE | C200AF-C250AF/Gable roof> | Z/1650 | 3.7 | +4.775 | +5.192 | 79
ADJUSTABLE FASCIA BRA | C150AF-C200AF/Gable roof | PL/746 | 1.3 | +2.823 | +3.058 | 105
ADJUSTABLE FASCIA BRA | C150AF-C200AF/Gable roof | PL/747 | 0.9 | +3.845 | +4.025 | 105
2 x RAFTER | C150AF-C200AF/Gable roof-Gable roof | Z/320 | 5.6 | +2.937 | +3.498 | 64
2 x RAFTER | C150AF-C200AF/Gable roof-Gable roof | Z/320 | 5.6 | +3.937 | +4.498 | 64
ADJUSTABLE FASCIA BRA | C150AF-C200AF/Gable roof | PL/748 | 0.9 | +4.858 | +4.993 | 105
2 x RAFTER | C150AF-C200AF/Gable roof-Gable roof | Z/320 | 5.6 | +4.937 | +5.498 | 64
3 x COLUMN | C150AF-C200AF/Gable roof | Z/319 | 28.1 | +0.000 | +5.050 | 64
ADJUSTABLE FASCIA BRA | C150AF-C200AF/Gable roof | PL/746 | 1.3 | +2.848 | +3.083 | 105
ADJUSTABLE FASCIA BRA | C150AF-C200AF/Gable roof | PL/747 | 0.9 | +3.871 | +4.051 | 105
ADJUSTABLE FASCIA BRA | C150AF-C200AF/Gable roof | PL/748 | 0.9 | +4.884 | +5.019 | 105
ADJUSTABLE FASCIA BRA | C150AF-C200AF/Gable roof | PL/746 | 1.3 | +2.873 | +3.108 | 105
ADJUSTABLE FASCIA BRA | C150AF-C200AF/Gable roof | PL/747 | 0.9 | +3.896 | +4.076 | 105
RAFTER | C150AF-C200AF/Gable roof> | Z/320 | 5.6 | +2.937 | +3.498 | 64
RAFTER | C150AF-C200AF/Gable roof> | Z/320 | 5.6 | +3.937 | +4.498 | 64
ADJUSTABLE FASCIA BRA | C150AF-C200AF/Gable roof | PL/748 | 0.9 | +4.909 | +5.044 | 105
RAFTER | C150AF-C200AF/Gable roof> | Z/320 | 5.6 | +4.937 | +5.498 | 64
3 x PLATE | C150AF-C200AF/Gable roof | Z/1649 | 2.9 | +2.777 | +3.168 | 67
3 x PLATE | C150AF-C200AF/Gable roof | Z/1649 | 2.9 | +3.777 | +4.168 | 67
3 x PLATE | C150AF-C200AF/Gable roof | Z/1649 | 2.9 | +4.777 | +5.168 | 67
ADJUSTABLE FASCIA BRA | C350AF/Gable roof | PL/743 | 2.4 | +2.823 | +3.058 | 133
ADJUSTABLE FASCIA BRA | C350AF/Gable roof | PL/744 | 1.9 | +3.845 | +4.025 | 133
ADJUSTABLE FASCIA BRA | C350AF/Gable roof | PL/745 | 1.4 | +4.858 | +4.993 | 133
2 x RAFTER | C350AF/Gable roof-Gable roof | Z/1644 | 15 | +2.850 | +3.590 | 125
2 x RAFTER | C350AF/Gable roof-Gable roof | Z/1644 | 15 | +3.850 | +4.590 | 125
ADJUSTABLE FASCIA BRA | C300AF/Gable roof | PL/737 | 2.1 | +2.823 | +3.058 | 125
ADJUSTABLE FASCIA BRA | C300AF/Gable roof | PL/738 | 1.7 | +3.845 | +4.025 | 125
ADJUSTABLE FASCIA BRA | C300AF/Gable roof | PL/739 | 1.3 | +4.858 | +4.993 | 125
2 x RAFTER | C300AF/Gable roof-Gable roof | Z/1522 | 12.5 | +2.872 | +3.567 | 96
2 x RAFTER | C300AF/Gable roof-Gable roof | Z/1522 | 12.5 | +3.872 | +4.567 | 96
ADJUSTABLE FASCIA BRA | C250AF/Gable roof | PL/700 | 1.7 | +2.823 | +3.058 | 105
ADJUSTABLE FASCIA BRA | C250AF/Gable roof | PL/701 | 1.4 | +3.845 | +4.025 | 105
ADJUSTABLE FASCIA BRA | C250AF/Gable roof | PL/702 | 1.1 | +4.858 | +4.993 | 105
2 x RAFTER | C250AF/Gable roof-Gable roof | Z/341 | 8 | +2.893 | +3.545 | 76
2 x RAFTER | C250AF/Gable roof-Gable roof | Z/341 | 8 | +3.893 | +4.545 | 76
ADJUSTABLE FASCIA BRA | C200AF/Gable roof | PL/138 | 1.4 | +2.823 | +3.058 | 105
ADJUSTABLE FASCIA BRA | C200AF/Gable roof | PL/139 | 1.3 | +3.845 | +4.025 | 105
ADJUSTABLE FASCIA BRA | C200AF/Gable roof | PL/140 | 0.9 | +4.858 | +4.993 | 105
2 x RAFTER | C200AF/Gable roof-Gable roof | Z/331 | 7.1 | +2.915 | +3.522 | 76
2 x RAFTER | C200AF/Gable roof-Gable roof | Z/331 | 7.1 | +3.915 | +4.522 | 76
ADJUSTABLE FASCIA BRA | C150AF/Gable roof | PL/132 | 1.3 | +2.823 | +3.058 | 105
ADJUSTABLE FASCIA BRA | C150AF/Gable roof | PL/133 | 0.9 | +3.845 | +4.025 | 105
2 x RAFTER | C150AF/Gable roof-Gable roof | Z/320 | 5.6 | +2.937 | +3.498 | 64
2 x RAFTER | C150AF/Gable roof-Gable roof | Z/320 | 5.6 | +3.937 | +4.498 | 64
ADJUSTABLE FASCIA BRA | C150AF/Gable roof | PL/134 | 0.9 | +4.858 | +4.993 | 105
2 x RAFTER | C350AF/Gable roof-Gable roof | Z/1644 | 15 | +4.850 | +5.590 | 125
3 x COLUMN | C350AF/Gable roof | Z/1643 | 75.5 | +0.000 | +5.050 | 125
2 x RAFTER | C300AF/Gable roof-Gable roof | Z/1522 | 12.5 | +4.872 | +5.567 | 96
3 x COLUMN | C300AF/Gable roof | Z/1520 | 63.2 | +0.000 | +5.050 | 96
2 x RAFTER | C250AF/Gable roof-Gable roof | Z/341 | 8 | +4.893 | +5.545 | 76
3 x COLUMN | C250AF/Gable roof | Z/340 | 40.5 | +0.000 | +5.050 | 76
2 x RAFTER | C200AF/Gable roof-Gable roof | Z/331 | 7.1 | +4.915 | +5.522 | 76
3 x COLUMN | C200AF/Gable roof | Z/330 | 35.8 | +0.000 | +5.050 | 76
2 x RAFTER | C150AF/Gable roof-Gable roof | Z/320 | 5.6 | +4.937 | +5.498 | 64
3 x COLUMN | C150AF/Gable roof | Z/319 | 28.1 | +0.000 | +5.050 | 64
ADJUSTABLE FASCIA BRA | C350AF/Gable roof | PL/743 | 2.4 | +2.848 | +3.083 | 133
ADJUSTABLE FASCIA BRA | C350AF/Gable roof | PL/744 | 1.9 | +3.871 | +4.051 | 133
ADJUSTABLE FASCIA BRA | C350AF/Gable roof | PL/745 | 1.4 | +4.884 | +5.019 | 133
ADJUSTABLE FASCIA BRA | C300AF/Gable roof | PL/737 | 2.1 | +2.848 | +3.083 | 125
ADJUSTABLE FASCIA BRA | C300AF/Gable roof | PL/738 | 1.7 | +3.871 | +4.051 | 125
ADJUSTABLE FASCIA BRA | C300AF/Gable roof | PL/739 | 1.3 | +4.884 | +5.019 | 125
ADJUSTABLE FASCIA BRA | C250AF/Gable roof | PL/700 | 1.7 | +2.848 | +3.083 | 105
ADJUSTABLE FASCIA BRA | C250AF/Gable roof | PL/701 | 1.4 | +3.871 | +4.051 | 105
ADJUSTABLE FASCIA BRA | C250AF/Gable roof | PL/702 | 1.1 | +4.884 | +5.019 | 105
ADJUSTABLE FASCIA BRA | C200AF/Gable roof | PL/138 | 1.4 | +2.848 | +3.083 | 105
ADJUSTABLE FASCIA BRA | C200AF/Gable roof | PL/139 | 1.3 | +3.871 | +4.051 | 105
ADJUSTABLE FASCIA BRA | C200AF/Gable roof | PL/140 | 0.9 | +4.884 | +5.019 | 105
ADJUSTABLE FASCIA BRA | C150AF/Gable roof | PL/132 | 1.3 | +2.848 | +3.083 | 105
ADJUSTABLE FASCIA BRA | C150AF/Gable roof | PL/133 | 0.9 | +3.871 | +4.051 | 105
ADJUSTABLE FASCIA BRA | C150AF/Gable roof | PL/134 | 0.9 | +4.884 | +5.019 | 105
ADJUSTABLE FASCIA BRA | C350AF/Gable roof | PL/743 | 2.4 | +2.873 | +3.108 | 133
ADJUSTABLE FASCIA BRA | C350AF/Gable roof | PL/744 | 1.9 | +3.896 | +4.076 | 133
ADJUSTABLE FASCIA BRA | C350AF/Gable roof | PL/745 | 1.4 | +4.909 | +5.044 | 133
RAFTER | C350AF/Gable roof> | Z/1644 | 15 | +2.850 | +3.590 | 125
RAFTER | C350AF/Gable roof> | Z/1644 | 15 | +3.850 | +4.590 | 125
ADJUSTABLE FASCIA BRA | C300AF/Gable roof | PL/737 | 2.1 | +2.873 | +3.108 | 125
ADJUSTABLE FASCIA BRA | C300AF/Gable roof | PL/738 | 1.7 | +3.896 | +4.076 | 125
ADJUSTABLE FASCIA BRA | C300AF/Gable roof | PL/739 | 1.3 | +4.909 | +5.044 | 125
RAFTER | C300AF/Gable roof> | Z/1522 | 12.5 | +2.872 | +3.567 | 96
RAFTER | C300AF/Gable roof> | Z/1522 | 12.5 | +3.872 | +4.567 | 96
ADJUSTABLE FASCIA BRA | C250AF/Gable roof | PL/700 | 1.7 | +2.873 | +3.108 | 105
ADJUSTABLE FASCIA BRA | C250AF/Gable roof | PL/701 | 1.4 | +3.896 | +4.076 | 105
ADJUSTABLE FASCIA BRA | C250AF/Gable roof | PL/702 | 1.1 | +4.909 | +5.044 | 105
RAFTER | C250AF/Gable roof> | Z/341 | 8 | +2.893 | +3.545 | 76
RAFTER | C250AF/Gable roof> | Z/341 | 8 | +3.893 | +4.545 | 76
ADJUSTABLE FASCIA BRA | C200AF/Gable roof | PL/138 | 1.4 | +2.873 | +3.108 | 105
ADJUSTABLE FASCIA BRA | C200AF/Gable roof | PL/139 | 1.3 | +3.896 | +4.076 | 105
ADJUSTABLE FASCIA BRA | C200AF/Gable roof | PL/140 | 0.9 | +4.909 | +5.044 | 105
RAFTER | C200AF/Gable roof> | Z/331 | 7.1 | +2.915 | +3.522 | 76
RAFTER | C200AF/Gable roof> | Z/331 | 7.1 | +3.915 | +4.522 | 76
ADJUSTABLE FASCIA BRA | C150AF/Gable roof | PL/132 | 1.3 | +2.873 | +3.108 | 105
ADJUSTABLE FASCIA BRA | C150AF/Gable roof | PL/133 | 0.9 | +3.896 | +4.076 | 105
RAFTER | C150AF/Gable roof> | Z/320 | 5.6 | +2.937 | +3.498 | 64
RAFTER | C150AF/Gable roof> | Z/320 | 5.6 | +3.937 | +4.498 | 64
ADJUSTABLE FASCIA BRA | C150AF/Gable roof | PL/134 | 0.9 | +4.909 | +5.044 | 105
RAFTER | C350AF/Gable roof> | Z/1644 | 15 | +4.850 | +5.590 | 125
RAFTER | C300AF/Gable roof> | Z/1522 | 12.5 | +4.872 | +5.567 | 96
RAFTER | C250AF/Gable roof> | Z/341 | 8 | +4.893 | +5.545 | 76
RAFTER | C200AF/Gable roof> | Z/331 | 7.1 | +4.915 | +5.522 | 76
RAFTER | C150AF/Gable roof> | Z/320 | 5.6 | +4.937 | +5.498 | 64
2 x PLATE | C350AF/Gable roof-Gable roof | Z/1528 | 11.8 | +2.577 | +3.345 | 128
2 x PLATE | C350AF/Gable roof-Gable roof | Z/1528 | 11.8 | +3.577 | +4.345 | 128
2 x PLATE | C300AF/Gable roof-Gable roof | Z/1519 | 10.1 | +2.577 | +3.322 | 99
2 x PLATE | C300AF/Gable roof-Gable roof | Z/1519 | 10.1 | +3.577 | +4.322 | 99
2 x PLATE | C250AF/Gable roof-Gable roof | Z/338 | 6.1 | +2.692 | +3.252 | 79
2 x PLATE | C250AF/Gable roof-Gable roof | Z/338 | 6.1 | +3.692 | +4.252 | 79
2 x PLATE | C200AF/Gable roof-Gable roof | Z/329 | 3.7 | +2.775 | +3.192 | 79
2 x PLATE | C200AF/Gable roof-Gable roof | Z/329 | 3.7 | +3.775 | +4.192 | 79
2 x PURLIN | <C150AF-C350AF>/Gable roof-Gable roof | B/10 | 32.7 | +3.467 | +3.715 | 151.5
3 x PLATE | C150AF/Gable roof | Z/317 | 2.9 | +2.777 | +3.168 | 67
2 x PURLIN | <C150AF-C350AF>/Gable roof-Gable roof | B/32 | 26.1 | +4.472 | +4.663 | 124.5
3 x PLATE | C150AF/Gable roof | Z/317 | 2.9 | +3.777 | +4.168 | 67
2 x PURLIN | <C150AF-C350AF>/Gable roof-Gable roof | B/33 | 19 | +5.477 | +5.612 | 100.5
3 x GIRT | C150AF-C350AF>/Gable roof | B/34 | 32.9 | +2.499 | +2.651 | 151.5
3 x GIRT | C150AF-C350AF>/Gable roof | B/36 | 26.2 | +3.512 | +3.637 | 124.5
3 x GIRT | C150AF-C350AF>/Gable roof | B/37 | 19.1 | +4.524 | +4.625 | 100.5
2 x PLATE | C350AF/Gable roof-Gable roof | Z/1528 | 11.8 | +4.577 | +5.345 | 128
2 x PLATE | C300AF/Gable roof-Gable roof | Z/1519 | 10.1 | +4.577 | +5.322 | 99
2 x PLATE | C250AF/Gable roof-Gable roof | Z/338 | 6.1 | +4.692 | +5.252 | 79
2 x PLATE | C200AF/Gable roof-Gable roof | Z/329 | 3.7 | +4.775 | +5.192 | 79
3 x PLATE | C150AF/Gable roof | Z/317 | 2.9 | +4.777 | +5.168 | 67
PLATE | C350AF/Gable roof> | Z/1528 | 11.8 | +2.577 | +3.345 | 128
PLATE | C350AF/Gable roof> | Z/1528 | 11.8 | +3.577 | +4.345 | 128
PLATE | C300AF/Gable roof> | Z/1519 | 10.1 | +2.577 | +3.322 | 99
PLATE | C300AF/Gable roof> | Z/1519 | 10.1 | +3.577 | +4.322 | 99
PLATE | C250AF/Gable roof> | Z/338 | 6.1 | +2.692 | +3.252 | 79
PLATE | C250AF/Gable roof> | Z/338 | 6.1 | +3.692 | +4.252 | 79
PLATE | C200AF/Gable roof> | Z/329 | 3.7 | +2.775 | +3.192 | 79
PLATE | C200AF/Gable roof> | Z/329 | 3.7 | +3.775 | +4.192 | 79
PURLIN | <C150AF-C350AF>/Gable roof> | B/10 | 32.7 | +3.467 | +3.715 | 151.5
PURLIN | <C150AF-C350AF>/Gable roof> | B/32 | 26.1 | +4.472 | +4.663 | 124.5
PURLIN |  | B/33 | 19 | +5.477 | +5.612 | 100.5
PLATE | C350AF/Gable roof> | Z/1528 | 11.8 | +4.577 | +5.345 | 128
PLATE | C300AF/Gable roof> | Z/1519 | 10.1 | +4.577 | +5.322 | 99
PLATE | C250AF/Gable roof> | Z/338 | 6.1 | +4.692 | +5.252 | 79
PLATE | C200AF/Gable roof> | Z/329 | 3.7 | +4.775 | +5.192 | 79

# IfcMechanicalFastener: Bolt assembly (630)
In: Undefined
Tekla Bolt - Location: Site
Name | NominalDiameter (mm) = Washer diameter (mm) | NominalLength (mm) = Bolt length (mm) | Material = Bolt standard | Washer count = Nut count | Washer type | Washer name | Nut type | Nut name | Slotted hole y (mm) | Slotted hole x (mm) | Bolt hole diameter (mm) | Bolt count | Bolt size (mm) | Bolt Name
180 x Bolt assembly | 12 | 30 | FB1230Z | 1 | FLAT | WASHERM12-FLAT | 4.6-HEX | NUTM12-4.6-HEX | 0 | 0 | 14 | 1 | 12 | BOLTFB1230
60 x Bolt assembly | 12 | 8 | 8.8S | 0 | HARD | WASHERM12-HARD | 8.8-HEX | NUTM12-8.8-HEX | 0 | 126 | 18 | 1 | 18 | BOLTM12*16
18 x Bolt assembly | 12 | 8 | 8.8S | 0 | HARD | WASHERM12-HARD | 8.8-HEX | NUTM12-8.8-HEX | 0 | 97 | 18 | 1 | 18 | BOLTM12*16
60 x Bolt assembly | 12 | 8 | 8.8S | 0 | HARD | WASHERM12-HARD | 8.8-HEX | NUTM12-8.8-HEX | 0 | 106 | 18 | 1 | 18 | BOLTM12*16
60 x Bolt assembly | 12 | 8 | 8.8S | 0 | HARD | WASHERM12-HARD | 8.8-HEX | NUTM12-8.8-HEX | 0 | 91 | 18 | 1 | 18 | BOLTM12*16
36 x Bolt assembly | 16 | 40 | 8.8S | 6 | HARD | WASHERM16-HARD | 8.8-HEX | NUTM16-8.8-HEX | 4 | 0 | 18 | 6 | 16 | BOLTM16*40
36 x Bolt assembly | 16 | 11 | 8.8S | 0 | HARD | WASHERM16-HARD | 8.8-HEX | NUTM16-8.8-HEX | 0 | 0 | 16 | 6 | 16 | BOLTM16*25
18 x Bolt assembly | 12 | 8 | 8.8S | 0 | HARD | WASHERM12-HARD | 8.8-HEX | NUTM12-8.8-HEX | 0 | 87 | 18 | 1 | 18 | BOLTM12*16
54 x Bolt assembly | 12 | 8 | 8.8S | 0 | HARD | WASHERM12-HARD | 8.8-HEX | NUTM12-8.8-HEX | 0 | 67 | 18 | 1 | 18 | BOLTM12*16
18 x Bolt assembly | 16 | 35 | 8.8S | 4 | HARD | WASHERM16-HARD | 8.8-HEX | NUTM16-8.8-HEX | 4 | 0 | 18 | 4 | 16 | BOLTM16*35
18 x Bolt assembly | 16 | 10.4 | 8.8S | 0 | HARD | WASHERM16-HARD | 8.8-HEX | NUTM16-8.8-HEX | 0 | 0 | 16 | 4 | 16 | BOLTM16*25
36 x Bolt assembly | 12 | 30 | 8.8S | 4 | HARD | WASHERM12-HARD | 8.8-HEX | NUTM12-8.8-HEX | 8 | 4 | 14 | 4 | 12 | BOLTM12*30
36 x Bolt assembly | 12 | 10.4 | 8.8S | 0 | HARD | WASHERM12-HARD | 8.8-HEX | NUTM12-8.8-HEX | 0 | 0 | 12 | 4 | 12 | BOLTM12*16

# IfcMember: C:150-24 (18)
In: Undefined
Description: C:150-24; Material: STEEL/G450
Tekla Common - Finish: 25 deg; Phase: 1; Class: 1
Tekla Quantity - Weight: 5.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 111.4 m2; Net surface area: 0.6 m2; Height: 152 mm; Width: 64 mm; Length: 1000 mm
Pset_MemberCommon - LoadBearing: no; Reference: Z/320
BaseQuantities - Length: 1000 mm; OuterSurfaceArea: 0.621076 m2; GrossSurfaceArea: 0 m2; CrossSectionArea: 0.00071 m2; NetVolume: 0.00073776 m3; GrossVolume: 0.00071 m3; NetWeight: 5.79142 kg; GrossWeight: 5.5735 kg
Name | Bottom elevation | Top elevation
6 x RAFTER | +2.937 | +3.498
6 x RAFTER | +3.937 | +4.498
6 x RAFTER | +4.937 | +5.498

# IfcMember: C:200-24 (18)
In: Undefined
Description: C:200-24; Material: STEEL/G450
Tekla Common - Finish: 25 deg; Phase: 1; Class: 1
Tekla Quantity - Weight: 7.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 110.2 m2; Net surface area: 0.8 m2; Height: 203 mm; Width: 76 mm; Length: 1000 mm
Pset_MemberCommon - LoadBearing: no; Reference: Z/331
BaseQuantities - Length: 1000 mm; OuterSurfaceArea: 0.78146 m2; GrossSurfaceArea: 0 m2; CrossSectionArea: 0.000903 m2; NetVolume: 0.00092976 m3; GrossVolume: 0.000903 m3; NetWeight: 7.29862 kg; GrossWeight: 7.08855 kg
Name | Bottom elevation | Top elevation
6 x RAFTER | +2.915 | +3.522
6 x RAFTER | +3.915 | +4.522
6 x RAFTER | +4.915 | +5.522

# IfcMember: C:250-24 (18)
In: Undefined
Description: C:250-24; Material: STEEL/G450
Tekla Common - Finish: 25 deg; Phase: 1; Class: 1
Tekla Quantity - Weight: 8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 109.9 m2; Height: 254 mm; Width: 76 mm; Length: 1000 mm
Pset_MemberCommon - LoadBearing: no; Reference: Z/341
BaseQuantities - Length: 1000 mm; OuterSurfaceArea: 0.8817 m2; GrossSurfaceArea: 0 m2; CrossSectionArea: 0.001022 m2; NetVolume: 0.00104976 m3; GrossVolume: 0.001022 m3; NetWeight: 8.24062 kg; GrossWeight: 8.0227 kg
Name | Bottom elevation | Top elevation | Net surface area (m2)
3 x RAFTER | +2.893 | +3.545 | 1
3 x RAFTER | +3.893 | +4.545 | 1
3 x RAFTER | +4.893 | +5.545 | 1
3 x RAFTER | +2.893 | +3.545 | 0.8
3 x RAFTER | +3.893 | +4.545 | 0.8
3 x RAFTER | +4.893 | +5.545 | 0.8

# IfcMember: C:300-30 (18)
In: Undefined
Description: C:300-30; Material: STEEL/G450
Tekla Common - Finish: 25 deg; Phase: 1; Class: 1
Tekla Quantity - Weight: 12.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.6 m2; Net surface area: 1.1 m2; Height: 300 mm; Width: 96 mm; Length: 1000 mm
Pset_MemberCommon - LoadBearing: no; Reference: Z/1522
BaseQuantities - Length: 1000 mm; OuterSurfaceArea: 1.09526 m2; GrossSurfaceArea: 0 m2; CrossSectionArea: 0.001593 m2; NetVolume: 0.001629 m3; GrossVolume: 0.001593 m3; NetWeight: 12.7877 kg; GrossWeight: 12.505 kg
Name | Bottom elevation | Top elevation
6 x RAFTER | +2.872 | +3.567
6 x RAFTER | +3.872 | +4.567
6 x RAFTER | +4.872 | +5.567

# IfcMember: C:350-30 (18)
In: Undefined
Description: C:350-30; Material: STEEL/G450
Tekla Common - Finish: 25 deg; Phase: 1; Class: 1
Tekla Quantity - Weight: 15 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.4 m2; Net surface area: 1.3 m2; Height: 350 mm; Width: 125 mm; Length: 1000 mm
Pset_MemberCommon - LoadBearing: no; Reference: Z/1644
BaseQuantities - Length: 1000 mm; OuterSurfaceArea: 1.30589 m2; GrossSurfaceArea: 0 m2; CrossSectionArea: 0.001905 m2; NetVolume: 0.001944 m3; GrossVolume: 0.001905 m3; NetWeight: 15.2604 kg; GrossWeight: 14.9542 kg
Name | Bottom elevation | Top elevation
6 x RAFTER | +2.850 | +3.590
6 x RAFTER | +3.850 | +4.590
6 x RAFTER | +4.850 | +5.590

# IfcPlate: PLT3*135 (30)
In: Undefined
Description: PLT3*135; Material: STEEL/250
Tekla Common - Phase: 1; Class: 2
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.1 m2; Height: 135 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 135 mm; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
ADJUSTABLE FASCIA BRA | PL/1670 | +4.858 | +4.993 | 1.4 | 87.8 | 560.6 | 0.125231 | 0.0756768 | 0.000181595
ADJUSTABLE FASCIA BRA | PL/1670 | +4.884 | +5.019 | 1.4 | 87.8 | 560.6 | 0.125231 | 0.0756768 | 0.000181595
ADJUSTABLE FASCIA BRA | PL/1670 | +4.909 | +5.044 | 1.4 | 87.8 | 560.6 | 0.125231 | 0.0756768 | 0.000181595
ADJUSTABLE FASCIA BRA | PL/1665 | +4.858 | +4.993 | 1.3 | 88 | 502.6 | 0.110423 | 0.0678468 | 0.000159905
ADJUSTABLE FASCIA BRA | PL/1665 | +4.884 | +5.019 | 1.3 | 88 | 502.6 | 0.110423 | 0.0678468 | 0.000159905
ADJUSTABLE FASCIA BRA | PL/1665 | +4.909 | +5.044 | 1.3 | 88 | 502.6 | 0.110423 | 0.0678468 | 0.000159905
ADJUSTABLE FASCIA BRA | PL/754 | +4.858 | +4.993 | 1.1 | 88.1 | 434.6 | 0.0946554 | 0.0586668 | 0.000136865
ADJUSTABLE FASCIA BRA | PL/754 | +4.884 | +5.019 | 1.1 | 88.1 | 434.6 | 0.0946554 | 0.0586668 | 0.000136865
ADJUSTABLE FASCIA BRA | PL/754 | +4.909 | +5.044 | 1.1 | 88.1 | 434.6 | 0.0946554 | 0.0586668 | 0.000136865
ADJUSTABLE FASCIA BRA | PL/751 | +4.858 | +4.993 | 0.9 | 88.3 | 384.1 | 0.0807174 | 0.0518493 | 0.000116412
ADJUSTABLE FASCIA BRA | PL/751 | +4.884 | +5.019 | 0.9 | 88.3 | 384.1 | 0.0807174 | 0.0518493 | 0.000116412
ADJUSTABLE FASCIA BRA | PL/751 | +4.909 | +5.044 | 0.9 | 88.3 | 384.1 | 0.0807174 | 0.0518493 | 0.000116412
ADJUSTABLE FASCIA BRA | PL/748 | +4.858 | +4.993 | 0.9 | 88.7 | 333.6 | 0.0667794 | 0.0450318 | 0.0000959598
ADJUSTABLE FASCIA BRA | PL/748 | +4.884 | +5.019 | 0.9 | 88.7 | 333.6 | 0.0667794 | 0.0450318 | 0.0000959598
ADJUSTABLE FASCIA BRA | PL/748 | +4.909 | +5.044 | 0.9 | 88.7 | 333.6 | 0.0667794 | 0.0450318 | 0.0000959598
ADJUSTABLE FASCIA BRA | PL/745 | +4.858 | +4.993 | 1.4 | 87.8 | 560.6 | 0.125231 | 0.0756768 | 0.000181595
ADJUSTABLE FASCIA BRA | PL/739 | +4.858 | +4.993 | 1.3 | 88 | 502.6 | 0.110423 | 0.0678468 | 0.000159905
ADJUSTABLE FASCIA BRA | PL/702 | +4.858 | +4.993 | 1.1 | 88.1 | 434.6 | 0.0946554 | 0.0586668 | 0.000136865
ADJUSTABLE FASCIA BRA | PL/140 | +4.858 | +4.993 | 0.9 | 88.3 | 384.1 | 0.0807174 | 0.0518493 | 0.000116412
ADJUSTABLE FASCIA BRA | PL/134 | +4.858 | +4.993 | 0.9 | 88.7 | 333.6 | 0.0667794 | 0.0450318 | 0.0000959598
ADJUSTABLE FASCIA BRA | PL/745 | +4.884 | +5.019 | 1.4 | 87.8 | 560.6 | 0.125231 | 0.0756768 | 0.000181595
ADJUSTABLE FASCIA BRA | PL/739 | +4.884 | +5.019 | 1.3 | 88 | 502.6 | 0.110423 | 0.0678468 | 0.000159905
ADJUSTABLE FASCIA BRA | PL/702 | +4.884 | +5.019 | 1.1 | 88.1 | 434.6 | 0.0946554 | 0.0586668 | 0.000136865
ADJUSTABLE FASCIA BRA | PL/140 | +4.884 | +5.019 | 0.9 | 88.3 | 384.1 | 0.0807174 | 0.0518493 | 0.000116412
ADJUSTABLE FASCIA BRA | PL/134 | +4.884 | +5.019 | 0.9 | 88.7 | 333.6 | 0.0667794 | 0.0450318 | 0.0000959598
ADJUSTABLE FASCIA BRA | PL/745 | +4.909 | +5.044 | 1.4 | 87.8 | 560.6 | 0.125231 | 0.0756768 | 0.000181595
ADJUSTABLE FASCIA BRA | PL/739 | +4.909 | +5.044 | 1.3 | 88 | 502.6 | 0.110423 | 0.0678468 | 0.000159905
ADJUSTABLE FASCIA BRA | PL/702 | +4.909 | +5.044 | 1.1 | 88.1 | 434.6 | 0.0946554 | 0.0586668 | 0.000136865
ADJUSTABLE FASCIA BRA | PL/140 | +4.909 | +5.044 | 0.9 | 88.3 | 384.1 | 0.0807174 | 0.0518493 | 0.000116412
ADJUSTABLE FASCIA BRA | PL/134 | +4.909 | +5.044 | 0.9 | 88.7 | 333.6 | 0.0667794 | 0.0450318 | 0.0000959598

# IfcPlate: PLT3*180 (30)
In: Undefined
Description: PLT3*180; Material: STEEL/250
Tekla Common - Phase: 1; Class: 2
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 180 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 180 mm; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
ADJUSTABLE FASCIA BRA | PL/1669 | +3.845 | +4.025 | 1.9 | 87.4 | 0.2 | 610.6 | 0.163964 | 0.109902 | 0.000238857
ADJUSTABLE FASCIA BRA | PL/1669 | +3.871 | +4.051 | 1.9 | 87.4 | 0.2 | 610.6 | 0.163964 | 0.109902 | 0.000238857
ADJUSTABLE FASCIA BRA | PL/1669 | +3.896 | +4.076 | 1.9 | 87.4 | 0.2 | 610.6 | 0.163964 | 0.109902 | 0.000238857
ADJUSTABLE FASCIA BRA | PL/756 | +3.845 | +4.025 | 1.7 | 87.6 | 0.1 | 552.6 | 0.144656 | 0.0994623 | 0.000210417
ADJUSTABLE FASCIA BRA | PL/756 | +3.871 | +4.051 | 1.7 | 87.6 | 0.1 | 552.6 | 0.144656 | 0.0994623 | 0.000210417
ADJUSTABLE FASCIA BRA | PL/756 | +3.896 | +4.076 | 1.7 | 87.6 | 0.1 | 552.6 | 0.144656 | 0.0994623 | 0.000210417
ADJUSTABLE FASCIA BRA | PL/753 | +3.845 | +4.025 | 1.4 | 87.6 | 0.1 | 484.6 | 0.124568 | 0.0872223 | 0.000180897
ADJUSTABLE FASCIA BRA | PL/753 | +3.871 | +4.051 | 1.4 | 87.6 | 0.1 | 484.6 | 0.124568 | 0.0872223 | 0.000180897
ADJUSTABLE FASCIA BRA | PL/753 | +3.896 | +4.076 | 1.4 | 87.6 | 0.1 | 484.6 | 0.124568 | 0.0872223 | 0.000180897
ADJUSTABLE FASCIA BRA | PL/750 | +3.845 | +4.025 | 1.3 | 88 | 0.1 | 434.1 | 0.106085 | 0.0781323 | 0.000153627
ADJUSTABLE FASCIA BRA | PL/750 | +3.871 | +4.051 | 1.3 | 88 | 0.1 | 434.1 | 0.106085 | 0.0781323 | 0.000153627
ADJUSTABLE FASCIA BRA | PL/750 | +3.896 | +4.076 | 1.3 | 88 | 0.1 | 434.1 | 0.106085 | 0.0781323 | 0.000153627
ADJUSTABLE FASCIA BRA | PL/747 | +3.845 | +4.025 | 0.9 | 88.3 | 0.1 | 383.6 | 0.0876015 | 0.0690423 | 0.000126357
ADJUSTABLE FASCIA BRA | PL/747 | +3.871 | +4.051 | 0.9 | 88.3 | 0.1 | 383.6 | 0.0876015 | 0.0690423 | 0.000126357
ADJUSTABLE FASCIA BRA | PL/747 | +3.896 | +4.076 | 0.9 | 88.3 | 0.1 | 383.6 | 0.0876015 | 0.0690423 | 0.000126357
ADJUSTABLE FASCIA BRA | PL/744 | +3.845 | +4.025 | 1.9 | 87.4 | 0.2 | 610.6 | 0.163964 | 0.109902 | 0.000238857
ADJUSTABLE FASCIA BRA | PL/738 | +3.845 | +4.025 | 1.7 | 87.6 | 0.1 | 552.6 | 0.144656 | 0.0994623 | 0.000210417
ADJUSTABLE FASCIA BRA | PL/701 | +3.845 | +4.025 | 1.4 | 87.6 | 0.1 | 484.6 | 0.124568 | 0.0872223 | 0.000180897
ADJUSTABLE FASCIA BRA | PL/139 | +3.845 | +4.025 | 1.3 | 88 | 0.1 | 434.1 | 0.106085 | 0.0781323 | 0.000153627
ADJUSTABLE FASCIA BRA | PL/133 | +3.845 | +4.025 | 0.9 | 88.3 | 0.1 | 383.6 | 0.0876015 | 0.0690423 | 0.000126357
ADJUSTABLE FASCIA BRA | PL/744 | +3.871 | +4.051 | 1.9 | 87.4 | 0.2 | 610.6 | 0.163964 | 0.109902 | 0.000238857
ADJUSTABLE FASCIA BRA | PL/738 | +3.871 | +4.051 | 1.7 | 87.6 | 0.1 | 552.6 | 0.144656 | 0.0994623 | 0.000210417
ADJUSTABLE FASCIA BRA | PL/701 | +3.871 | +4.051 | 1.4 | 87.6 | 0.1 | 484.6 | 0.124568 | 0.0872223 | 0.000180897
ADJUSTABLE FASCIA BRA | PL/139 | +3.871 | +4.051 | 1.3 | 88 | 0.1 | 434.1 | 0.106085 | 0.0781323 | 0.000153627
ADJUSTABLE FASCIA BRA | PL/133 | +3.871 | +4.051 | 0.9 | 88.3 | 0.1 | 383.6 | 0.0876015 | 0.0690423 | 0.000126357
ADJUSTABLE FASCIA BRA | PL/744 | +3.896 | +4.076 | 1.9 | 87.4 | 0.2 | 610.6 | 0.163964 | 0.109902 | 0.000238857
ADJUSTABLE FASCIA BRA | PL/738 | +3.896 | +4.076 | 1.7 | 87.6 | 0.1 | 552.6 | 0.144656 | 0.0994623 | 0.000210417
ADJUSTABLE FASCIA BRA | PL/701 | +3.896 | +4.076 | 1.4 | 87.6 | 0.1 | 484.6 | 0.124568 | 0.0872223 | 0.000180897
ADJUSTABLE FASCIA BRA | PL/139 | +3.896 | +4.076 | 1.3 | 88 | 0.1 | 434.1 | 0.106085 | 0.0781323 | 0.000153627
ADJUSTABLE FASCIA BRA | PL/133 | +3.896 | +4.076 | 0.9 | 88.3 | 0.1 | 383.6 | 0.0876015 | 0.0690423 | 0.000126357

# IfcPlate: PLT3*235 (30)
In: Undefined
Description: PLT3*235; Material: STEEL/250
Tekla Common - Phase: 1; Class: 2
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 235 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 235 mm; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
ADJUSTABLE FASCIA BRA | PL/1666 | +2.823 | +3.058 | 2.4 | 87.1 | 0.2 | 661.6 | 0.210037 | 0.155469 | 0.000307025
ADJUSTABLE FASCIA BRA | PL/1666 | +2.848 | +3.083 | 2.4 | 87.1 | 0.2 | 661.6 | 0.210037 | 0.155469 | 0.000307025
ADJUSTABLE FASCIA BRA | PL/1666 | +2.873 | +3.108 | 2.4 | 87.1 | 0.2 | 661.6 | 0.210037 | 0.155469 | 0.000307025
ADJUSTABLE FASCIA BRA | PL/755 | +2.823 | +3.058 | 2.1 | 87.4 | 0.2 | 603.6 | 0.185229 | 0.141839 | 0.000270335
ADJUSTABLE FASCIA BRA | PL/755 | +2.848 | +3.083 | 2.1 | 87.4 | 0.2 | 603.6 | 0.185229 | 0.141839 | 0.000270335
ADJUSTABLE FASCIA BRA | PL/755 | +2.873 | +3.108 | 2.1 | 87.4 | 0.2 | 603.6 | 0.185229 | 0.141839 | 0.000270335
ADJUSTABLE FASCIA BRA | PL/752 | +2.823 | +3.058 | 1.7 | 87.4 | 0.2 | 535.6 | 0.159861 | 0.125859 | 0.000232895
ADJUSTABLE FASCIA BRA | PL/752 | +2.848 | +3.083 | 1.7 | 87.4 | 0.2 | 535.6 | 0.159861 | 0.125859 | 0.000232895
ADJUSTABLE FASCIA BRA | PL/752 | +2.873 | +3.108 | 1.7 | 87.4 | 0.2 | 535.6 | 0.159861 | 0.125859 | 0.000232895
ADJUSTABLE FASCIA BRA | PL/749 | +2.823 | +3.058 | 1.4 | 87.6 | 0.1 | 485.1 | 0.135823 | 0.113991 | 0.000197292
ADJUSTABLE FASCIA BRA | PL/749 | +2.848 | +3.083 | 1.4 | 87.6 | 0.1 | 485.1 | 0.135823 | 0.113991 | 0.000197292
ADJUSTABLE FASCIA BRA | PL/749 | +2.873 | +3.108 | 1.4 | 87.6 | 0.1 | 485.1 | 0.135823 | 0.113991 | 0.000197292
ADJUSTABLE FASCIA BRA | PL/746 | +2.823 | +3.058 | 1.3 | 88.1 | 0.1 | 434.6 | 0.111785 | 0.102124 | 0.00016169
ADJUSTABLE FASCIA BRA | PL/746 | +2.848 | +3.083 | 1.3 | 88.1 | 0.1 | 434.6 | 0.111785 | 0.102124 | 0.00016169
ADJUSTABLE FASCIA BRA | PL/746 | +2.873 | +3.108 | 1.3 | 88.1 | 0.1 | 434.6 | 0.111785 | 0.102124 | 0.00016169
ADJUSTABLE FASCIA BRA | PL/743 | +2.823 | +3.058 | 2.4 | 87.1 | 0.2 | 661.6 | 0.210037 | 0.155469 | 0.000307025
ADJUSTABLE FASCIA BRA | PL/737 | +2.823 | +3.058 | 2.1 | 87.4 | 0.2 | 603.6 | 0.185229 | 0.141839 | 0.000270335
ADJUSTABLE FASCIA BRA | PL/700 | +2.823 | +3.058 | 1.7 | 87.4 | 0.2 | 535.6 | 0.159861 | 0.125859 | 0.000232895
ADJUSTABLE FASCIA BRA | PL/138 | +2.823 | +3.058 | 1.4 | 87.6 | 0.1 | 485.1 | 0.135823 | 0.113991 | 0.000197292
ADJUSTABLE FASCIA BRA | PL/132 | +2.823 | +3.058 | 1.3 | 88.1 | 0.1 | 434.6 | 0.111785 | 0.102124 | 0.00016169
ADJUSTABLE FASCIA BRA | PL/743 | +2.848 | +3.083 | 2.4 | 87.1 | 0.2 | 661.6 | 0.210037 | 0.155469 | 0.000307025
ADJUSTABLE FASCIA BRA | PL/737 | +2.848 | +3.083 | 2.1 | 87.4 | 0.2 | 603.6 | 0.185229 | 0.141839 | 0.000270335
ADJUSTABLE FASCIA BRA | PL/700 | +2.848 | +3.083 | 1.7 | 87.4 | 0.2 | 535.6 | 0.159861 | 0.125859 | 0.000232895
ADJUSTABLE FASCIA BRA | PL/138 | +2.848 | +3.083 | 1.4 | 87.6 | 0.1 | 485.1 | 0.135823 | 0.113991 | 0.000197292
ADJUSTABLE FASCIA BRA | PL/132 | +2.848 | +3.083 | 1.3 | 88.1 | 0.1 | 434.6 | 0.111785 | 0.102124 | 0.00016169
ADJUSTABLE FASCIA BRA | PL/743 | +2.873 | +3.108 | 2.4 | 87.1 | 0.2 | 661.6 | 0.210037 | 0.155469 | 0.000307025
ADJUSTABLE FASCIA BRA | PL/737 | +2.873 | +3.108 | 2.1 | 87.4 | 0.2 | 603.6 | 0.185229 | 0.141839 | 0.000270335
ADJUSTABLE FASCIA BRA | PL/700 | +2.873 | +3.108 | 1.7 | 87.4 | 0.2 | 535.6 | 0.159861 | 0.125859 | 0.000232895
ADJUSTABLE FASCIA BRA | PL/138 | +2.873 | +3.108 | 1.4 | 87.6 | 0.1 | 485.1 | 0.135823 | 0.113991 | 0.000197292
ADJUSTABLE FASCIA BRA | PL/132 | +2.873 | +3.108 | 1.3 | 88.1 | 0.1 | 434.6 | 0.111785 | 0.102124 | 0.00016169

# IfcPlate: PLT3*327 (9)
In: Undefined
Description: PLT3*327; Material: STEEL/450
Tekla Common - Phase: 1; Class: 11
Default - ASSEMBLY_POS: Z/317
Tekla Quantity - Weight: 2.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.5 m2; Net surface area: 0.2 m2; Height: 327 mm; Width: 3.1 mm; Length: 510.3 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/317
BaseQuantities - Width: 327.001 mm; NetArea: 0.248283 m2; GrossArea: 0.166851 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000365726 m3; GrossVolume: 0.000365726 m3
Name | Bottom elevation | Top elevation
3 x PLATE | +2.777 | +3.168
3 x PLATE | +3.777 | +4.168
3 x PLATE | +4.777 | +5.168

# IfcPlate: PLT3*327.1 (9)
In: Undefined
Description: PLT3*327.1; Material: STEEL/450
Default - ASSEMBLY_POS: Z/1649
Tekla Common - Phase: 1; Class: 11
Tekla Quantity - Weight: 2.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.5 m2; Net surface area: 0.2 m2; Height: 327.1 mm; Width: 3.1 mm; Length: 510.3 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/1649
BaseQuantities - Width: 327.13 mm; NetArea: 0.248286 m2; GrossArea: 0.166929 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000365749 m3; GrossVolume: 0.000365749 m3
Name | Bottom elevation | Top elevation
3 x PLATE | +2.777 | +3.168
3 x PLATE | +3.777 | +4.168
3 x PLATE | +4.777 | +5.168

# IfcPlate: PLT3*363.8 (18)
In: Undefined
Description: PLT3*363.8; Material: STEEL/450
Tekla Common - Phase: 1; Class: 11
Tekla Quantity - Weight: 3.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Net surface area: 0.3 m2; Height: 363.8 mm; Width: 3 mm; Length: 564.9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 363.821 mm; NetArea: 0.315463 m2; GrossArea: 0.205516 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00046552 m3; GrossVolume: 0.00046552 m3
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation
3 x PLATE | Z/1650 | +2.775 | +3.192
3 x PLATE | Z/1650 | +3.775 | +4.192
3 x PLATE | Z/1650 | +4.775 | +5.192
3 x PLATE | Z/329 | +2.775 | +3.192
3 x PLATE | Z/329 | +3.775 | +4.192
3 x PLATE | Z/329 | +4.775 | +5.192

# IfcPlate: PLT3*459.7 (9)
In: Undefined
Description: PLT3*459.7; Material: STEEL/450
Tekla Common - Phase: 1; Class: 11
Tekla Quantity - Weight: 6.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.5 m2; Height: 459.8 mm; Width: 3.1 mm; Length: 743.7 mm
Default - ASSEMBLY_POS: Z/338
Pset_PlateCommon - LoadBearing: no; Reference: Z/338
BaseQuantities - Width: 459.656 mm; NetArea: 0.521886 m2; GrossArea: 0.341847 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.0007731 m3; GrossVolume: 0.0007731 m3
Name | Bottom elevation | Top elevation
3 x PLATE | +2.692 | +3.252
3 x PLATE | +3.692 | +4.252
3 x PLATE | +4.692 | +5.252

# IfcPlate: PLT3*459.8 (9)
In: Undefined
Description: PLT3*459.8; Material: STEEL/450
Default - ASSEMBLY_POS: Z/1654
Tekla Common - Phase: 1; Class: 11
Tekla Quantity - Weight: 6.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86 m2; Net surface area: 0.5 m2; Height: 459.8 mm; Width: 3.1 mm; Length: 743.7 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/1654
BaseQuantities - Width: 459.8 mm; NetArea: 0.521888 m2; GrossArea: 0.341971 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000773137 m3; GrossVolume: 0.000773137 m3
Name | Bottom elevation | Top elevation
3 x PLATE | +2.692 | +3.252
3 x PLATE | +3.692 | +4.252
3 x PLATE | +4.692 | +5.252

# IfcPlate: PLT3*601.4 (9)
In: Undefined
Description: PLT3*601.4; Material: STEEL/450
Tekla Common - Phase: 1; Class: 11
Default - ASSEMBLY_POS: Z/1519
Tekla Quantity - Weight: 10.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 0.8 m2; Height: 601.4 mm; Width: 3.1 mm; Length: 967.3 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/1519
BaseQuantities - Width: 601.441 mm; NetArea: 0.863374 m2; GrossArea: 0.581793 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.0012825 m3; GrossVolume: 0.0012825 m3
Name | Bottom elevation | Top elevation
3 x PLATE | +2.577 | +3.322
3 x PLATE | +3.577 | +4.322
3 x PLATE | +4.577 | +5.322

# IfcPlate: PLT3*601.6 (9)
In: Undefined
Description: PLT3*601.6; Material: STEEL/450
Default - ASSEMBLY_POS: Z/1655
Tekla Common - Phase: 1; Class: 11
Tekla Quantity - Weight: 10.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.8 m2; Net surface area: 1 m2; Height: 601.6 mm; Width: 3.1 mm; Length: 967.4 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/1655
BaseQuantities - Width: 601.577 mm; NetArea: 0.863379 m2; GrossArea: 0.58195 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00128254 m3; GrossVolume: 0.00128254 m3
Name | Bottom elevation | Top elevation
3 x PLATE | +2.577 | +3.322
3 x PLATE | +3.577 | +4.322
3 x PLATE | +4.577 | +5.322

# IfcPlate: PLT3*651.8 (9)
In: Undefined
Description: PLT3*651.8; Material: STEEL/450
Tekla Common - Phase: 1; Class: 11
Default - ASSEMBLY_POS: Z/1528
Tekla Quantity - Weight: 11.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.7 m2; Net surface area: 1 m2; Height: 651.8 mm; Width: 3.1 mm; Length: 1025.8 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/1528
BaseQuantities - Width: 651.804 mm; NetArea: 1.00762 m2; GrossArea: 0.668586 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00149792 m3; GrossVolume: 0.00149792 m3
Name | Bottom elevation | Top elevation
3 x PLATE | +2.577 | +3.345
3 x PLATE | +3.577 | +4.345
3 x PLATE | +4.577 | +5.345

# IfcPlate: PLT3*652 (9)
In: Undefined
Description: PLT3*652; Material: STEEL/450
Default - ASSEMBLY_POS: Z/1656
Tekla Common - Phase: 1; Class: 11
Tekla Quantity - Weight: 11.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.7 m2; Net surface area: 1 m2; Height: 652 mm; Width: 3.1 mm; Length: 1025.8 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/1656
BaseQuantities - Width: 651.954 mm; NetArea: 1.00763 m2; GrossArea: 0.668766 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.0014979 m3; GrossVolume: 0.0014979 m3
Name | Bottom elevation | Top elevation
3 x PLATE | +2.577 | +3.345
3 x PLATE | +3.577 | +4.345
3 x PLATE | +4.577 | +5.345
