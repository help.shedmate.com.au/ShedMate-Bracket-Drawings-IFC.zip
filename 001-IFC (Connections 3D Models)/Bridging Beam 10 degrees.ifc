Properties of the parts of a building model (IFC2X3), part 2 of 4

# IfcDiscreteAccessory: FASCIA STIFFENER (66)
Name | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Length (mm) | Reference | NetArea (m2) = GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
FASCIA STIFFENER | +3.410 | +3.664 | 0.6 | 88.1 | 254 | PL/128(?) | 0.063204 | 0.00009144
FASCIA STIFFENER | +3.365 | +3.619 | 0.6 | 88.1 | 254 | PL/128(?) | 0.063204 | 0.00009144
FASCIA STIFFENER | +3.386 | +3.589 | 0.6 | 88.3 | 203 | PL/156(?) | 0.050658 | 0.00007308
FASCIA STIFFENER | +3.405 | +3.608 | 0.6 | 88.3 | 203 | PL/156(?) | 0.050658 | 0.00007308
FASCIA STIFFENER | +3.416 | +3.619 | 0.6 | 88.3 | 203 | PL/156(?) | 0.050658 | 0.00007308
3 x FASCIA STIFFENER | +3.291 | +3.641 | 1 | 87.8 | 350 | PL/116 | 0.08682 | 0.000126
FASCIA STIFFENER | +3.294 | +3.644 | 1 | 87.8 | 350 | PL/116 | 0.08682 | 0.000126
FASCIA STIFFENER | +3.269 | +3.619 | 1 | 87.8 | 350 | PL/116 | 0.08682 | 0.000126
FASCIA STIFFENER | +3.248 | +3.598 | 1 | 87.8 | 350 | PL/116 | 0.08682 | 0.000126
FASCIA STIFFENER | +3.319 | +3.619 | 0.8 | 87.8 | 300 | PL/113 | 0.07452 | 0.000108
FASCIA STIFFENER | +3.339 | +3.639 | 0.8 | 87.8 | 300 | PL/113 | 0.07452 | 0.000108
FASCIA STIFFENER | +3.344 | +3.644 | 0.8 | 87.8 | 300 | PL/113 | 0.07452 | 0.000108
3 x FASCIA STIFFENER | +3.293 | +3.643 | 1 | 87.8 | 350 | PL/116 | 0.08682 | 0.000126
6 x FASCIA STIFFENER | +3.343 | +3.643 | 0.8 | 87.8 | 300 | PL/113 | 0.07452 | 0.000108
FASCIA STIFFENER | +3.354 | +3.608 | 0.6 | 88.1 | 254 | PL/128 | 0.063204 | 0.00009144
FASCIA STIFFENER | +3.369 | +3.623 | 0.6 | 88.1 | 254 | PL/128 | 0.063204 | 0.00009144
4 x FASCIA STIFFENER | +3.389 | +3.643 | 0.6 | 88.1 | 254 | PL/128 | 0.063204 | 0.00009144
FASCIA STIFFENER | +3.379 | +3.633 | 0.6 | 88.1 | 254 | PL/128 | 0.063204 | 0.00009144
FASCIA STIFFENER | +3.390 | +3.593 | 0.6 | 88.3 | 203 | PL/156 | 0.050658 | 0.00007308
FASCIA STIFFENER | +3.410 | +3.613 | 0.6 | 88.3 | 203 | PL/156 | 0.050658 | 0.00007308
FASCIA STIFFENER | +3.430 | +3.633 | 0.6 | 88.3 | 203 | PL/156 | 0.050658 | 0.00007308
FASCIA STIFFENER | +3.365 | +3.619 | 0.6 | 88.1 | 254 | PL/128 | 0.063204 | 0.00009144
FASCIA STIFFENER | +3.343 | +3.597 | 0.6 | 88.1 | 254 | PL/128 | 0.063204 | 0.00009144
FASCIA STIFFENER | +3.384 | +3.587 | 0.6 | 88.3 | 203 | PL/156 | 0.050658 | 0.00007308
2 x FASCIA STIFFENER | +3.394 | +3.597 | 0.6 | 88.3 | 203 | PL/156 | 0.050658 | 0.00007308

# IfcElementAssembly (1446)
In: Undefined
PredefinedType: RIGID_FRAME
Name | ASSEMBLY_POSITION_CODE = Assembly/Cast unit position code | ASSEMBLY_POS = Assembly/Cast unit Mark | Assembly/Cast unit weight (kg) | Assembly/Cast unit bottom elevation | Assembly/Cast unit top elevation | Width (mm)
BRIDGING U-PLATE | C350-C350/BB350(Z200) | PL/2047(?) | 4.4 | +3.254 | +3.612 | 358
RAFTER | C350-C350/BB350(Z200)> | Z/2606(?) | 10.8 | +3.258 | +3.729 | 125
BB TRUSS BRACKET | C350-C350/BB350(Z200)> | PL/2069(?) | 5.4 | +3.258 | +3.666 | 147.699
BB TRUSS BRACKET | C350-C350/BB350(Z200)> | PL/2068(?) | 5.4 | +3.258 | +3.666 | 147.699
BRIDGING U-PLATE | C350-C350/BB350(Z150) | PL/2034(?) | 4.4 | +3.275 | +3.633 | 358
RAFTER | C350-C350/BB350(Z150)-BB350(Z200) | Z/2606(?) | 10.8 | +3.279 | +3.750 | 125
BB TRUSS BRACKET | C350-C350/BB350(Z150)-BB350(Z200) | PL/2069(?) | 5.4 | +3.279 | +3.687 | 147.699
BB TRUSS BRACKET | C350-C350/BB350(Z150)-BB350(Z200) | PL/2068(?) | 5.4 | +3.279 | +3.687 | 147.699
2 x RAFTER | C300/BB350(Z200)> | Z/430(?) | 8.9 | +3.300 | +3.720 | 96
COLUMN | C300/BB350(Z200) | Z/3135(?) | 46.4 | +0.000 | +3.711 | 96
2 x PLATE | C300/BB350(Z200)> | Z/2548(?) | 8.7 | +3.113 | +3.668 | 104.5
COLUMN | C300/BB350(Z200) | Z/3185(?) | 46.4 | +0.000 | +3.711 | 96
2 x RAFTER | C300/BB350(Z150)-BB350(Z200) | Z/430(?) | 8.9 | +3.296 | +3.716 | 96
COLUMN | C300/BB350(Z150) | Z/3136(?) | 45.8 | +0.000 | +3.665 | 96
2 x PLATE | C300/BB350(Z150)-BB350(Z200) | Z/2548(?) | 8.7 | +3.109 | +3.665 | 104.5
COLUMN | C300/BB350(Z150) | Z/3198(?) | 45.8 | +0.000 | +3.665 | 96
2 x RAFTER | C300/BB350(Z100)-BB350(Z150) | Z/430(?) | 8.9 | +3.293 | +3.713 | 96
COLUMN | C300/BB350(Z100) | Z/3190(?) | 45.3 | +0.000 | +3.620 | 96
2 x PLATE | C300/BB350(Z100)-BB350(Z150) | Z/2548(?) | 8.7 | +3.106 | +3.662 | 104.5
COLUMN | C300/BB350(Z100) | Z/304(?) | 45.3 | +0.000 | +3.620 | 96
2 x RAFTER | C300/BB300(Z200)-BB350(Z100) | Z/430(?) | 8.9 | +3.300 | +3.720 | 96
COLUMN | C300/BB300(Z200) | Z/3185(?) | 46.4 | +0.000 | +3.711 | 96
2 x PLATE | C300/BB300(Z200)-BB350(Z100) | Z/2548(?) | 8.7 | +3.113 | +3.668 | 104.5
COLUMN | C300/BB300(Z200) | Z/3135(?) | 46.4 | +0.000 | +3.711 | 96
2 x RAFTER | C300/BB300(Z150)-BB300(Z200) | Z/430(?) | 8.9 | +3.321 | +3.741 | 96
COLUMN | C300/BB300(Z150) | Z/3173(?) | 46.1 | +0.000 | +3.689 | 96
2 x PLATE | C300/BB300(Z150)-BB300(Z200) | Z/2548(?) | 8.7 | +3.134 | +3.689 | 104.5
COLUMN | C300/BB300(Z150) | Z/3122(?) | 46.1 | +0.000 | +3.689 | 96
2 x RAFTER | C300/BB300(Z100)-BB300(Z150) | Z/430(?) | 8.9 | +3.339 | +3.759 | 96
COLUMN | C300/BB300(Z100) | Z/3172(?) | 45.8 | +0.000 | +3.666 | 96
2 x PLATE | C300/BB300(Z100)-BB300(Z150) | Z/2548(?) | 8.7 | +3.152 | +3.708 | 104.5
COLUMN | C300/BB300(Z100) | Z/3121(?) | 45.8 | +0.000 | +3.666 | 96
BRIDGING U-PLATE | C300-C300/BB350(Z200) | PL/2046(?) | 4.4 | +3.296 | +3.654 | 129
RAFTER | C300-C300/BB350(Z200)> | Z/2599(?) | 8.9 | +3.300 | +3.720 | 96
BB TRUSS BRACKET | C300-C300/BB350(Z200)> | PL/0(?) | 4.3 | +3.292 | +3.659 | 147.699
BB TRUSS BRACKET | C300-C300/BB350(Z200)> | PL/2065(?) | 4.3 | +3.292 | +3.659 | 147.699
BRIDGING U-PLATE | C300-C300/BB350(Z150) | PL/2046(?) | 4.4 | +3.293 | +3.651 | 129
RAFTER | C300-C300/BB350(Z150)-BB350(Z200) | Z/2599(?) | 8.9 | +3.296 | +3.716 | 96
BB TRUSS BRACKET | C300-C300/BB350(Z150)-BB350(Z200) | PL/0(?) | 4.3 | +3.288 | +3.655 | 147.699
BB TRUSS BRACKET | C300-C300/BB350(Z150)-BB350(Z200) | PL/2065(?) | 4.3 | +3.288 | +3.655 | 147.699
BRIDGING U-PLATE | C300-C300/BB300(Z200) | PL/2030(?) | 3.6 | +3.296 | +3.604 | 100
RAFTER | C300-C300/BB300(Z200)-BB350(Z100) | Z/2599(?) | 8.9 | +3.300 | +3.720 | 96
BB TRUSS BRACKET | C300-C300/BB300(Z200)-BB350(Z100) | PL/2066(?) | 4.6 | +3.299 | +3.659 | 147.699
BB TRUSS BRACKET | C300-C300/BB300(Z200)-BB350(Z100) | PL/2064(?) | 4.6 | +3.299 | +3.659 | 147.699
BRIDGING U-PLATE | C300-C300/BB300(Z150) | PL/2030(?) | 3.6 | +3.317 | +3.625 | 100
RAFTER | C300-C300/BB300(Z150)-BB300(Z200) | Z/2599(?) | 8.9 | +3.321 | +3.741 | 96
BB TRUSS BRACKET | C300-C300/BB300(Z150)-BB300(Z200) | PL/2066(?) | 4.6 | +3.320 | +3.679 | 147.699
BB TRUSS BRACKET | C300-C300/BB300(Z150)-BB300(Z200) | PL/2064(?) | 4.6 | +3.320 | +3.679 | 147.699
2 x RAFTER | C250/BB350(Z200)> | Z/289(?) | 5.9 | +3.336 | +3.713 | 76
COLUMN | C250/BB350(Z200) | Z/3044(?) | 29.8 | +0.000 | +3.710 | 76
2 x PLATE | C250/BB350(Z200) | Z/2538(?) | 5.2 | +3.227 | +3.639 | 84.5
COLUMN | C250/BB350(Z200) | Z/3115(?) | 29.8 | +0.000 | +3.710 | 76
2 x RAFTER | C250/BB350(Z150)-BB350(Z200) | Z/289(?) | 5.9 | +3.357 | +3.734 | 76
COLUMN | C250/BB350(Z150) | Z/3043(?) | 29.6 | +0.000 | +3.688 | 76
2 x PLATE | C250/BB350(Z150) | Z/2538(?) | 5.2 | +3.248 | +3.660 | 84.5
COLUMN | C250/BB350(Z150) | Z/3114(?) | 29.6 | +0.000 | +3.688 | 76
2 x RAFTER | C250/BB350(Z100)-BB350(Z150) | Z/289(?) | 5.9 | +3.376 | +3.753 | 76
COLUMN | C250/BB350(Z100) | Z/3042(?) | 29.4 | +0.000 | +3.665 | 76
2 x PLATE | C250/BB350(Z100) | Z/2538(?) | 5.2 | +3.266 | +3.679 | 84.5
COLUMN | C250/BB350(Z100) | Z/3113(?) | 29.4 | +0.000 | +3.665 | 76
2 x RAFTER | C250/BB300(Z200)-BB350(Z100) | Z/289(?) | 5.9 | +3.336 | +3.713 | 76
COLUMN | C250/BB300(Z200) | Z/3044(?) | 29.8 | +0.000 | +3.710 | 76
2 x PLATE | C250/BB300(Z200) | Z/2538(?) | 5.2 | +3.227 | +3.639 | 84.5
COLUMN | C250/BB300(Z200) | Z/3115(?) | 29.8 | +0.000 | +3.710 | 76
2 x RAFTER | C250/BB300(Z150)-BB300(Z200) | Z/289(?) | 5.9 | +3.357 | +3.734 | 76
COLUMN | C250/BB300(Z150) | Z/3043(?) | 29.6 | +0.000 | +3.688 | 76
2 x PLATE | C250/BB300(Z150) | Z/2538(?) | 5.2 | +3.248 | +3.660 | 84.5
COLUMN | C250/BB300(Z150) | Z/3114(?) | 29.6 | +0.000 | +3.688 | 76
2 x RAFTER | C250/BB300(Z100)-BB300(Z150) | Z/289(?) | 5.9 | +3.376 | +3.753 | 76
COLUMN | C250/BB300(Z100) | Z/3042(?) | 29.4 | +0.000 | +3.665 | 76
2 x PLATE | C250/BB300(Z100) | Z/2538(?) | 5.2 | +3.266 | +3.679 | 84.5
COLUMN | C250/BB300(Z100) | Z/3113(?) | 29.4 | +0.000 | +3.665 | 76
2 x RAFTER | C250/BB250(Z200)-BB300(Z100) | Z/289(?) | 5.9 | +3.337 | +3.713 | 76
COLUMN | C250/BB250(Z200) | Z/3115(?) | 29.8 | +0.000 | +3.710 | 76
2 x PLATE | C250/BB250(Z200) | Z/2538(?) | 5.2 | +3.227 | +3.640 | 84.5
COLUMN | C250/BB250(Z200) | Z/3044(?) | 29.8 | +0.000 | +3.710 | 76
2 x RAFTER | C250/BB250(Z150)-BB250(Z200) | Z/289(?) | 5.9 | +3.357 | +3.734 | 76
COLUMN | C250/BB250(Z150) | Z/3043(?) | 29.6 | +0.000 | +3.689 | 76
2 x PLATE | C250/BB250(Z150) | Z/2538(?) | 5.2 | +3.248 | +3.661 | 84.5
COLUMN | C250/BB250(Z150) | Z/3114(?) | 29.6 | +0.000 | +3.689 | 76
2 x RAFTER | C250/BB250(Z100)-BB250(Z150) | Z/289(?) | 5.9 | +3.376 | +3.753 | 76
COLUMN | C250/BB250(Z100) | Z/3113(?) | 29.4 | +0.000 | +3.665 | 76
2 x PLATE | C250/BB250(Z100) | Z/2538(?) | 5.2 | +3.266 | +3.679 | 84.5
COLUMN | C250/BB250(Z100) | Z/3042(?) | 29.4 | +0.000 | +3.665 | 76
BRIDGING U-PLATE | C250-C250/BB350(Z200) | PL/2044(?) | 4.4 | +3.332 | +3.690 | 129
RAFTER | C250-C250/BB350(Z200)> | Z/2591(?) | 5.9 | +3.336 | +3.713 | 76
2 x BB TRUSS BRACKET | C250-C250/BB350(Z200) | PL/0(?) | 2.6 | +3.340 | +3.628 | 147.999
BRIDGING U-PLATE | C250-C250/BB350(Z150) | PL/2043(?) | 4.4 | +3.334 | +3.692 | 129
RAFTER | C250-C250/BB350(Z150)-BB350(Z200) | Z/2591(?) | 5.9 | +3.357 | +3.734 | 76
2 x BB TRUSS BRACKET | C250-C250/BB350(Z150) | PL/0(?) | 2.6 | +3.360 | +3.649 | 147.999
BRIDGING U-PLATE | C250-C250/BB300(Z200) | PL/2041(?) | 3.6 | +3.332 | +3.640 | 100
RAFTER | C250-C250/BB300(Z200)-BB350(Z100) | Z/2591(?) | 5.9 | +3.336 | +3.713 | 76
BB TRUSS BRACKET | C250-C250/BB300(Z200) | PL/2062(?) | 2.9 | +3.329 | +3.628 | 147.999
BB TRUSS BRACKET | C250-C250/BB300(Z200) | PL/2059(?) | 2.9 | +3.329 | +3.628 | 147.999
BRIDGING U-PLATE | C250-C250/BB300(Z150) | PL/2040(?) | 3.6 | +3.352 | +3.660 | 100
RAFTER | C250-C250/BB300(Z150)-BB300(Z200) | Z/2591(?) | 5.9 | +3.357 | +3.734 | 76
BB TRUSS BRACKET | C250-C250/BB300(Z150) | PL/2062(?) | 2.9 | +3.350 | +3.649 | 147.999
BB TRUSS BRACKET | C250-C250/BB300(Z150) | PL/2059(?) | 2.9 | +3.350 | +3.649 | 147.999
BRIDGING U-PLATE | C250-C250/BB250(Z200) | PL/1985(?) | 2.9 | +3.332 | +3.594 | 80
RAFTER | C250-C250/BB250(Z200)-BB300(Z100) | Z/2591(?) | 5.9 | +3.337 | +3.713 | 76
BB TRUSS BRACKET | C250-C250/BB250(Z200) | PL/0(?) | 3.1 | +3.337 | +3.628 | 147.999
BB TRUSS BRACKET | C250-C250/BB250(Z200) | PL/2061(?) | 3.1 | +3.337 | +3.628 | 147.999
BRIDGING U-PLATE | C250-C250/BB250(Z150) | PL/1985(?) | 2.9 | +3.354 | +3.616 | 80
RAFTER | C250-C250/BB250(Z150)-BB250(Z200) | Z/2591(?) | 5.9 | +3.357 | +3.734 | 76
BB TRUSS BRACKET | C250-C250/BB250(Z150) | PL/0(?) | 3.1 | +3.358 | +3.649 | 147.999
BB TRUSS BRACKET | C250-C250/BB250(Z150) | PL/2061(?) | 3.1 | +3.358 | +3.649 | 147.999
2 x RAFTER | C200/BB300(Z200)-BB350(Z100) | R/92(?) | 3.9 | +3.378 | +3.673 | 76
COLUMN | C200/BB300(Z200) | C/64(?) | 26.3 | +0.000 | +3.710 | 76
2 x PLATE | C200/BB300(Z200) | Z/2525(?) | 2.9 | +3.312 | +3.616 | 80
COLUMN | C200/BB300(Z200) | C/67(?) | 26.3 | +0.000 | +3.710 | 76
2 x RAFTER | C200/BB300(Z150)-BB300(Z200) | R/92(?) | 3.9 | +3.399 | +3.694 | 76
COLUMN | C200/BB300(Z150) | C/63(?) | 26.1 | +0.000 | +3.689 | 76
2 x PLATE | C200/BB300(Z150) | Z/2525(?) | 2.9 | +3.333 | +3.637 | 80
COLUMN | C200/BB300(Z150) | C/66(?) | 26.1 | +0.000 | +3.689 | 76
2 x RAFTER | C200/BB300(Z100)-BB300(Z150) | R/92(?) | 3.9 | +3.417 | +3.713 | 76
COLUMN | C200/BB300(Z100) | C/62(?) | 26 | +0.000 | +3.665 | 76
2 x PLATE | C200/BB300(Z100) | Z/2525(?) | 2.9 | +3.351 | +3.655 | 80
COLUMN | C200/BB300(Z100) | C/65(?) | 26 | +0.000 | +3.665 | 76
2 x RAFTER | C200/BB250(Z200)-BB300(Z100) | R/92(?) | 3.9 | +3.378 | +3.673 | 76
COLUMN | C200/BB250(Z200) | C/64(?) | 26.3 | +0.000 | +3.710 | 76
2 x PLATE | C200/BB250(Z200) | Z/2525(?) | 2.9 | +3.312 | +3.616 | 80
COLUMN | C200/BB250(Z200) | C/67(?) | 26.3 | +0.000 | +3.710 | 76
2 x RAFTER | C200/BB250(Z150)-BB250(Z200) | R/92(?) | 3.9 | +3.399 | +3.694 | 76
COLUMN | C200/BB250(Z150) | C/63(?) | 26.1 | +0.000 | +3.689 | 76
2 x PLATE | C200/BB250(Z150) | Z/2525(?) | 2.9 | +3.333 | +3.637 | 80
COLUMN | C200/BB250(Z150) | C/66(?) | 26.1 | +0.000 | +3.689 | 76
2 x RAFTER | C200/BB250(Z100)-BB250(Z150) | R/92(?) | 3.9 | +3.417 | +3.713 | 76
COLUMN | C200/BB250(Z100) | C/62(?) | 26 | +0.000 | +3.665 | 76
2 x PLATE | C200/BB250(Z100) | Z/2525(?) | 2.9 | +3.351 | +3.655 | 80
COLUMN | C200/BB250(Z100) | C/65(?) | 26 | +0.000 | +3.665 | 76
2 x RAFTER | C200/BB200(Z200)-BB250(Z100) | R/92(?) | 3.9 | +3.378 | +3.673 | 76
COLUMN | C200/BB200(Z200) | C/64(?) | 26.3 | +0.000 | +3.710 | 76
2 x PLATE | C200/BB200(Z200) | Z/2525(?) | 2.9 | +3.312 | +3.616 | 80
COLUMN | C200/BB200(Z200) | C/67(?) | 26.3 | +0.000 | +3.710 | 76
2 x RAFTER | C200/BB200(Z150)-BB200(Z200) | R/92(?) | 3.9 | +3.399 | +3.694 | 76
COLUMN | C200/BB200(Z150) | C/63(?) | 26.1 | +0.000 | +3.689 | 76
2 x PLATE | C200/BB200(Z150) | Z/2525(?) | 2.9 | +3.333 | +3.637 | 80
COLUMN | C200/BB200(Z150) | C/66(?) | 26.1 | +0.000 | +3.689 | 76
2 x RAFTER | C200/BB200(Z100)-BB200(Z150) | R/92(?) | 3.9 | +3.417 | +3.713 | 76
COLUMN | C200/BB200(Z100) | C/65(?) | 26 | +0.000 | +3.665 | 76
2 x PLATE | C200/BB200(Z100) | Z/2525(?) | 2.9 | +3.351 | +3.655 | 80
COLUMN | C200/BB200(Z100) | C/62(?) | 26 | +0.000 | +3.665 | 76
BRIDGING U-PLATE | C200-C200/BB300(Z200) | PL/2038(?) | 3.6 | +3.373 | +3.681 | 308
RAFTER | C200-C200/BB300(Z200)-BB350(Z100) | R/93(?) | 3.9 | +3.378 | +3.673 | 76
BB TRUSS BRACKET | C200-C200/BB300(Z200) | PL/2057(?) | 1.7 | +3.381 | +3.605 | 147.999
BB TRUSS BRACKET | C200-C200/BB300(Z200) | PL/2054(?) | 1.7 | +3.381 | +3.605 | 147.999
BRIDGING U-PLATE | C200-C200/BB300(Z150) | PL/2037(?) | 3.6 | +3.385 | +3.693 | 308
RAFTER | C200-C200/BB300(Z150)-BB300(Z200) | R/93(?) | 3.9 | +3.399 | +3.694 | 76
BB TRUSS BRACKET | C200-C200/BB300(Z150) | PL/2057(?) | 1.7 | +3.402 | +3.626 | 147.999
BB TRUSS BRACKET | C200-C200/BB300(Z150) | PL/2054(?) | 1.7 | +3.402 | +3.626 | 147.999
BRIDGING U-PLATE | C200-C200/BB250(Z200) | PL/2026(?) | 2.9 | +3.373 | +3.635 | 262
RAFTER | C200-C200/BB250(Z200)-BB300(Z100) | R/93(?) | 3.9 | +3.378 | +3.673 | 76
BB TRUSS BRACKET | C200-C200/BB250(Z200) | PL/2056(?) | 1.9 | +3.374 | +3.605 | 147.999
BB TRUSS BRACKET | C200-C200/BB250(Z200) | PL/2053(?) | 1.9 | +3.374 | +3.605 | 147.999
BRIDGING U-PLATE | C200-C200/BB250(Z150) | PL/2026(?) | 2.9 | +3.395 | +3.657 | 262
RAFTER | C200-C200/BB250(Z150)-BB250(Z200) | R/93(?) | 3.9 | +3.399 | +3.694 | 76
BB TRUSS BRACKET | C200-C200/BB250(Z150) | PL/2056(?) | 1.9 | +3.395 | +3.626 | 147.999
BB TRUSS BRACKET | C200-C200/BB250(Z150) | PL/2053(?) | 1.9 | +3.395 | +3.626 | 147.999
BRIDGING U-PLATE | C200-C200/BB200(Z200) | PL/2017(?) | 2.6 | +3.373 | +3.584 | 211
RAFTER | C200-C200/BB200(Z200)-BB250(Z100) | R/93(?) | 3.9 | +3.378 | +3.673 | 76
BB TRUSS BRACKET | C200-C200/BB200(Z200) | PL/2055(?) | 1.9 | +3.374 | +3.605 | 147.999
BB TRUSS BRACKET | C200-C200/BB200(Z200) | PL/2052(?) | 1.9 | +3.374 | +3.605 | 147.999
BRIDGING U-PLATE | C200-C200/BB200(Z150) | PL/2035(?) | 2.6 | +3.395 | +3.606 | 211
RAFTER | C200-C200/BB200(Z150)-BB200(Z200) | R/93(?) | 3.9 | +3.399 | +3.694 | 76
BB TRUSS BRACKET | C200-C200/BB200(Z150) | PL/2055(?) | 1.9 | +3.395 | +3.626 | 147.999
BB TRUSS BRACKET | C200-C200/BB200(Z150) | PL/2052(?) | 1.9 | +3.395 | +3.626 | 147.999
2 x RAFTER | C150/BB250(Z200)-BB300(Z100) | Z/222(?) | 2.6 | +3.419 | +3.649 | 64
COLUMN | C150/BB250(Z200) | Z/2641(?) | 20.7 | +0.000 | +3.711 | 64
2 x PLATE | C150/BB250(Z200) | Z/2453(?) | 2.5 | +3.312 | +3.607 | 72.5
COLUMN | C150/BB250(Z200) | Z/2596(?) | 20.7 | +0.000 | +3.711 | 64
2 x RAFTER | C150/BB250(Z150)-BB250(Z200) | Z/222(?) | 2.6 | +3.416 | +3.646 | 64
COLUMN | C150/BB250(Z150) | Z/2640(?) | 20.4 | +0.000 | +3.664 | 64
2 x PLATE | C150/BB250(Z150) | Z/2453(?) | 2.5 | +3.309 | +3.603 | 72.5
COLUMN | C150/BB250(Z150) | Z/2572(?) | 20.4 | +0.000 | +3.664 | 64
2 x RAFTER | C150/BB250(Z100)-BB250(Z150) | Z/222(?) | 2.6 | +3.413 | +3.643 | 64
COLUMN | C150/BB250(Z100) | Z/2575(?) | 20.2 | +0.000 | +3.619 | 64
2 x PLATE | C150/BB250(Z100) | Z/2453(?) | 2.5 | +3.306 | +3.600 | 72.5
COLUMN | C150/BB250(Z100) | Z/1584(?) | 20.2 | +0.000 | +3.619 | 64
2 x RAFTER | C150/BB200(Z200)-BB250(Z100) | Z/222(?) | 2.6 | +3.373 | +3.603 | 64
COLUMN | C150/BB200(Z200) | Z/2639(?) | 20.4 | +0.000 | +3.665 | 64
2 x PLATE | C150/BB200(Z200) | Z/2453(?) | 2.5 | +3.266 | +3.561 | 72.5
COLUMN | C150/BB200(Z200) | Z/2571(?) | 20.4 | +0.000 | +3.665 | 64
2 x RAFTER | C150/BB200(Z150)-BB200(Z200) | Z/222(?) | 2.6 | +3.394 | +3.624 | 64
COLUMN | C150/BB200(Z150) | Z/2638(?) | 20.2 | +0.000 | +3.643 | 64
2 x PLATE | C150/BB200(Z150) | Z/2453(?) | 2.5 | +3.287 | +3.582 | 72.5
COLUMN | C150/BB200(Z150) | Z/2532(?) | 20.2 | +0.000 | +3.643 | 64
2 x RAFTER | C150/BB200(Z100)-BB200(Z150) | Z/222(?) | 2.6 | +3.413 | +3.643 | 64
COLUMN | C150/BB200(Z100) | Z/1584(?) | 20.2 | +0.000 | +3.619 | 64
2 x PLATE | C150/BB200(Z100) | Z/2453(?) | 2.5 | +3.306 | +3.600 | 72.5
COLUMN | C150/BB200(Z100) | Z/2575(?) | 20.2 | +0.000 | +3.619 | 64
BRIDGING U-PLATE | C150-C150/BB250(Z200) | PL/2016(?) | 2.9 | +3.415 | +3.677 | 262
RAFTER | C150-C150/BB250(Z200)-BB300(Z100) | Z/2555(?) | 2.6 | +3.419 | +3.649 | 64
BB TRUSS BRACKET | C150-C150/BB250(Z200) | PL/2050(?) | 1.2 | +3.425 | +3.596 | 147.999
BB TRUSS BRACKET | C150-C150/BB250(Z200) | PL/2051(?) | 1.2 | +3.425 | +3.596 | 147.999
BRIDGING U-PLATE | C150-C150/BB250(Z150) | PL/2015(?) | 2.9 | +3.406 | +3.668 | 262
RAFTER | C150-C150/BB250(Z150)-BB250(Z200) | Z/2555(?) | 2.6 | +3.416 | +3.646 | 64
BB TRUSS BRACKET | C150-C150/BB250(Z150) | PL/2050(?) | 1.2 | +3.422 | +3.593 | 147.999
BB TRUSS BRACKET | C150-C150/BB250(Z150) | PL/2051(?) | 1.2 | +3.422 | +3.593 | 147.999
BRIDGING U-PLATE | C150-C150/BB250(Z100) | PL/2014(?) | 2.9 | +3.361 | +3.623 | 262
RAFTER | C150-C150/BB250(Z100)-BB250(Z150) | Z/2555(?) | 2.6 | +3.413 | +3.643 | 64
BB TRUSS BRACKET | C150-C150/BB250(Z100) | PL/2050(?) | 1.2 | +3.419 | +3.590 | 147.999
BB TRUSS BRACKET | C150-C150/BB250(Z100) | PL/2051(?) | 1.2 | +3.419 | +3.590 | 147.999
BRIDGING U-PLATE | C150-C150/BB200(Z200) | PL/2007(?) | 2.6 | +3.369 | +3.580 | 211
RAFTER | C150-C150/BB200(Z200)-BB250(Z100) | Z/2555(?) | 2.6 | +3.373 | +3.603 | 64
BB TRUSS BRACKET | C150-C150/BB200(Z200) | PL/2050(?) | 1.2 | +3.379 | +3.550 | 147.999
BB TRUSS BRACKET | C150-C150/BB200(Z200) | PL/2051(?) | 1.2 | +3.379 | +3.550 | 147.999
BRIDGING U-PLATE | C150-C150/BB200(Z150) | PL/1999(?) | 2.6 | +3.391 | +3.602 | 211
RAFTER | C150-C150/BB200(Z150)-BB200(Z200) | Z/2555(?) | 2.6 | +3.394 | +3.624 | 64
BB TRUSS BRACKET | C150-C150/BB200(Z150) | PL/2050(?) | 1.2 | +3.400 | +3.571 | 147.999
BB TRUSS BRACKET | C150-C150/BB200(Z150) | PL/2051(?) | 1.2 | +3.400 | +3.571 | 147.999
BB TRUSS BRACKET | C250-C250/BB250(Z100) | PL/0(?) | 3.1 | +3.376 | +3.667 | 147.999
2 x BB TRUSS BRACKET | C250-C250/BB350(Z100) | PL/0(?) | 2.6 | +3.379 | +3.667 | 147.999
BB TRUSS BRACKET | C300-C300/BB350(Z100)-BB350(Z150) | PL/0(?) | 4.3 | +3.285 | +3.652 | 147.699
BRIDGING U-PLATE | C300-C300/BB350(Z100) | PL/2045(?) | 4.4 | +3.266 | +3.624 | 129
BRIDGING U-PLATE | C250-C250/BB350(Z100) | PL/2042(?) | 4.4 | +3.311 | +3.669 | 129
BRIDGING U-PLATE | C250-C250/BB250(Z100) | PL/2018(?) | 2.9 | +3.372 | +3.634 | 80
BRIDGING U-PLATE | C350-C350/BB350(Z100) | PL/2034(?) | 4.4 | +3.293 | +3.651 | 358
RAFTER | C350-C350/BB350(Z100)-BB350(Z150) | Z/2606(?) | 10.8 | +3.298 | +3.768 | 125
2 x FASCIA BRACKET | C350/BB350(Z200) | Z/2533(?) | 0.4 | +3.555 | +3.712 | 157.2
FASCIA BRACKET | C350-C350/BB350(Z200) | Z/3088(?) | 0.4 | +3.555 | +3.712 | 157.2
FASCIA STIFFENER | C350-C350/BB350(Z200) | PL/116(?) | 1 | +3.280 | +3.630 | 3
BEAM | C350-C350/BB350(Z200) | B/99(?) | 27.7 | +3.258 | +3.608 | 125
COLUMN | C350/BB350(Z200) | Z/3618(?) | 55.5 | +0.000 | +3.710 | 125
2 x FASCIA BRACKET | C350/BB350(Z150) | Z/2515(?) | 0.4 | +3.533 | +3.690 | 157.2
FASCIA BRACKET | C350-C350/BB350(Z150) | Z/3087(?) | 0.4 | +3.533 | +3.690 | 157.2
FASCIA STIFFENER | C350-C350/BB350(Z150) | PL/116(?) | 1 | +3.298 | +3.648 | 3
BEAM | C350-C350/BB350(Z150) | B/99(?) | 27.7 | +3.279 | +3.629 | 125
COLUMN | C350/BB350(Z150) | Z/3617(?) | 55.2 | +0.000 | +3.688 | 125
2 x FASCIA BRACKET | C350/BB350(Z100) | Z/2514(?) | 0.4 | +3.510 | +3.667 | 157.2
FASCIA BRACKET | C350-C350/BB350(Z100) | Z/3086(?) | 0.4 | +3.510 | +3.667 | 157.2
FASCIA STIFFENER | C350-C350/BB350(Z100) | PL/116(?) | 1 | +3.314 | +3.664 | 3
BEAM | C350-C350/BB350(Z100) | B/99(?) | 27.7 | +3.297 | +3.647 | 125
COLUMN | C350/BB350(Z100) | Z/3616(?) | 54.8 | +0.000 | +3.664 | 125
RAFTER | C300-C300/BB350(Z100)-BB350(Z150) | Z/2599(?) | 8.9 | +3.293 | +3.713 | 96
2 x FASCIA BRACKET | C300/BB350(Z200) | Z/2533(?) | 0.4 | +3.556 | +3.713 | 157.2
FASCIA BRACKET | C300-C300/BB350(Z200) | Z/3088(?) | 0.4 | +3.556 | +3.713 | 157.2
FASCIA STIFFENER | C300-C300/BB350(Z200) | PL/116(?) | 1 | +3.319 | +3.669 | 3
BEAM | C300-C300/BB350(Z200) | B/98(?) | 28.2 | +3.300 | +3.650 | 125
2 x FASCIA BRACKET | C300/BB350(Z150) | Z/2515(?) | 0.4 | +3.510 | +3.667 | 157.2
FASCIA BRACKET | C300-C300/BB350(Z150) | Z/3087(?) | 0.4 | +3.510 | +3.667 | 157.2
FASCIA STIFFENER | C300-C300/BB350(Z150) | PL/116(?) | 1 | +3.314 | +3.664 | 3
BEAM | C300-C300/BB350(Z150) | B/98(?) | 28.2 | +3.297 | +3.647 | 125
2 x FASCIA BRACKET | C300/BB350(Z100) | Z/2514(?) | 0.4 | +3.465 | +3.622 | 157.2
FASCIA BRACKET | C300-C300/BB350(Z100) | Z/3086(?) | 0.4 | +3.465 | +3.622 | 157.2
FASCIA STIFFENER | C300-C300/BB350(Z100) | PL/116(?) | 1 | +3.270 | +3.620 | 3
BEAM | C300-C300/BB350(Z100) | B/98(?) | 28.2 | +3.270 | +3.620 | 125
FASCIA STIFFENER | C300-C300/BB300(Z200) | PL/113(?) | 0.8 | +3.318 | +3.618 | 3
FASCIA STIFFENER | C300-C300/BB300(Z150) | PL/113(?) | 0.8 | +3.338 | +3.638 | 3
FASCIA STIFFENER | C300-C300/BB300(Z100) | PL/113(?) | 0.8 | +3.356 | +3.656 | 3
BEAM | C300-C300/BB300(Z200) | B/97(?) | 23.6 | +3.300 | +3.600 | 96
2 x FASCIA BRACKET | C300/BB300(Z200) | Z/2533(?) | 0.4 | +3.556 | +3.713 | 157.2
FASCIA BRACKET | C300-C300/BB300(Z200) | Z/3088(?) | 0.4 | +3.556 | +3.713 | 157.2
BEAM | C300-C300/BB300(Z150) | B/97(?) | 23.6 | +3.321 | +3.621 | 96
2 x FASCIA BRACKET | C300/BB300(Z150) | Z/2515(?) | 0.4 | +3.534 | +3.692 | 157.2
FASCIA BRACKET | C300-C300/BB300(Z150) | Z/3087(?) | 0.4 | +3.534 | +3.692 | 157.2
BEAM | C300-C300/BB300(Z100) | B/97(?) | 23.6 | +3.339 | +3.639 | 96
BRIDGING U-PLATE | C300-C300/BB300(Z100) | PL/1992(?) | 3.6 | +3.335 | +3.643 | 100
RAFTER | C300-C300/BB300(Z100)-BB300(Z150) | Z/2599(?) | 8.9 | +3.339 | +3.759 | 96
2 x FASCIA BRACKET | C300/BB300(Z100) | Z/2514(?) | 0.4 | +3.511 | +3.668 | 157.2
FASCIA BRACKET | C300-C300/BB300(Z100) | Z/3086(?) | 0.4 | +3.511 | +3.668 | 157.2
RAFTER | C250-C250/BB350(Z100)-BB350(Z150) | Z/2591(?) | 5.9 | +3.376 | +3.753 | 76
2 x FASCIA BRACKET | C250/BB350(Z200) | Z/2533(?) | 0.4 | +3.556 | +3.713 | 157.2
FASCIA BRACKET | C250-C250/BB350(Z200) | Z/3088(?) | 0.4 | +3.556 | +3.713 | 157.2
FASCIA STIFFENER | C250-C250/BB350(Z200) | PL/116(?) | 1 | +3.353 | +3.703 | 3
BEAM | C250-C250/BB350(Z200) | B/103(?) | 28.5 | +3.336 | +3.686 | 125
2 x FASCIA BRACKET | C250/BB350(Z150) | Z/2515(?) | 0.4 | +3.534 | +3.691 | 157.2
FASCIA BRACKET | C250-C250/BB350(Z150) | Z/3087(?) | 0.4 | +3.534 | +3.691 | 157.2
FASCIA STIFFENER | C250-C250/BB350(Z150) | PL/116(?) | 1 | +3.338 | +3.688 | 3
BEAM | C250-C250/BB350(Z150) | B/103(?) | 28.5 | +3.338 | +3.688 | 125
2 x FASCIA BRACKET | C250/BB350(Z100) | Z/2514(?) | 0.4 | +3.511 | +3.668 | 157.2
FASCIA BRACKET | C250-C250/BB350(Z100) | Z/3086(?) | 0.4 | +3.511 | +3.668 | 157.2
FASCIA STIFFENER | C250-C250/BB350(Z100) | PL/116(?) | 1 | +3.315 | +3.665 | 3
BEAM | C250-C250/BB350(Z100) | B/103(?) | 28.5 | +3.315 | +3.665 | 125
BRIDGING U-PLATE | C250-C250/BB300(Z100) | PL/2039(?) | 3.6 | +3.361 | +3.669 | 100
RAFTER | C250-C250/BB300(Z100)-BB300(Z150) | Z/2591(?) | 5.9 | +3.376 | +3.753 | 76
2 x FASCIA BRACKET | C250/BB300(Z200) | Z/2533(?) | 0.4 | +3.556 | +3.713 | 157.2
FASCIA BRACKET | C250-C250/BB300(Z200) | Z/3088(?) | 0.4 | +3.556 | +3.713 | 157.2
FASCIA STIFFENER | C250-C250/BB300(Z200) | PL/113(?) | 0.8 | +3.352 | +3.652 | 3
BEAM | C250-C250/BB300(Z200) | B/93(?) | 19 | +3.336 | +3.636 | 96
2 x FASCIA BRACKET | C250/BB300(Z150) | Z/2515(?) | 0.4 | +3.534 | +3.691 | 157.2
FASCIA BRACKET | C250-C250/BB300(Z150) | Z/3087(?) | 0.4 | +3.534 | +3.691 | 157.2
FASCIA STIFFENER | C250-C250/BB300(Z150) | PL/113(?) | 0.8 | +3.368 | +3.668 | 3
BEAM | C250-C250/BB300(Z150) | B/93(?) | 19 | +3.356 | +3.656 | 96
2 x FASCIA BRACKET | C250/BB300(Z100) | Z/2514(?) | 0.4 | +3.511 | +3.668 | 157.2
FASCIA BRACKET | C250-C250/BB300(Z100) | Z/3086(?) | 0.4 | +3.511 | +3.668 | 157.2
FASCIA STIFFENER | C250-C250/BB300(Z100) | PL/113(?) | 0.8 | +3.365 | +3.665 | 3
BEAM | C250-C250/BB300(Z100) | B/93(?) | 19 | +3.365 | +3.665 | 96
2 x FASCIA BRACKET | C250/BB250(Z200) | Z/2533(?) | 0.4 | +3.556 | +3.713 | 157.2
FASCIA BRACKET | C250-C250/BB250(Z200) | Z/3088(?) | 0.4 | +3.556 | +3.713 | 157.2
FASCIA STIFFENER | C250-C250/BB250(Z200) | PL/128(?) | 0.8 | +3.353 | +3.607 | 3
BEAM | C250-C250/BB250(Z200) | B/92(?) | 15.3 | +3.336 | +3.590 | 76
2 x FASCIA BRACKET | C250/BB250(Z150) | Z/2515(?) | 0.4 | +3.534 | +3.691 | 157.2
FASCIA BRACKET | C250-C250/BB250(Z150) | Z/3087(?) | 0.4 | +3.534 | +3.691 | 157.2
FASCIA STIFFENER | C250-C250/BB250(Z150) | PL/128(?) | 0.8 | +3.373 | +3.627 | 3
BEAM | C250-C250/BB250(Z150) | B/92(?) | 15.3 | +3.358 | +3.612 | 76
2 x FASCIA BRACKET | C250/BB250(Z100) | Z/2514(?) | 0.4 | +3.511 | +3.668 | 157.2
FASCIA BRACKET | C250-C250/BB250(Z100) | Z/3086(?) | 0.4 | +3.511 | +3.668 | 157.2
RAFTER | C250-C250/BB250(Z100)-BB250(Z150) | Z/2591(?) | 5.9 | +3.376 | +3.753 | 76
FASCIA STIFFENER | C250-C250/BB250(Z100) | PL/128(?) | 0.8 | +3.386 | +3.640 | 3
BEAM | C250-C250/BB250(Z100) | B/92(?) | 15.3 | +3.376 | +3.630 | 76
2 x FASCIA BRACKET | C200/BB300(Z200) | Z/2954(?) | 0.8 | +3.554 | +3.715 | 161
FASCIA BRACKET | C200-C200/BB300(Z200) | Z/2994(?) | 0.8 | +3.554 | +3.715 | 161
2 x FASCIA BRACKET | C200/BB250(Z200) | Z/2954(?) | 0.8 | +3.554 | +3.715 | 161
FASCIA BRACKET | C200-C200/BB250(Z200) | Z/2994(?) | 0.8 | +3.554 | +3.715 | 161
2 x FASCIA BRACKET | C200/BB200(Z200) | Z/2954(?) | 0.8 | +3.554 | +3.715 | 161
FASCIA BRACKET | C200-C200/BB200(Z200) | Z/2994(?) | 0.8 | +3.554 | +3.715 | 161
2 x FASCIA BRACKET | C200/BB300(Z150) | Z/2953(?) | 0.6 | +3.532 | +3.693 | 161
FASCIA BRACKET | C200-C200/BB300(Z150) | Z/2953(?) | 0.6 | +3.532 | +3.693 | 161
2 x FASCIA BRACKET | C200/BB250(Z150) | Z/2953(?) | 0.6 | +3.532 | +3.693 | 161
FASCIA BRACKET | C200-C200/BB250(Z150) | Z/2981(?) | 0.6 | +3.532 | +3.693 | 161
2 x FASCIA BRACKET | C200/BB200(Z150) | Z/2953(?) | 0.6 | +3.532 | +3.693 | 161
FASCIA BRACKET | C200-C200/BB200(Z150) | Z/2981(?) | 0.6 | +3.532 | +3.693 | 161
2 x FASCIA BRACKET | C200/BB300(Z100) | Z/2951(?) | 0.4 | +3.509 | +3.670 | 161
FASCIA BRACKET | C200-C200/BB300(Z100) | Z/2980(?) | 0.4 | +3.509 | +3.670 | 161
2 x FASCIA BRACKET | C200/BB250(Z100) | Z/2951(?) | 0.4 | +3.509 | +3.670 | 161
FASCIA BRACKET | C200-C200/BB250(Z100) | Z/2980(?) | 0.4 | +3.509 | +3.670 | 161
2 x FASCIA BRACKET | C200/BB200(Z100) | Z/2951(?) | 0.4 | +3.509 | +3.670 | 161
FASCIA BRACKET | C200-C200/BB200(Z100) | Z/2980(?) | 0.4 | +3.509 | +3.670 | 161
BRIDGING U-PLATE | C200-C200/BB300(Z100) | PL/2031(?) | 3.6 | +3.361 | +3.669 | 308
BRIDGING U-PLATE | C200-C200/BB250(Z100) | PL/2025(?) | 2.9 | +3.407 | +3.669 | 262
RAFTER | C200-C200/BB300(Z100)-BB300(Z150) | R/93(?) | 3.9 | +3.417 | +3.713 | 76
FASCIA STIFFENER | C200-C200/BB300(Z200) | PL/113(?) | 0.8 | +3.385 | +3.685 | 3
BRIDGING BEAM | C200-C200/BB300(Z200) | BB/5(?) | 19 | +3.377 | +3.677 | 96
FASCIA STIFFENER | C200-C200/BB300(Z150) | PL/113(?) | 0.8 | +3.389 | +3.689 | 3
BRIDGING BEAM | C200-C200/BB300(Z150) | BB/5(?) | 19 | +3.389 | +3.689 | 96
FASCIA STIFFENER | C200-C200/BB300(Z100) | PL/113(?) | 0.8 | +3.365 | +3.665 | 3
BRIDGING BEAM | C200-C200/BB300(Z100) | BB/5(?) | 19 | +3.365 | +3.665 | 96
FASCIA STIFFENER | C200-C200/BB250(Z200) | PL/128(?) | 0.6 | +3.391 | +3.645 | 3
BRIDGING BEAM | C200-C200/BB250(Z200) | BB/3(?) | 15.3 | +3.377 | +3.631 | 76
FASCIA STIFFENER | C200-C200/BB250(Z150) | PL/128(?) | 0.6 | +3.411 | +3.665 | 3
BRIDGING BEAM | C200-C200/BB250(Z150) | BB/3(?) | 15.3 | +3.399 | +3.653 | 76
RAFTER | C200-C200/BB250(Z100)-BB250(Z150) | R/93(?) | 3.9 | +3.417 | +3.713 | 76
FASCIA STIFFENER | C200-C200/BB250(Z100) | PL/128(?) | 0.6 | +3.411 | +3.665 | 3
BRIDGING BEAM | C200-C200/BB250(Z100) | BB/3(?) | 15.3 | +3.411 | +3.665 | 76
FASCIA STIFFENER | C200-C200/BB200(Z200) | PL/156(?) | 0.6 | +3.392 | +3.595 | 3
BRIDGING BEAM | C200-C200/BB200(Z200) | BB/1(?) | 13.5 | +3.377 | +3.580 | 76
FASCIA STIFFENER | C200-C200/BB200(Z150) | PL/156(?) | 0.6 | +3.411 | +3.614 | 3
BRIDGING BEAM | C200-C200/BB200(Z150) | BB/1(?) | 13.5 | +3.399 | +3.602 | 76
BRIDGING U-PLATE | C200-C200/BB200(Z100) | PL/2035(?) | 2.6 | +3.412 | +3.623 | 211
FASCIA STIFFENER | C200-C200/BB200(Z100) | PL/156(?) | 0.6 | +3.428 | +3.631 | 3
RAFTER | C200-C200/BB200(Z100)-BB200(Z150) | R/93(?) | 3.9 | +3.417 | +3.713 | 76
BRIDGING BEAM | C200-C200/BB200(Z100) | BB/1(?) | 13.5 | +3.416 | +3.619 | 76
FASCIA STIFFENER | C150-C150/BB250(Z200) | PL/128(?) | 0.6 | +3.432 | +3.686 | 3
2 x FASCIA BRACKET | C150/BB250(Z200) | Z/2533(?) | 0.4 | +3.556 | +3.713 | 157.2
FASCIA BRACKET | C150-C150/BB250(Z200) | Z/2533(?) | 0.4 | +3.556 | +3.713 | 157.2
BEAM | C150-C150/BB250(Z200) | B/80(?) | 15.3 | +3.419 | +3.673 | 76
BEAM | C150-C150/BB250(Z200) | B/91(?) | 15.3 | +3.419 | +3.673 | 76
FASCIA STIFFENER | C150-C150/BB250(Z150) | PL/128(?) | 0.6 | +3.410 | +3.664 | 3
2 x FASCIA BRACKET | C150/BB250(Z150) | Z/2515(?) | 0.4 | +3.510 | +3.667 | 157.2
FASCIA BRACKET | C150-C150/BB250(Z150) | Z/2515(?) | 0.4 | +3.510 | +3.667 | 157.2
BEAM | C150-C150/BB250(Z150) | B/80(?) | 15.3 | +3.410 | +3.664 | 76
BEAM | C150-C150/BB250(Z150) | B/91(?) | 15.3 | +3.410 | +3.664 | 76
FASCIA STIFFENER | C150-C150/BB250(Z100) | PL/128(?) | 0.6 | +3.365 | +3.619 | 3
2 x FASCIA BRACKET | C150/BB250(Z100) | Z/2514(?) | 0.4 | +3.465 | +3.622 | 157.2
FASCIA BRACKET | C150-C150/BB250(Z100) | Z/2514(?) | 0.4 | +3.465 | +3.622 | 157.2
BEAM | C150-C150/BB250(Z100) | B/80(?) | 15.3 | +3.365 | +3.619 | 76
BEAM | C150-C150/BB250(Z100) | B/91(?) | 15.3 | +3.365 | +3.619 | 76
FASCIA STIFFENER | C150-C150/BB200(Z200) | PL/156(?) | 0.6 | +3.386 | +3.589 | 3
2 x FASCIA BRACKET | C150/BB200(Z200) | Z/2533(?) | 0.4 | +3.510 | +3.667 | 157.2
FASCIA BRACKET | C150-C150/BB200(Z200) | Z/2533(?) | 0.4 | +3.510 | +3.667 | 157.2
BEAM | C150-C150/BB200(Z200) | B/15(?) | 13.6 | +3.373 | +3.576 | 76
BEAM | C150-C150/BB200(Z200) | B/38(?) | 13.6 | +3.373 | +3.576 | 76
FASCIA STIFFENER | C150-C150/BB200(Z150) | PL/156(?) | 0.6 | +3.405 | +3.608 | 3
2 x FASCIA BRACKET | C150/BB200(Z150) | Z/2515(?) | 0.4 | +3.488 | +3.645 | 157.2
FASCIA BRACKET | C150-C150/BB200(Z150) | Z/2515(?) | 0.4 | +3.488 | +3.645 | 157.2
BEAM | C150-C150/BB200(Z150) | B/15(?) | 13.6 | +3.395 | +3.598 | 76
BEAM | C150-C150/BB200(Z150) | B/38(?) | 13.6 | +3.395 | +3.598 | 76
BRIDGING U-PLATE | C150-C150/BB200(Z100) | PL/2005(?) | 2.6 | +3.412 | +3.623 | 211
FASCIA STIFFENER | C150-C150/BB200(Z100) | PL/156(?) | 0.6 | +3.416 | +3.619 | 3
RAFTER | C150-C150/BB200(Z100)-BB200(Z150) | Z/2555(?) | 2.6 | +3.413 | +3.643 | 64
2 x FASCIA BRACKET | C150/BB200(Z100) | Z/2514(?) | 0.4 | +3.465 | +3.622 | 157.2
FASCIA BRACKET | C150-C150/BB200(Z100) | Z/2514(?) | 0.4 | +3.465 | +3.622 | 157.2
BEAM | C150-C150/BB200(Z100) | B/15(?) | 13.6 | +3.416 | +3.619 | 76
BEAM | C150-C150/BB200(Z100) | B/38(?) | 13.6 | +3.416 | +3.619 | 76
BRIDGING-COLUMN STIFF | C350/BB350(Z200) | PL/118(?) | 4.4 | +3.360 | +3.710 | 112
BRIDGING-COLUMN STIFF | C350/BB350(Z150) | PL/118(?) | 4.4 | +3.338 | +3.688 | 112
BRIDGING-COLUMN STIFF | C350/BB350(Z100) | PL/118(?) | 4.4 | +3.314 | +3.664 | 112
BRIDGING-COLUMN STIFF | C300/BB350(Z200) | PL/117(?) | 3.7 | +3.361 | +3.711 | 83
BRIDGING-COLUMN STIFF | C300/BB350(Z150) | PL/117(?) | 3.7 | +3.315 | +3.665 | 83
BRIDGING-COLUMN STIFF | C300/BB350(Z100) | PL/117(?) | 3.7 | +3.270 | +3.620 | 83
BRIDGING-COLUMN STIFF | C300/BB300(Z200) | PL/117(?) | 3.7 | +3.361 | +3.711 | 83
BRIDGING-COLUMN STIFF | C300/BB300(Z150) | PL/117(?) | 3.7 | +3.339 | +3.689 | 83
BRIDGING-COLUMN STIFF | C300/BB300(Z100) | PL/117(?) | 3.7 | +3.316 | +3.666 | 83
BRIDGING-COLUMN STIFF | C250/BB350(Z200) | PL/114(?) | 2.9 | +3.360 | +3.710 | 64.2
BRIDGING-COLUMN STIFF | C250/BB350(Z150) | PL/114(?) | 2.9 | +3.338 | +3.688 | 64.2
BRIDGING-COLUMN STIFF | C250/BB350(Z100) | PL/114(?) | 2.9 | +3.315 | +3.665 | 64.2
BRIDGING-COLUMN STIFF | C250/BB300(Z200) | PL/114(?) | 2.9 | +3.360 | +3.710 | 64.2
BRIDGING-COLUMN STIFF | C250/BB300(Z150) | PL/114(?) | 2.9 | +3.338 | +3.688 | 64.2
BRIDGING-COLUMN STIFF | C250/BB300(Z100) | PL/114(?) | 2.9 | +3.315 | +3.665 | 64.2
BRIDGING-COLUMN STIFF | C250/BB250(Z200) | PL/114(?) | 2.9 | +3.360 | +3.710 | 64.2
BRIDGING-COLUMN STIFF | C250/BB250(Z150) | PL/114(?) | 2.9 | +3.339 | +3.689 | 64.2
BRIDGING-COLUMN STIFF | C250/BB250(Z100) | PL/114(?) | 2.9 | +3.315 | +3.665 | 64.2
2 x BRIDGING BRACKET | C300/BB300(Z200) | PL/218(?) | 1.7 | +3.315 | +3.585 | 6
2 x BRIDGING BRACKET | C300/BB300(Z150) | PL/218(?) | 1.7 | +3.336 | +3.606 | 6
2 x BRIDGING BRACKET | C300/BB300(Z100) | PL/218(?) | 1.7 | +3.354 | +3.624 | 6
2 x BRIDGING BRACKET | C250/BB300(Z100) | PL/218(?) | 1.7 | +3.380 | +3.650 | 6
2 x BRIDGING BRACKET | C250/BB300(Z150) | PL/218(?) | 1.7 | +3.371 | +3.641 | 6
2 x BRIDGING BRACKET | C250/BB300(Z200) | PL/218(?) | 1.7 | +3.351 | +3.621 | 6
2 x BRIDGING BRACKET | C250/BB350(Z100) | PL/1998(?) | 2.2 | +3.330 | +3.650 | 6
2 x BRIDGING BRACKET | C250/BB350(Z150) | PL/1998(?) | 2.2 | +3.353 | +3.673 | 6
2 x BRIDGING BRACKET | C250/BB350(Z200) | PL/1998(?) | 2.2 | +3.351 | +3.671 | 6
2 x BRIDGING BRACKET | C300/BB350(Z200) | PL/1998(?) | 2.2 | +3.315 | +3.635 | 6
2 x BRIDGING BRACKET | C300/BB350(Z150) | PL/1998(?) | 2.2 | +3.312 | +3.632 | 6
2 x BRIDGING BRACKET | C300/BB350(Z100) | PL/1998(?) | 2.2 | +3.285 | +3.605 | 6
2 x BRIDGING BRACKET | C350/BB350(Z100) | PL/1998(?) | 2.2 | +3.312 | +3.632 | 6
2 x BRIDGING BRACKET | C350/BB350(Z150) | PL/1998(?) | 2.2 | +3.294 | +3.614 | 6
2 x BRIDGING BRACKET | C350/BB350(Z200) | PL/1998(?) | 2.2 | +3.273 | +3.593 | 6
GIRT | C350-C350/BB350(Z200) | G/20(?) | 7 | +2.950 | +3.102 | 151.5
GIRT | C350-C350/BB350(Z150) | G/19(?) | 5.6 | +2.964 | +3.089 | 124.5
GIRT | C350-C350/BB350(Z100) | G/18(?) | 4.1 | +2.976 | +3.077 | 100.5
2 x RAFTER | C350/BB350(Z100)-BB350(Z150) | Z/431(?) | 10.8 | +3.298 | +3.768 | 125
2 x RAFTER | C350/BB350(Z150)-BB350(Z200) | Z/431(?) | 10.8 | +3.279 | +3.750 | 125
2 x RAFTER | C350/BB350(Z200)> | Z/431(?) | 10.8 | +3.258 | +3.729 | 125
BB TRUSS BRACKET | C350-C350/BB350(Z100)-BB350(Z150) | PL/2069(?) | 5.4 | +3.297 | +3.705 | 147.699
BB TRUSS BRACKET | C350-C350/BB350(Z100)-BB350(Z150) | PL/2068(?) | 5.4 | +3.297 | +3.705 | 147.699
PURLIN | C350-C350/BB350(Z200)> | PU/21(?) | 7 | +3.716 | +3.942 | 151.5
FASCIA | C350-C350/BB350(Z200) | F/16(?) | 8.9 | +3.558 | +3.710 | 64
COLUMN | C350/BB350(Z200) | Z/3639(?) | 55.5 | +0.000 | +3.710 | 125
BEAM | C350-C350/BB350(Z200) | B/78(?) | 27.7 | +3.258 | +3.608 | 125
PURLIN | C350-C350/BB350(Z150)-BB350(Z200) | PU/20(?) | 5.6 | +3.739 | +3.911 | 124.5
FASCIA | C350-C350/BB350(Z150) | F/16(?) | 8.9 | +3.536 | +3.688 | 64
COLUMN | C350/BB350(Z150) | Z/3638(?) | 55.2 | +0.000 | +3.688 | 125
BEAM | C350-C350/BB350(Z150) | B/78(?) | 27.7 | +3.279 | +3.629 | 125
PURLIN | C350-C350/BB350(Z100)-BB350(Z150) | PU/19(?) | 4.1 | +3.760 | +3.878 | 100.5
FASCIA | C350-C350/BB350(Z100) | F/16(?) | 8.9 | +3.512 | +3.664 | 64
COLUMN | C350/BB350(Z100) | Z/3637(?) | 54.8 | +0.000 | +3.664 | 125
BEAM | C350-C350/BB350(Z100) | B/78(?) | 27.7 | +3.297 | +3.647 | 125
GIRT | C300-C300/BB350(Z200) | G/17(?) | 7.4 | +2.985 | +3.137 | 151.5
GIRT | C300-C300/BB350(Z150) | G/16(?) | 5.9 | +2.999 | +3.124 | 124.5
GIRT | C300-C300/BB350(Z100) | G/15(?) | 4.3 | +3.011 | +3.112 | 100.5
GIRT | C300-C300/BB300(Z200) | G/17(?) | 7.4 | +2.985 | +3.137 | 151.5
GIRT | C300-C300/BB300(Z150) | G/16(?) | 5.9 | +2.999 | +3.124 | 124.5
GIRT | C300-C300/BB300(Z100) | G/15(?) | 4.3 | +3.011 | +3.112 | 100.5
BB TRUSS BRACKET | C300-C300/BB350(Z100)-BB350(Z150) | PL/2065(?) | 4.3 | +3.285 | +3.652 | 147.699
PURLIN | C300-C300/BB350(Z200)> | PU/18(?) | 7.4 | +3.707 | +3.933 | 151.5
FASCIA | C300-C300/BB350(Z200) | F/15(?) | 9.4 | +3.559 | +3.711 | 64
BEAM | C300-C300/BB350(Z200) | B/75(?) | 28.2 | +3.300 | +3.650 | 125
PURLIN | C300-C300/BB350(Z150)-BB350(Z200) | PU/17(?) | 5.9 | +3.706 | +3.877 | 124.5
FASCIA | C300-C300/BB350(Z150) | F/15(?) | 9.4 | +3.513 | +3.665 | 64
BEAM | C300-C300/BB350(Z150) | B/75(?) | 28.2 | +3.297 | +3.647 | 125
PURLIN | C300-C300/BB350(Z100)-BB350(Z150) | PU/16(?) | 4.3 | +3.705 | +3.823 | 100.5
FASCIA | C300-C300/BB350(Z100) | F/15(?) | 9.4 | +3.468 | +3.620 | 64
BEAM | C300-C300/BB350(Z100) | B/75(?) | 28.2 | +3.270 | +3.620 | 125
BEAM | C300-C300/BB300(Z200) | B/96(?) | 23.6 | +3.300 | +3.600 | 96
PURLIN | C300-C300/BB300(Z200)-BB350(Z100) | PU/18(?) | 7.4 | +3.697 | +3.923 | 151.5
FASCIA | C300-C300/BB300(Z200) | F/15(?) | 9.4 | +3.559 | +3.711 | 64
BEAM | C300-C300/BB300(Z150) | B/96(?) | 23.6 | +3.321 | +3.621 | 96
PURLIN | C300-C300/BB300(Z150)-BB300(Z200) | PU/17(?) | 5.9 | +3.720 | +3.891 | 124.5
FASCIA | C300-C300/BB300(Z150) | F/15(?) | 9.4 | +3.537 | +3.689 | 64
BEAM | C300-C300/BB300(Z100) | B/96(?) | 23.6 | +3.339 | +3.639 | 96
BB TRUSS BRACKET | C300-C300/BB300(Z100)-BB300(Z150) | PL/2066(?) | 4.6 | +3.339 | +3.698 | 147.699
BB TRUSS BRACKET | C300-C300/BB300(Z100)-BB300(Z150) | PL/2064(?) | 4.6 | +3.339 | +3.698 | 147.699
PURLIN | C300-C300/BB300(Z100)-BB300(Z150) | PU/16(?) | 4.3 | +3.740 | +3.858 | 100.5
FASCIA | C300-C300/BB300(Z100) | F/15(?) | 9.4 | +3.514 | +3.666 | 64
GIRT | C250-C250/BB350(Z200) | G/14(?) | 7.4 | +3.098 | +3.249 | 151.5
GIRT | C250-C250/BB350(Z150) | G/13(?) | 5.9 | +3.111 | +3.235 | 124.5
GIRT | C250-C250/BB350(Z100) | G/12(?) | 4.1 | +3.123 | +3.223 | 100.5
GIRT | C250-C250/BB300(Z200) | G/14(?) | 7.4 | +3.098 | +3.249 | 151.5
GIRT | C250-C250/BB300(Z150) | G/13(?) | 5.9 | +3.111 | +3.235 | 124.5
GIRT | C250-C250/BB300(Z100) | G/12(?) | 4.1 | +3.123 | +3.223 | 100.5
GIRT | C250-C250/BB250(Z200) | G/14(?) | 7.4 | +3.098 | +3.249 | 151.5
GIRT | C250-C250/BB250(Z150) | G/13(?) | 5.9 | +3.111 | +3.235 | 124.5
GIRT | C250-C250/BB250(Z100) | G/12(?) | 4.1 | +3.123 | +3.223 | 100.5
FASCIA | C250-C250/BB350(Z200) | F/14(?) | 8.1 | +3.558 | +3.710 | 64
PURLIN | C250-C250/BB350(Z200)> | PU/15(?) | 7.4 | +3.701 | +3.927 | 151.5
BEAM | C250-C250/BB350(Z200) | B/104(?) | 28.5 | +3.336 | +3.686 | 125
FASCIA | C250-C250/BB350(Z150) | F/14(?) | 8.1 | +3.536 | +3.688 | 64
PURLIN | C250-C250/BB350(Z150)-BB350(Z200) | PU/14(?) | 5.9 | +3.724 | +3.895 | 124.5
BEAM | C250-C250/BB350(Z150) | B/104(?) | 28.5 | +3.338 | +3.688 | 125
PURLIN | C250-C250/BB350(Z100)-BB350(Z150) | PU/13(?) | 4.1 | +3.744 | +3.862 | 100.5
FASCIA | C250-C250/BB350(Z100) | F/14(?) | 8.1 | +3.513 | +3.665 | 64
BEAM | C250-C250/BB350(Z100) | B/104(?) | 28.5 | +3.315 | +3.665 | 125
BB TRUSS BRACKET | C250-C250/BB300(Z100) | PL/2062(?) | 2.9 | +3.369 | +3.667 | 147.999
BB TRUSS BRACKET | C250-C250/BB300(Z100) | PL/2059(?) | 2.9 | +3.369 | +3.667 | 147.999
PURLIN | C250-C250/BB300(Z200)-BB350(Z100) | PU/15(?) | 7.4 | +3.701 | +3.927 | 151.5
FASCIA | C250-C250/BB300(Z200) | F/14(?) | 8.1 | +3.558 | +3.710 | 64
BEAM | C250-C250/BB300(Z200) | B/72(?) | 19 | +3.336 | +3.636 | 96
PURLIN | C250-C250/BB300(Z150)-BB300(Z200) | PU/14(?) | 5.9 | +3.724 | +3.895 | 124.5
FASCIA | C250-C250/BB300(Z150) | F/14(?) | 8.1 | +3.536 | +3.688 | 64
BEAM | C250-C250/BB300(Z150) | B/72(?) | 19 | +3.356 | +3.656 | 96
PURLIN | C250-C250/BB300(Z100)-BB300(Z150) | PU/13(?) | 4.1 | +3.744 | +3.862 | 100.5
FASCIA | C250-C250/BB300(Z100) | F/14(?) | 8.1 | +3.513 | +3.665 | 64
BEAM | C250-C250/BB300(Z100) | B/72(?) | 19 | +3.365 | +3.665 | 96
FASCIA | C250-C250/BB250(Z200) | F/12(?) | 7.9 | +3.558 | +3.710 | 64
PURLIN | C250-C250/BB250(Z200)-BB300(Z100) | PU/15(?) | 7.4 | +3.672 | +3.899 | 151.5
2 x BRIDGING BRACKET | C250/BB250(Z200) | PL/152(?) | 1.5 | +3.353 | +3.573 | 6
BEAM | C250-C250/BB250(Z200) | B/70(?) | 15.3 | +3.336 | +3.590 | 76
FASCIA | C250-C250/BB250(Z150) | F/12(?) | 7.9 | +3.537 | +3.689 | 64
PURLIN | C250-C250/BB250(Z150)-BB250(Z200) | PU/14(?) | 5.9 | +3.696 | +3.867 | 124.5
2 x BRIDGING BRACKET | C250/BB250(Z150) | PL/152(?) | 1.5 | +3.375 | +3.595 | 6
BEAM | C250-C250/BB250(Z150) | B/70(?) | 15.3 | +3.358 | +3.612 | 76
FASCIA | C250-C250/BB250(Z100) | F/12(?) | 7.9 | +3.513 | +3.665 | 64
BB TRUSS BRACKET | C250-C250/BB250(Z100) | PL/2061(?) | 3.1 | +3.376 | +3.667 | 147.999
PURLIN | C250-C250/BB250(Z100)-BB250(Z150) | PU/13(?) | 4.1 | +3.716 | +3.834 | 100.5
2 x BRIDGING BRACKET | C250/BB250(Z100) | PL/152(?) | 1.5 | +3.393 | +3.613 | 6
BEAM | C250-C250/BB250(Z100) | B/70(?) | 15.3 | +3.376 | +3.630 | 76
BRIDGING-COLUMN STIFF | C200/BB300(Z200) | PL/111(?) | 2.6 | +3.360 | +3.710 | 64.2
BRIDGING-COLUMN STIFF | C200/BB300(Z150) | PL/111(?) | 2.6 | +3.339 | +3.689 | 64.2
BRIDGING-COLUMN STIFF | C200/BB300(Z100) | PL/111(?) | 2.6 | +3.315 | +3.665 | 64.2
BRIDGING-COLUMN STIFF | C200/BB250(Z200) | PL/111(?) | 2.6 | +3.360 | +3.710 | 64.2
BRIDGING-COLUMN STIFF | C200/BB250(Z150) | PL/111(?) | 2.6 | +3.339 | +3.689 | 64.2
BRIDGING-COLUMN STIFF | C200/BB250(Z100) | PL/111(?) | 2.6 | +3.315 | +3.665 | 64.2
BRIDGING-COLUMN STIFF | C200/BB200(Z200) | PL/111(?) | 2.6 | +3.360 | +3.710 | 64.2
BRIDGING-COLUMN STIFF | C200/BB200(Z150) | PL/111(?) | 2.6 | +3.339 | +3.689 | 64.2
BRIDGING-COLUMN STIFF | C200/BB200(Z100) | PL/111(?) | 2.6 | +3.315 | +3.665 | 64.2
2 x BRIDGING BRACKET | C200/BB300(Z200) | PL/218(?) | 1.7 | +3.392 | +3.662 | 6
2 x BRIDGING BRACKET | C200/BB300(Z150) | PL/218(?) | 1.7 | +3.404 | +3.674 | 6
2 x BRIDGING BRACKET | C200/BB300(Z100) | PL/218(?) | 1.7 | +3.380 | +3.650 | 6
BB TRUSS BRACKET | C200-C200/BB300(Z100) | PL/2057(?) | 1.7 | +3.420 | +3.644 | 147.999
BB TRUSS BRACKET | C200-C200/BB300(Z100) | PL/2054(?) | 1.7 | +3.420 | +3.644 | 147.999
BB TRUSS BRACKET | C200-C200/BB250(Z100) | PL/2056(?) | 1.9 | +3.413 | +3.644 | 147.999
BB TRUSS BRACKET | C200-C200/BB250(Z100) | PL/2053(?) | 1.9 | +3.413 | +3.644 | 147.999
GIRT | C200-C200/BB300(Z200) | G/11(?) | 11.3 | +3.065 | +3.216 | 151.5
GIRT | C200-C200/BB300(Z150) | G/10(?) | 8.9 | +3.078 | +3.202 | 124.5
GIRT | C200-C200/BB300(Z100) | G/9(?) | 6.6 | +3.090 | +3.190 | 100.5
GIRT | C200-C200/BB250(Z200) | G/11(?) | 11.3 | +3.065 | +3.216 | 151.5
GIRT | C200-C200/BB250(Z150) | G/10(?) | 8.9 | +3.078 | +3.202 | 124.5
GIRT | C200-C200/BB250(Z100) | G/9(?) | 6.6 | +3.090 | +3.190 | 100.5
GIRT | C200-C200/BB200(Z200) | G/11(?) | 11.3 | +3.065 | +3.216 | 151.5
GIRT | C200-C200/BB200(Z150) | G/10(?) | 8.9 | +3.078 | +3.202 | 124.5
GIRT | C200-C200/BB200(Z100) | G/9(?) | 6.6 | +3.090 | +3.190 | 100.5
PURLIN | C200-C200/BB300(Z200)-BB350(Z100) | PU/12(?) | 11.3 | +3.660 | +3.887 | 151.5
FASCIA | C200-C200/BB300(Z200) | F/16(?) | 8.9 | +3.558 | +3.710 | 64
BRIDGING BEAM | C200-C200/BB300(Z200) | BB/6(?) | 19 | +3.377 | +3.677 | 96
PURLIN | C200-C200/BB300(Z150)-BB300(Z200) | PU/11(?) | 8.9 | +3.684 | +3.855 | 124.5
FASCIA | C200-C200/BB300(Z150) | F/16(?) | 8.9 | +3.537 | +3.689 | 64
BRIDGING BEAM | C200-C200/BB300(Z150) | BB/6(?) | 19 | +3.389 | +3.689 | 96
PURLIN | C200-C200/BB300(Z100)-BB300(Z150) | PU/10(?) | 6.6 | +3.704 | +3.822 | 100.5
FASCIA | C200-C200/BB300(Z100) | F/16(?) | 8.9 | +3.513 | +3.665 | 64
BRIDGING BEAM | C200-C200/BB300(Z100) | BB/6(?) | 19 | +3.365 | +3.665 | 96
2 x BRIDGING BRACKET | C200/BB250(Z200) | PL/152(?) | 1.5 | +3.394 | +3.614 | 6
2 x BRIDGING BRACKET | C200/BB250(Z150) | PL/152(?) | 1.5 | +3.416 | +3.636 | 6
2 x BRIDGING BRACKET | C200/BB250(Z100) | PL/152(?) | 1.5 | +3.428 | +3.648 | 6
PURLIN | C200-C200/BB250(Z200)-BB300(Z100) | PU/12(?) | 11.3 | +3.660 | +3.887 | 151.5
FASCIA | C200-C200/BB250(Z200) | F/16(?) | 8.9 | +3.558 | +3.710 | 64
BRIDGING BEAM | C200-C200/BB250(Z200) | BB/4(?) | 15.3 | +3.377 | +3.631 | 76
PURLIN | C200-C200/BB250(Z150)-BB250(Z200) | PU/11(?) | 8.9 | +3.684 | +3.855 | 124.5
FASCIA | C200-C200/BB250(Z150) | F/16(?) | 8.9 | +3.537 | +3.689 | 64
BRIDGING BEAM | C200-C200/BB250(Z150) | BB/4(?) | 15.3 | +3.399 | +3.653 | 76
PURLIN | C200-C200/BB250(Z100)-BB250(Z150) | PU/10(?) | 6.6 | +3.704 | +3.822 | 100.5
FASCIA | C200-C200/BB250(Z100) | F/16(?) | 8.9 | +3.513 | +3.665 | 64
BRIDGING BEAM | C200-C200/BB250(Z100) | BB/4(?) | 15.3 | +3.411 | +3.665 | 76
BB TRUSS BRACKET | C200-C200/BB200(Z100) | PL/2055(?) | 1.9 | +3.413 | +3.644 | 147.999
BB TRUSS BRACKET | C200-C200/BB200(Z100) | PL/2052(?) | 1.9 | +3.413 | +3.644 | 147.999
2 x BRIDGING BRACKET | C200/BB200(Z200) | PL/214(?) | 1.2 | +3.394 | +3.564 | 6
PURLIN | C200-C200/BB200(Z200)-BB250(Z100) | PU/12(?) | 11.3 | +3.660 | +3.887 | 151.5
FASCIA | C200-C200/BB200(Z200) | F/16(?) | 8.9 | +3.558 | +3.710 | 64
BRIDGING BEAM | C200-C200/BB200(Z200) | BB/2(?) | 13.5 | +3.377 | +3.580 | 76
2 x BRIDGING BRACKET | C200/BB200(Z150) | PL/214(?) | 1.2 | +3.415 | +3.585 | 6
PURLIN | C200-C200/BB200(Z150)-BB200(Z200) | PU/11(?) | 8.9 | +3.684 | +3.855 | 124.5
FASCIA | C200-C200/BB200(Z150) | F/16(?) | 8.9 | +3.537 | +3.689 | 64
BRIDGING BEAM | C200-C200/BB200(Z150) | BB/2(?) | 13.5 | +3.399 | +3.602 | 76
2 x BRIDGING BRACKET | C200/BB200(Z100) | PL/214(?) | 1.2 | +3.433 | +3.603 | 6
PURLIN | C200-C200/BB200(Z100)-BB200(Z150) | PU/10(?) | 6.6 | +3.704 | +3.822 | 100.5
FASCIA | C200-C200/BB200(Z100) | F/16(?) | 8.9 | +3.513 | +3.665 | 64
BRIDGING BEAM | C200-C200/BB200(Z100) | BB/2(?) | 13.5 | +3.416 | +3.619 | 76
BRIDGING-COLUMN STIFF | C150/BB250(Z200) | PL/91(?) | 1.9 | +3.361 | +3.711 | 52.2
BRIDGING-COLUMN STIFF | C150/BB250(Z150) | PL/91(?) | 1.9 | +3.314 | +3.664 | 52.2
BRIDGING-COLUMN STIFF | C150/BB250(Z100) | PL/91(?) | 1.9 | +3.269 | +3.619 | 52.2
BRIDGING-COLUMN STIFF | C150/BB200(Z200) | PL/91(?) | 1.9 | +3.315 | +3.665 | 52.2
BRIDGING-COLUMN STIFF | C150/BB200(Z150) | PL/91(?) | 1.9 | +3.293 | +3.643 | 52.2
BRIDGING-COLUMN STIFF | C150/BB200(Z100) | PL/91(?) | 1.9 | +3.269 | +3.619 | 52.2
BB TRUSS BRACKET | C150-C150/BB200(Z100) | PL/2050(?) | 1.2 | +3.419 | +3.590 | 147.999
BB TRUSS BRACKET | C150-C150/BB200(Z100) | PL/2051(?) | 1.2 | +3.419 | +3.590 | 147.999
GIRT | C150-C150/BB250(Z200) | G/8(?) | 7.2 | +3.106 | +3.258 | 151.5
GIRT | C150-C150/BB250(Z150) | G/7(?) | 5.9 | +3.119 | +3.244 | 124.5
GIRT | C150-C150/BB250(Z100) | G/6(?) | 4.1 | +3.131 | +3.232 | 100.5
GIRT | C150-C150/BB200(Z200) | G/8(?) | 7.2 | +3.106 | +3.258 | 151.5
GIRT | C150-C150/BB200(Z150) | G/7(?) | 5.9 | +3.119 | +3.244 | 124.5
GIRT | C150-C150/BB200(Z100) | G/6(?) | 4.1 | +3.131 | +3.232 | 100.5
2 x BRIDGING BRACKET | C150/BB250(Z200) | PL/152(?) | 1.5 | +3.436 | +3.656 | 6
2 x BRIDGING BRACKET | C150/BB250(Z150) | PL/152(?) | 1.5 | +3.427 | +3.647 | 6
2 x BRIDGING BRACKET | C150/BB250(Z100) | PL/152(?) | 1.5 | +3.382 | +3.602 | 6
PURLIN | C150-C150/BB250(Z100)-BB250(Z150) | PU/7(?) | 4.1 | +3.634 | +3.752 | 100.5
PURLIN | C150-C150/BB250(Z200)-BB300(Z100) | PU/9(?) | 7.2 | +3.637 | +3.863 | 151.5
FASCIA | C150-C150/BB250(Z200) | F/11(?) | 7.7 | +3.559 | +3.711 | 64
PURLIN | C150-C150/BB250(Z150)-BB250(Z200) | PU/8(?) | 5.9 | +3.635 | +3.807 | 124.5
FASCIA | C150-C150/BB250(Z150) | F/11(?) | 7.7 | +3.512 | +3.664 | 64
FASCIA | C150-C150/BB250(Z100) | F/11(?) | 7.7 | +3.467 | +3.619 | 64
2 x BRIDGING BRACKET | C150/BB200(Z200) | PL/214(?) | 1.2 | +3.389 | +3.559 | 6
PURLIN | C150-C150/BB200(Z200)-BB250(Z100) | PU/9(?) | 7.2 | +3.591 | +3.817 | 151.5
FASCIA | C150-C150/BB200(Z200) | F/11(?) | 7.7 | +3.513 | +3.665 | 64
2 x BRIDGING BRACKET | C150/BB200(Z150) | PL/214(?) | 1.2 | +3.411 | +3.581 | 6
PURLIN | C150-C150/BB200(Z150)-BB200(Z200) | PU/8(?) | 5.9 | +3.614 | +3.785 | 124.5
FASCIA | C150-C150/BB200(Z150) | F/11(?) | 7.7 | +3.491 | +3.643 | 64
2 x BRIDGING BRACKET | C150/BB200(Z100) | PL/214(?) | 1.2 | +3.433 | +3.603 | 6
PURLIN | C150-C150/BB200(Z100)-BB200(Z150) | PU/7(?) | 4.1 | +3.634 | +3.752 | 100.5
FASCIA | C150-C150/BB200(Z100) | F/11(?) | 7.7 | +3.467 | +3.619 | 64
2 x RAFTER | C350/BB350(TH120)> | Z/3706 | 10.8 | +3.261 | +3.731 | 125
COLUMN | C350/BB350(TH120) | Z/3711 | 54.5 | +0.000 | +3.643 | 125
2 x PLATE | C350/BB350(TH120)> | Z/2563 | 9.9 | +3.114 | +3.678 | 133.5
COLUMN | C350/BB350(TH120) | Z/3708 | 54.5 | +0.000 | +3.643 | 125
2 x RAFTER | C350/BB350(TH96)-BB350(TH120) | Z/3706 | 10.8 | +3.281 | +3.751 | 125
COLUMN | C350/BB350(TH96) | Z/3710 | 54.5 | +0.000 | +3.643 | 125
2 x PLATE | C350/BB350(TH96)-BB350(TH120) | Z/2563 | 9.9 | +3.134 | +3.698 | 133.5
COLUMN | C350/BB350(TH96) | Z/3707 | 54.5 | +0.000 | +3.643 | 125
2 x RAFTER | C350/BB350(TH75)-BB350(TH96) | Z/3706 | 10.8 | +3.298 | +3.769 | 125
COLUMN | C350/BB350(TH75) | Z/3709 | 54.5 | +0.000 | +3.643 | 125
2 x PLATE | C350/BB350(TH75)-BB350(TH96) | Z/2563 | 9.9 | +3.151 | +3.716 | 133.5
COLUMN | C350/BB350(TH75) | Z/3705 | 54.5 | +0.000 | +3.643 | 125
BRIDGING U-PLATE | C350-C350/BB350(TH120) | PL/2033 | 4.4 | +3.257 | +3.615 | 358
RAFTER | C350-C350/BB350(TH120)> | Z/2606 | 10.8 | +3.261 | +3.731 | 125
BB TRUSS BRACKET | C350-C350/BB350(TH120)> | PL/2558 | 5.4 | +3.261 | +3.669 | 147.699
BB TRUSS BRACKET | C350-C350/BB350(TH120)> | PL/2560 | 5.4 | +3.261 | +3.669 | 147.699
BRIDGING U-PLATE | C350-C350/BB350(TH96) | PL/2033 | 4.4 | +3.277 | +3.635 | 358
RAFTER | C350-C350/BB350(TH96)-BB350(TH120) | Z/2606 | 10.8 | +3.281 | +3.751 | 125
BB TRUSS BRACKET | C350-C350/BB350(TH96)-BB350(TH120) | PL/2558 | 5.4 | +3.281 | +3.689 | 147.699
BB TRUSS BRACKET | C350-C350/BB350(TH96)-BB350(TH120) | PL/2560 | 5.4 | +3.281 | +3.689 | 147.699
2 x RAFTER | C300/BB350(TH120)> | Z/3695 | 8.9 | +3.302 | +3.722 | 96
COLUMN | C300/BB350(TH120) | Z/3697 | 45.6 | +0.000 | +3.644 | 96
2 x PLATE | C300/BB350(TH120)> | Z/2548 | 8.7 | +3.115 | +3.671 | 104.5
COLUMN | C300/BB350(TH120) | Z/3702 | 45.6 | +0.000 | +3.644 | 96
2 x RAFTER | C300/BB350(TH96)-BB350(TH120) | Z/3695 | 8.9 | +3.298 | +3.718 | 96
COLUMN | C300/BB350(TH96) | Z/3699 | 45.3 | +0.000 | +3.619 | 96
2 x PLATE | C300/BB350(TH96)-BB350(TH120) | Z/2548 | 8.7 | +3.111 | +3.666 | 104.5
COLUMN | C300/BB350(TH96) | Z/3704 | 45.3 | +0.000 | +3.619 | 96
2 x RAFTER | C300/BB350(TH75)-BB350(TH96) | Z/3695 | 8.9 | +3.294 | +3.714 | 96
COLUMN | C300/BB350(TH75) | Z/3698 | 45 | +0.000 | +3.598 | 96
2 x PLATE | C300/BB350(TH75)-BB350(TH96) | Z/2548 | 8.7 | +3.107 | +3.663 | 104.5
COLUMN | C300/BB350(TH75) | Z/3703 | 45 | +0.000 | +3.598 | 96
2 x RAFTER | C300/BB300(TH120)-BB350(TH75) | Z/3695 | 8.9 | +3.302 | +3.722 | 96
COLUMN | C300/BB300(TH120) | Z/3697 | 45.6 | +0.000 | +3.644 | 96
2 x PLATE | C300/BB300(TH120)-BB350(TH75) | Z/2548 | 8.7 | +3.115 | +3.671 | 104.5
COLUMN | C300/BB300(TH120) | Z/3702 | 45.6 | +0.000 | +3.644 | 96
2 x RAFTER | C300/BB300(TH96)-BB300(TH120) | Z/3695 | 8.9 | +3.323 | +3.742 | 96
COLUMN | C300/BB300(TH96) | Z/3696 | 45.6 | +0.000 | +3.644 | 96
2 x PLATE | C300/BB300(TH96)-BB300(TH120) | Z/2548 | 8.7 | +3.135 | +3.691 | 104.5
COLUMN | C300/BB300(TH96) | Z/3701 | 45.6 | +0.000 | +3.644 | 96
2 x RAFTER | C300/BB300(TH75)-BB300(TH96) | Z/3695 | 8.9 | +3.340 | +3.760 | 96
COLUMN | C300/BB300(TH75) | Z/3700 | 45.6 | +0.000 | +3.644 | 96
2 x PLATE | C300/BB300(TH75)-BB300(TH96) | Z/2548 | 8.7 | +3.153 | +3.709 | 104.5
COLUMN | C300/BB300(TH75) | Z/3694 | 45.6 | +0.000 | +3.644 | 96
BRIDGING U-PLATE | C300-C300/BB350(TH120) | PL/2553 | 4.4 | +3.290 | +3.648 | 129
RAFTER | C300-C300/BB350(TH120)> | Z/2599 | 8.9 | +3.302 | +3.722 | 96
BB TRUSS BRACKET | C300-C300/BB350(TH120)> | PL/2549 | 4.3 | +3.294 | +3.661 | 147.699
BB TRUSS BRACKET | C300-C300/BB350(TH120)> | PL/2556 | 4.3 | +3.294 | +3.661 | 147.699
BRIDGING U-PLATE | C300-C300/BB350(TH96) | PL/2552 | 4.4 | +3.265 | +3.623 | 129
RAFTER | C300-C300/BB350(TH96)-BB350(TH120) | Z/2599 | 8.9 | +3.298 | +3.718 | 96
BB TRUSS BRACKET | C300-C300/BB350(TH96)-BB350(TH120) | PL/2549 | 4.3 | +3.290 | +3.657 | 147.699
BB TRUSS BRACKET | C300-C300/BB350(TH96)-BB350(TH120) | PL/2556 | 4.3 | +3.290 | +3.657 | 147.699
BRIDGING U-PLATE | C300-C300/BB300(TH120) | PL/2555 | 3.6 | +3.299 | +3.607 | 100
RAFTER | C300-C300/BB300(TH120)-BB350(TH75) | Z/2599 | 8.9 | +3.302 | +3.722 | 96
BB TRUSS BRACKET | C300-C300/BB300(TH120)-BB350(TH75) | PL/2550 | 4.4 | +3.306 | +3.661 | 147.699
BB TRUSS BRACKET | C300-C300/BB300(TH120)-BB350(TH75) | PL/2557 | 4.4 | +3.306 | +3.661 | 147.699
BRIDGING U-PLATE | C300-C300/BB300(TH96) | PL/2555 | 3.6 | +3.319 | +3.627 | 100
RAFTER | C300-C300/BB300(TH96)-BB300(TH120) | Z/2599 | 8.9 | +3.323 | +3.742 | 96
BB TRUSS BRACKET | C300-C300/BB300(TH96)-BB300(TH120) | PL/2550 | 4.4 | +3.326 | +3.681 | 147.699
BB TRUSS BRACKET | C300-C300/BB300(TH96)-BB300(TH120) | PL/2557 | 4.4 | +3.326 | +3.681 | 147.699
2 x RAFTER | C250/BB350(TH120)> | Z/3688 | 5.9 | +3.352 | +3.729 | 76
COLUMN | C250/BB350(TH120) | Z/3690 | 29.2 | +0.000 | +3.643 | 76
2 x PLATE | C250/BB350(TH120) | Z/2538 | 5.2 | +3.242 | +3.655 | 84.5
COLUMN | C250/BB350(TH120) | Z/3693 | 29.2 | +0.000 | +3.643 | 76
2 x RAFTER | C250/BB350(TH96)-BB350(TH120) | Z/3688 | 5.9 | +3.371 | +3.748 | 76
COLUMN | C250/BB350(TH96) | Z/3689 | 29.2 | +0.000 | +3.643 | 76
2 x PLATE | C250/BB350(TH96) | Z/2538 | 5.2 | +3.262 | +3.674 | 84.5
COLUMN | C250/BB350(TH96) | Z/3692 | 29.2 | +0.000 | +3.643 | 76
2 x RAFTER | C250/BB350(TH75)-BB350(TH96) | Z/3688 | 5.9 | +3.388 | +3.765 | 76
COLUMN | C250/BB350(TH75) | Z/3687 | 29.2 | +0.000 | +3.643 | 76
2 x PLATE | C250/BB350(TH75) | Z/2538 | 5.2 | +3.279 | +3.691 | 84.5
COLUMN | C250/BB350(TH75) | Z/3691 | 29.2 | +0.000 | +3.643 | 76
2 x RAFTER | C250/BB300(TH120)-BB350(TH75) | Z/3688 | 5.9 | +3.352 | +3.729 | 76
COLUMN | C250/BB300(TH120) | Z/3690 | 29.2 | +0.000 | +3.643 | 76
2 x PLATE | C250/BB300(TH120) | Z/2538 | 5.2 | +3.242 | +3.655 | 84.5
COLUMN | C250/BB300(TH120) | Z/3693 | 29.2 | +0.000 | +3.643 | 76
2 x RAFTER | C250/BB300(TH96)-BB300(TH120) | Z/3688 | 5.9 | +3.371 | +3.748 | 76
COLUMN | C250/BB300(TH96) | Z/3689 | 29.2 | +0.000 | +3.643 | 76
2 x PLATE | C250/BB300(TH96) | Z/2538 | 5.2 | +3.262 | +3.674 | 84.5
COLUMN | C250/BB300(TH96) | Z/3692 | 29.2 | +0.000 | +3.643 | 76
2 x RAFTER | C250/BB300(TH75)-BB300(TH96) | Z/3688 | 5.9 | +3.388 | +3.765 | 76
COLUMN | C250/BB300(TH75) | Z/3687 | 29.2 | +0.000 | +3.643 | 76
2 x PLATE | C250/BB300(TH75) | Z/2538 | 5.2 | +3.279 | +3.691 | 84.5
COLUMN | C250/BB300(TH75) | Z/3691 | 29.2 | +0.000 | +3.643 | 76
2 x RAFTER | C250/BB250(TH120)-BB300(TH75) | Z/3688 | 5.9 | +3.352 | +3.729 | 76
COLUMN | C250/BB250(TH120) | Z/3690 | 29.2 | +0.000 | +3.643 | 76
2 x PLATE | C250/BB250(TH120) | Z/2538 | 5.2 | +3.242 | +3.655 | 84.5
COLUMN | C250/BB250(TH120) | Z/3693 | 29.2 | +0.000 | +3.643 | 76
2 x RAFTER | C250/BB250(TH96)-BB250(TH120) | Z/3688 | 5.9 | +3.372 | +3.748 | 76
COLUMN | C250/BB250(TH96) | Z/3689 | 29.2 | +0.000 | +3.643 | 76
2 x PLATE | C250/BB250(TH96) | Z/2538 | 5.2 | +3.262 | +3.675 | 84.5
COLUMN | C250/BB250(TH96) | Z/3692 | 29.2 | +0.000 | +3.643 | 76
2 x RAFTER | C250/BB250(TH75)-BB250(TH96) | Z/3688 | 5.9 | +3.389 | +3.765 | 76
COLUMN | C250/BB250(TH75) | Z/3691 | 29.2 | +0.000 | +3.643 | 76
2 x PLATE | C250/BB250(TH75) | Z/2538 | 5.2 | +3.279 | +3.692 | 84.5
COLUMN | C250/BB250(TH75) | Z/3687 | 29.2 | +0.000 | +3.643 | 76
BRIDGING U-PLATE | C250-C250/BB350(TH120) | PL/2024 | 4.4 | +3.289 | +3.647 | 129
RAFTER | C250-C250/BB350(TH120)> | Z/2591 | 5.9 | +3.352 | +3.729 | 76
BB TRUSS BRACKET | C250-C250/BB350(TH120) | PL/2541 | 2.6 | +3.355 | +3.643 | 147.999
BB TRUSS BRACKET | C250-C250/BB350(TH120) | PL/2548 | 2.6 | +3.355 | +3.643 | 147.999
BRIDGING U-PLATE | C250-C250/BB350(TH96) | PL/2023 | 4.4 | +3.289 | +3.647 | 129
RAFTER | C250-C250/BB350(TH96)-BB350(TH120) | Z/2591 | 5.9 | +3.371 | +3.748 | 76
BB TRUSS BRACKET | C250-C250/BB350(TH96) | PL/2541 | 2.6 | +3.374 | +3.663 | 147.999
BB TRUSS BRACKET | C250-C250/BB350(TH96) | PL/2548 | 2.6 | +3.374 | +3.663 | 147.999
BRIDGING U-PLATE | C250-C250/BB300(TH120) | PL/2545 | 3.6 | +3.339 | +3.647 | 100
RAFTER | C250-C250/BB300(TH120)-BB350(TH75) | Z/2591 | 5.9 | +3.352 | +3.729 | 76
BB TRUSS BRACKET | C250-C250/BB300(TH120) | PL/2540 | 2.9 | +3.345 | +3.643 | 147.999
BB TRUSS BRACKET | C250-C250/BB300(TH120) | PL/2547 | 2.9 | +3.345 | +3.643 | 147.999
BRIDGING U-PLATE | C250-C250/BB300(TH96) | PL/2544 | 3.6 | +3.339 | +3.647 | 100
RAFTER | C250-C250/BB300(TH96)-BB300(TH120) | Z/2591 | 5.9 | +3.371 | +3.748 | 76
BB TRUSS BRACKET | C250-C250/BB300(TH96) | PL/2540 | 2.9 | +3.364 | +3.663 | 147.999
BB TRUSS BRACKET | C250-C250/BB300(TH96) | PL/2547 | 2.9 | +3.364 | +3.663 | 147.999
BRIDGING U-PLATE | C250-C250/BB250(TH120) | PL/2018 | 2.9 | +3.350 | +3.612 | 80
RAFTER | C250-C250/BB250(TH120)-BB300(TH75) | Z/2591 | 5.9 | +3.352 | +3.729 | 76
BB TRUSS BRACKET | C250-C250/BB250(TH120) | PL/2546 | 3.1 | +3.354 | +3.643 | 147.999
BB TRUSS BRACKET | C250-C250/BB250(TH120) | PL/2539 | 3.1 | +3.354 | +3.643 | 147.999
BRIDGING U-PLATE | C250-C250/BB250(TH96) | PL/2542 | 2.9 | +3.365 | +3.627 | 80
RAFTER | C250-C250/BB250(TH96)-BB250(TH120) | Z/2591 | 5.9 | +3.372 | +3.748 | 76
BB TRUSS BRACKET | C250-C250/BB250(TH96) | PL/2546 | 3.1 | +3.374 | +3.663 | 147.999
BB TRUSS BRACKET | C250-C250/BB250(TH96) | PL/2539 | 3.1 | +3.374 | +3.663 | 147.999
BRIDGING U-PLATE | C200-C200/BB300(TH120) | PL/2535 | 3.6 | +3.339 | +3.647 | 308
RAFTER | C200-C200/BB300(TH120)-BB350(TH75) | R/93 | 3.9 | +3.380 | +3.676 | 76
BB TRUSS BRACKET | C200-C200/BB300(TH120) | PL/2529 | 1.7 | +3.383 | +3.607 | 147.999
BB TRUSS BRACKET | C200-C200/BB300(TH120) | PL/2538 | 1.7 | +3.383 | +3.607 | 147.999
BRIDGING U-PLATE | C200-C200/BB300(TH96) | PL/2534 | 3.6 | +3.339 | +3.647 | 308
RAFTER | C200-C200/BB300(TH96)-BB300(TH120) | R/93 | 3.9 | +3.400 | +3.696 | 76
BB TRUSS BRACKET | C200-C200/BB300(TH96) | PL/2529 | 1.7 | +3.403 | +3.627 | 147.999
BB TRUSS BRACKET | C200-C200/BB300(TH96) | PL/2538 | 1.7 | +3.403 | +3.627 | 147.999
BRIDGING U-PLATE | C200-C200/BB250(TH120) | PL/2532 | 2.9 | +3.375 | +3.637 | 262
RAFTER | C200-C200/BB250(TH120)-BB300(TH75) | R/93 | 3.9 | +3.380 | +3.676 | 76
BB TRUSS BRACKET | C200-C200/BB250(TH120) | PL/2528 | 1.9 | +3.376 | +3.607 | 147.999
BB TRUSS BRACKET | C200-C200/BB250(TH120) | PL/2537 | 1.9 | +3.376 | +3.607 | 147.999
BRIDGING U-PLATE | C200-C200/BB250(TH96) | PL/2010 | 2.9 | +3.385 | +3.647 | 262
RAFTER | C200-C200/BB250(TH96)-BB250(TH120) | R/93 | 3.9 | +3.400 | +3.696 | 76
BB TRUSS BRACKET | C200-C200/BB250(TH96) | PL/2528 | 1.9 | +3.396 | +3.627 | 147.999
BB TRUSS BRACKET | C200-C200/BB250(TH96) | PL/2537 | 1.9 | +3.396 | +3.627 | 147.999
BRIDGING U-PLATE | C200-C200/BB200(TH120) | PL/2530 | 2.6 | +3.376 | +3.587 | 211
RAFTER | C200-C200/BB200(TH120)-BB250(TH75) | R/93 | 3.9 | +3.380 | +3.676 | 76
BB TRUSS BRACKET | C200-C200/BB200(TH120) | PL/2527 | 1.9 | +3.376 | +3.607 | 147.999
BB TRUSS BRACKET | C200-C200/BB200(TH120) | PL/2536 | 1.9 | +3.376 | +3.607 | 147.999
BRIDGING U-PLATE | C200-C200/BB200(TH96) | PL/2530 | 2.6 | +3.396 | +3.607 | 211
RAFTER | C200-C200/BB200(TH96)-BB200(TH120) | R/93 | 3.9 | +3.400 | +3.696 | 76
BB TRUSS BRACKET | C200-C200/BB200(TH96) | PL/2527 | 1.9 | +3.396 | +3.627 | 147.999
