Properties of the parts of a building model (IFC2X3), part 4 of 4

# IfcPlate: PLT3*310 (66)
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
BRIDGING U-PLATE | PL/2531 | +3.385 | +3.647 | 2.9 | 86.7 | 0.3 | 405.3 | 0.258153 | 0.125636 | 0.000379252
BRIDGING U-PLATE | PL/2530 | +3.376 | +3.587 | 2.6 | 86.9 | 0.2 | 354.3 | 0.226227 | 0.109826 | 0.000331822
BRIDGING U-PLATE | PL/2530 | +3.396 | +3.607 | 2.6 | 86.9 | 0.2 | 354.3 | 0.226227 | 0.109826 | 0.000331822
BRIDGING U-PLATE | PL/2033 | +3.257 | +3.615 | 4.4 | 86.3 | 0.3 | 599.3 | 0.379597 | 0.185776 | 0.000559672
BRIDGING U-PLATE | PL/2530 | +3.414 | +3.625 | 2.6 | 86.9 | 0.2 | 354.3 | 0.226227 | 0.109826 | 0.000331822
BRIDGING U-PLATE | PL/2525 | +3.385 | +3.647 | 2.9 | 86.7 | 0.3 | 405.3 | 0.258153 | 0.125636 | 0.000379252
BRIDGING U-PLATE | PL/2524 | +3.361 | +3.623 | 2.9 | 86.7 | 0.3 | 405.3 | 0.258153 | 0.125636 | 0.000379252
BRIDGING U-PLATE | PL/2523 | +3.339 | +3.601 | 2.9 | 86.7 | 0.3 | 405.3 | 0.258153 | 0.125636 | 0.000379252
BRIDGING U-PLATE | PL/1999 | +3.371 | +3.582 | 2.6 | 86.9 | 0.2 | 354.3 | 0.226227 | 0.109826 | 0.000331822
BRIDGING U-PLATE | PL/1999 | +3.390 | +3.601 | 2.6 | 86.9 | 0.2 | 354.3 | 0.226227 | 0.109826 | 0.000331822
BRIDGING U-PLATE | PL/2522 | +3.390 | +3.601 | 2.6 | 86.9 | 0.2 | 354.3 | 0.226227 | 0.109826 | 0.000331822

# IfcPlate: PLT3*313.3 (24)
In: Undefined
Description: PLT3*313.3; Material: STEEL/G450
Tekla Common - Phase: 1; Class: 11
Tekla Quantity - Weight: 2.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.7 m2; Net surface area: 0.2 m2; Height: 313.3 mm; Width: 3 mm; Length: 445.2 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 313.286 mm; NetArea: 0.21672 m2; GrossArea: 0.139471 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000318273 m3; GrossVolume: 0.000318273 m3
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation
2 x PLATE | Z/2453(?) | +3.312 | +3.607
2 x PLATE | Z/2453(?) | +3.309 | +3.603
4 x PLATE | Z/2453(?) | +3.306 | +3.600
2 x PLATE | Z/2453(?) | +3.266 | +3.561
2 x PLATE | Z/2453(?) | +3.287 | +3.582
2 x PLATE | Z/2453 | +3.315 | +3.609
2 x PLATE | Z/2453 | +3.310 | +3.605
4 x PLATE | Z/2453 | +3.307 | +3.601
2 x PLATE | Z/2453 | +3.269 | +3.563
2 x PLATE | Z/2453 | +3.289 | +3.584

# IfcPlate: PLT3*332.1 (36)
In: Undefined
Description: PLT3*332.1; Material: STEEL/G450
Tekla Common - Phase: 1; Class: 11
Tekla Quantity - Weight: 2.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.7 m2; Net surface area: 0.3 m2; Height: 332.1 mm; Width: 3 mm; Length: 487.7 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 332.119 mm; NetArea: 0.261745 m2; GrossArea: 0.16196 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000385111 m3; GrossVolume: 0.000385111 m3
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation
6 x PLATE | Z/2525(?) | +3.312 | +3.616
6 x PLATE | Z/2525(?) | +3.333 | +3.637
6 x PLATE | Z/2525(?) | +3.351 | +3.655
6 x PLATE | Z/2525 | +3.314 | +3.618
6 x PLATE | Z/2525 | +3.334 | +3.638
6 x PLATE | Z/2525 | +3.352 | +3.656

# IfcPlate: PLT3*350 (36)
In: Undefined
Description: PLT3*350; Material: STEEL/450
Tekla Common - Phase: 1; Class: 2
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.3 m2; Height: 350 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 350 mm; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
BRIDGING-COLUMN STIFF | PL/118(?) | +3.360 | +3.710 | 4.4 | 86.3 | 549.3 | 0.392812 | 0.192248 | 0.000579389
BRIDGING-COLUMN STIFF | PL/118(?) | +3.338 | +3.688 | 4.4 | 86.3 | 549.3 | 0.392812 | 0.192248 | 0.000579389
BRIDGING-COLUMN STIFF | PL/118(?) | +3.314 | +3.664 | 4.4 | 86.3 | 549.3 | 0.392812 | 0.192248 | 0.000579389
2 x BRIDGING-COLUMN STIFF | PL/117(?) | +3.361 | +3.711 | 3.7 | 86.5 | 441.3 | 0.316564 | 0.154448 | 0.000465989
BRIDGING-COLUMN STIFF | PL/117(?) | +3.315 | +3.665 | 3.7 | 86.5 | 441.3 | 0.316564 | 0.154448 | 0.000465989
BRIDGING-COLUMN STIFF | PL/117(?) | +3.270 | +3.620 | 3.7 | 86.5 | 441.3 | 0.316564 | 0.154448 | 0.000465989
BRIDGING-COLUMN STIFF | PL/117(?) | +3.339 | +3.689 | 3.7 | 86.5 | 441.3 | 0.316564 | 0.154448 | 0.000465989
BRIDGING-COLUMN STIFF | PL/117(?) | +3.316 | +3.666 | 3.7 | 86.5 | 441.3 | 0.316564 | 0.154448 | 0.000465989
3 x BRIDGING-COLUMN STIFF | PL/114(?) | +3.360 | +3.710 | 2.9 | 86.7 | 358.9 | 0.25839 | 0.125608 | 0.000379469
2 x BRIDGING-COLUMN STIFF | PL/114(?) | +3.338 | +3.688 | 2.9 | 86.7 | 358.9 | 0.25839 | 0.125608 | 0.000379469
3 x BRIDGING-COLUMN STIFF | PL/114(?) | +3.315 | +3.665 | 2.9 | 86.7 | 358.9 | 0.25839 | 0.125608 | 0.000379469
BRIDGING-COLUMN STIFF | PL/114(?) | +3.339 | +3.689 | 2.9 | 86.7 | 358.9 | 0.25839 | 0.125608 | 0.000379469
3 x BRIDGING-COLUMN STIFF | PL/118 | +3.293 | +3.643 | 4.4 | 86.3 | 549.3 | 0.392812 | 0.192248 | 0.000579389
4 x BRIDGING-COLUMN STIFF | PL/117 | +3.294 | +3.644 | 3.7 | 86.5 | 441.3 | 0.316564 | 0.154448 | 0.000465989
BRIDGING-COLUMN STIFF | PL/117 | +3.269 | +3.619 | 3.7 | 86.5 | 441.3 | 0.316564 | 0.154448 | 0.000465989
BRIDGING-COLUMN STIFF | PL/117 | +3.248 | +3.598 | 3.7 | 86.5 | 441.3 | 0.316564 | 0.154448 | 0.000465989
9 x BRIDGING-COLUMN STIFF | PL/114 | +3.293 | +3.643 | 2.9 | 86.7 | 358.9 | 0.25839 | 0.125608 | 0.000379469

# IfcPlate: PLT3*354.7 (12)
In: Undefined
Description: PLT3*354.7; Material: STEEL/450
Tekla Common - Phase: 1; Class: 9
Tekla Quantity - Weight: 5.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.2 m2; Net surface area: 0.5 m2; Height: 354.7 mm; Width: 3 mm; Length: 721.5 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 354.718 mm; CrossSectionArea: 0.000009 m2; GrossVolume: 0.000694253 m3
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | NetArea (m2) | GrossArea (m2) | NetVolume (m3)
BB TRUSS BRACKET | PL/2069(?) | +3.258 | +3.666 | 0.462226 | 0.255936 | 0.000683368
BB TRUSS BRACKET | PL/2068(?) | +3.258 | +3.666 | 0.462226 | 0.255936 | 0.000683368
BB TRUSS BRACKET | PL/2069(?) | +3.279 | +3.687 | 0.462226 | 0.255936 | 0.000683368
BB TRUSS BRACKET | PL/2068(?) | +3.279 | +3.687 | 0.462226 | 0.255936 | 0.000683368
BB TRUSS BRACKET | PL/2069(?) | +3.297 | +3.705 | 0.462226 | 0.255936 | 0.000683368
BB TRUSS BRACKET | PL/2068(?) | +3.297 | +3.705 | 0.462226 | 0.255936 | 0.000683368
BB TRUSS BRACKET | PL/2558 | +3.261 | +3.669 | 0.462174 | 0.255929 | 0.000683292
BB TRUSS BRACKET | PL/2560 | +3.261 | +3.669 | 0.462174 | 0.255929 | 0.000683292
BB TRUSS BRACKET | PL/2558 | +3.281 | +3.689 | 0.462174 | 0.255929 | 0.000683292
BB TRUSS BRACKET | PL/2560 | +3.281 | +3.689 | 0.462174 | 0.255929 | 0.000683292
BB TRUSS BRACKET | PL/2558 | +3.298 | +3.706 | 0.462173 | 0.255929 | 0.00068329
BB TRUSS BRACKET | PL/2560 | +3.298 | +3.706 | 0.462173 | 0.255929 | 0.00068329

# IfcPlate: PLT3*428.1 (36)
In: Undefined
Description: PLT3*428.1; Material: STEEL/G450
Tekla Common - Phase: 1; Class: 11
Tekla Quantity - Weight: 5.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.2 m2; Height: 428.1 mm; Width: 3 mm; Length: 645.3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 428.068 mm; NetArea: 0.445095 m2; GrossArea: 0.276216 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000657872 m3; GrossVolume: 0.000657872 m3
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Net surface area (m2)
4 x PLATE | Z/2538(?) | +3.227 | +3.639 | 0.5
4 x PLATE | Z/2538(?) | +3.248 | +3.660 | 0.5
6 x PLATE | Z/2538(?) | +3.266 | +3.679 | 0.5
2 x PLATE | Z/2538(?) | +3.227 | +3.640 | 0.5
2 x PLATE | Z/2538(?) | +3.248 | +3.661 | 0.5
6 x PLATE | Z/2538 | +3.242 | +3.655 | 0.3
4 x PLATE | Z/2538 | +3.262 | +3.674 | 0.3
4 x PLATE | Z/2538 | +3.279 | +3.691 | 0.3
2 x PLATE | Z/2538 | +3.262 | +3.675 | 0.3
2 x PLATE | Z/2538 | +3.279 | +3.692 | 0.3

# IfcPlate: PLT3*566.6 (24)
In: Undefined
Description: PLT3*566.6; Material: STEEL/G450
Tekla Common - Phase: 1; Class: 11
Tekla Quantity - Weight: 8.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.9 m2; Net surface area: 0.7 m2; Height: 566.6 mm; Width: 3 mm; Length: 839.6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 566.553 mm; NetArea: 0.747131 m2; GrossArea: 0.475651 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00110801 m3; GrossVolume: 0.00110801 m3
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation
4 x PLATE | Z/2548(?) | +3.113 | +3.668
2 x PLATE | Z/2548(?) | +3.109 | +3.665
2 x PLATE | Z/2548(?) | +3.106 | +3.662
2 x PLATE | Z/2548(?) | +3.134 | +3.689
2 x PLATE | Z/2548(?) | +3.152 | +3.708
4 x PLATE | Z/2548 | +3.115 | +3.671
2 x PLATE | Z/2548 | +3.111 | +3.666
2 x PLATE | Z/2548 | +3.107 | +3.663
2 x PLATE | Z/2548 | +3.135 | +3.691
2 x PLATE | Z/2548 | +3.153 | +3.709

# IfcPlate: PLT3*605.6 (6)
In: Undefined
Description: PLT3*605.6; Material: STEEL/G450
Default - ASSEMBLY_POS: Z/2563
Tekla Common - Phase: 1; Class: 11
Tekla Quantity - Weight: 9.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.9 m2; Net surface area: 1 m2; Height: 605.6 mm; Width: 3 mm; Length: 889.3 mm
Pset_PlateCommon - LoadBearing: no; Reference: Z/2563
BaseQuantities - Width: 605.596 mm; NetArea: 0.853405 m2; GrossArea: 0.538543 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00126655 m3; GrossVolume: 0.00126655 m3
Name | Bottom elevation | Top elevation
2 x PLATE | +3.114 | +3.678
2 x PLATE | +3.134 | +3.698
2 x PLATE | +3.151 | +3.716

# IfcPlate: PLT6*145 (132)
In: Undefined
Description: PLT6*145; Material: STEEL/250
Tekla Common - Phase: 1; Class: 9
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.1 m2; Height: 145 mm; Width: 6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 145 mm; CrossSectionArea: 0.000036 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
2 x BRIDGING BRACKET | PL/218(?) | +3.315 | +3.585 | 1.7 | 45.2 | 270 | 0.08328 | 0.03915 | 0.0002349
2 x BRIDGING BRACKET | PL/218(?) | +3.336 | +3.606 | 1.7 | 45.2 | 270 | 0.08328 | 0.03915 | 0.0002349
2 x BRIDGING BRACKET | PL/218(?) | +3.354 | +3.624 | 1.7 | 45.2 | 270 | 0.08328 | 0.03915 | 0.0002349
4 x BRIDGING BRACKET | PL/218(?) | +3.380 | +3.650 | 1.7 | 45.2 | 270 | 0.08328 | 0.03915 | 0.0002349
2 x BRIDGING BRACKET | PL/218(?) | +3.371 | +3.641 | 1.7 | 45.2 | 270 | 0.08328 | 0.03915 | 0.0002349
2 x BRIDGING BRACKET | PL/218(?) | +3.351 | +3.621 | 1.7 | 45.2 | 270 | 0.08328 | 0.03915 | 0.0002349
2 x BRIDGING BRACKET | PL/1998(?) | +3.330 | +3.650 | 2.2 | 45 | 320 | 0.09838 | 0.0464 | 0.0002784
2 x BRIDGING BRACKET | PL/1998(?) | +3.353 | +3.673 | 2.2 | 45 | 320 | 0.09838 | 0.0464 | 0.0002784
2 x BRIDGING BRACKET | PL/1998(?) | +3.351 | +3.671 | 2.2 | 45 | 320 | 0.09838 | 0.0464 | 0.0002784
2 x BRIDGING BRACKET | PL/1998(?) | +3.315 | +3.635 | 2.2 | 45 | 320 | 0.09838 | 0.0464 | 0.0002784
4 x BRIDGING BRACKET | PL/1998(?) | +3.312 | +3.632 | 2.2 | 45 | 320 | 0.09838 | 0.0464 | 0.0002784
2 x BRIDGING BRACKET | PL/1998(?) | +3.285 | +3.605 | 2.2 | 45 | 320 | 0.09838 | 0.0464 | 0.0002784
2 x BRIDGING BRACKET | PL/1998(?) | +3.294 | +3.614 | 2.2 | 45 | 320 | 0.09838 | 0.0464 | 0.0002784
2 x BRIDGING BRACKET | PL/1998(?) | +3.273 | +3.593 | 2.2 | 45 | 320 | 0.09838 | 0.0464 | 0.0002784
2 x BRIDGING BRACKET | PL/152(?) | +3.353 | +3.573 | 1.5 | 45.4 | 220 | 0.06818 | 0.0319 | 0.0001914
2 x BRIDGING BRACKET | PL/152(?) | +3.375 | +3.595 | 1.5 | 45.4 | 220 | 0.06818 | 0.0319 | 0.0001914
2 x BRIDGING BRACKET | PL/152(?) | +3.393 | +3.613 | 1.5 | 45.4 | 220 | 0.06818 | 0.0319 | 0.0001914
2 x BRIDGING BRACKET | PL/218(?) | +3.392 | +3.662 | 1.7 | 45.2 | 270 | 0.08328 | 0.03915 | 0.0002349
2 x BRIDGING BRACKET | PL/218(?) | +3.404 | +3.674 | 1.7 | 45.2 | 270 | 0.08328 | 0.03915 | 0.0002349
2 x BRIDGING BRACKET | PL/152(?) | +3.394 | +3.614 | 1.5 | 45.4 | 220 | 0.06818 | 0.0319 | 0.0001914
2 x BRIDGING BRACKET | PL/152(?) | +3.416 | +3.636 | 1.5 | 45.4 | 220 | 0.06818 | 0.0319 | 0.0001914
2 x BRIDGING BRACKET | PL/152(?) | +3.428 | +3.648 | 1.5 | 45.4 | 220 | 0.06818 | 0.0319 | 0.0001914
2 x BRIDGING BRACKET | PL/214(?) | +3.394 | +3.564 | 1.2 | 45.7 | 170 | 0.05308 | 0.02465 | 0.0001479
2 x BRIDGING BRACKET | PL/214(?) | +3.415 | +3.585 | 1.2 | 45.7 | 170 | 0.05308 | 0.02465 | 0.0001479
4 x BRIDGING BRACKET | PL/214(?) | +3.433 | +3.603 | 1.2 | 45.7 | 170 | 0.05308 | 0.02465 | 0.0001479
2 x BRIDGING BRACKET | PL/152(?) | +3.436 | +3.656 | 1.5 | 45.4 | 220 | 0.06818 | 0.0319 | 0.0001914
2 x BRIDGING BRACKET | PL/152(?) | +3.427 | +3.647 | 1.5 | 45.4 | 220 | 0.06818 | 0.0319 | 0.0001914
2 x BRIDGING BRACKET | PL/152(?) | +3.382 | +3.602 | 1.5 | 45.4 | 220 | 0.06818 | 0.0319 | 0.0001914
2 x BRIDGING BRACKET | PL/214(?) | +3.389 | +3.559 | 1.2 | 45.7 | 170 | 0.05308 | 0.02465 | 0.0001479
2 x BRIDGING BRACKET | PL/214(?) | +3.411 | +3.581 | 1.2 | 45.7 | 170 | 0.05308 | 0.02465 | 0.0001479
2 x BRIDGING BRACKET | PL/218 | +3.318 | +3.588 | 1.7 | 45.2 | 270 | 0.08328 | 0.03915 | 0.0002349
2 x BRIDGING BRACKET | PL/218 | +3.338 | +3.608 | 1.7 | 45.2 | 270 | 0.08328 | 0.03915 | 0.0002349
2 x BRIDGING BRACKET | PL/218 | +3.359 | +3.629 | 1.7 | 45.2 | 270 | 0.08328 | 0.03915 | 0.0002349
12 x BRIDGING BRACKET | PL/218 | +3.358 | +3.628 | 1.7 | 45.2 | 270 | 0.08328 | 0.03915 | 0.0002349
8 x BRIDGING BRACKET | PL/1998 | +3.308 | +3.628 | 2.2 | 45 | 320 | 0.09838 | 0.0464 | 0.0002784
2 x BRIDGING BRACKET | PL/1998 | +3.309 | +3.629 | 2.2 | 45 | 320 | 0.09838 | 0.0464 | 0.0002784
2 x BRIDGING BRACKET | PL/1998 | +3.284 | +3.604 | 2.2 | 45 | 320 | 0.09838 | 0.0464 | 0.0002784
2 x BRIDGING BRACKET | PL/1998 | +3.263 | +3.583 | 2.2 | 45 | 320 | 0.09838 | 0.0464 | 0.0002784
2 x BRIDGING BRACKET | PL/1998 | +3.296 | +3.616 | 2.2 | 45 | 320 | 0.09838 | 0.0464 | 0.0002784
2 x BRIDGING BRACKET | PL/1998 | +3.276 | +3.596 | 2.2 | 45 | 320 | 0.09838 | 0.0464 | 0.0002784
2 x BRIDGING BRACKET | PL/152 | +3.371 | +3.591 | 1.5 | 45.4 | 220 | 0.06818 | 0.0319 | 0.0001914
2 x BRIDGING BRACKET | PL/152 | +3.386 | +3.606 | 1.5 | 45.4 | 220 | 0.06818 | 0.0319 | 0.0001914
8 x BRIDGING BRACKET | PL/152 | +3.406 | +3.626 | 1.5 | 45.4 | 220 | 0.06818 | 0.0319 | 0.0001914
2 x BRIDGING BRACKET | PL/152 | +3.396 | +3.616 | 1.5 | 45.4 | 220 | 0.06818 | 0.0319 | 0.0001914
2 x BRIDGING BRACKET | PL/214 | +3.397 | +3.567 | 1.2 | 45.7 | 170 | 0.05308 | 0.02465 | 0.0001479
2 x BRIDGING BRACKET | PL/214 | +3.417 | +3.587 | 1.2 | 45.7 | 170 | 0.05308 | 0.02465 | 0.0001479
2 x BRIDGING BRACKET | PL/214 | +3.435 | +3.605 | 1.2 | 45.7 | 170 | 0.05308 | 0.02465 | 0.0001479
2 x BRIDGING BRACKET | PL/152 | +3.382 | +3.602 | 1.5 | 45.4 | 220 | 0.06818 | 0.0319 | 0.0001914
2 x BRIDGING BRACKET | PL/152 | +3.360 | +3.580 | 1.5 | 45.4 | 220 | 0.06818 | 0.0319 | 0.0001914
2 x BRIDGING BRACKET | PL/214 | +3.392 | +3.562 | 1.2 | 45.7 | 170 | 0.05308 | 0.02465 | 0.0001479
4 x BRIDGING BRACKET | PL/214 | +3.411 | +3.581 | 1.2 | 45.7 | 170 | 0.05308 | 0.02465 | 0.0001479
