Properties of the parts of a building model (IFC2X3), part 3 of 4

# IfcElementAssembly (1446)
Name | ASSEMBLY_POSITION_CODE = Assembly/Cast unit position code | ASSEMBLY_POS = Assembly/Cast unit Mark | Assembly/Cast unit weight (kg) | Assembly/Cast unit bottom elevation | Assembly/Cast unit top elevation | Width (mm)
BB TRUSS BRACKET | C200-C200/BB200(TH96) | PL/2536 | 1.9 | +3.396 | +3.627 | 147.999
2 x RAFTER | C200/BB300(TH120)-BB350(TH75) | R/92 | 3.9 | +3.380 | +3.676 | 76
COLUMN | C200/BB300(TH120) | C/70 | 25.8 | +0.000 | +3.643 | 76
2 x PLATE | C200/BB300(TH120) | Z/2525 | 2.9 | +3.314 | +3.618 | 80
COLUMN | C200/BB300(TH120) | C/73 | 25.8 | +0.000 | +3.643 | 76
2 x RAFTER | C200/BB300(TH96)-BB300(TH120) | R/92 | 3.9 | +3.400 | +3.696 | 76
COLUMN | C200/BB300(TH96) | C/69 | 25.8 | +0.000 | +3.643 | 76
2 x PLATE | C200/BB300(TH96) | Z/2525 | 2.9 | +3.334 | +3.638 | 80
COLUMN | C200/BB300(TH96) | C/72 | 25.8 | +0.000 | +3.643 | 76
2 x RAFTER | C200/BB300(TH75)-BB300(TH96) | R/92 | 3.9 | +3.418 | +3.713 | 76
COLUMN | C200/BB300(TH75) | C/68 | 25.8 | +0.000 | +3.643 | 76
2 x PLATE | C200/BB300(TH75) | Z/2525 | 2.9 | +3.352 | +3.656 | 80
COLUMN | C200/BB300(TH75) | C/71 | 25.8 | +0.000 | +3.643 | 76
2 x RAFTER | C200/BB250(TH120)-BB300(TH75) | R/92 | 3.9 | +3.380 | +3.676 | 76
COLUMN | C200/BB250(TH120) | C/70 | 25.8 | +0.000 | +3.643 | 76
2 x PLATE | C200/BB250(TH120) | Z/2525 | 2.9 | +3.314 | +3.618 | 80
COLUMN | C200/BB250(TH120) | C/73 | 25.8 | +0.000 | +3.643 | 76
2 x RAFTER | C200/BB250(TH96)-BB250(TH120) | R/92 | 3.9 | +3.400 | +3.696 | 76
COLUMN | C200/BB250(TH96) | C/69 | 25.8 | +0.000 | +3.643 | 76
2 x PLATE | C200/BB250(TH96) | Z/2525 | 2.9 | +3.334 | +3.638 | 80
COLUMN | C200/BB250(TH96) | C/72 | 25.8 | +0.000 | +3.643 | 76
2 x RAFTER | C200/BB250(TH75)-BB250(TH96) | R/92 | 3.9 | +3.418 | +3.713 | 76
COLUMN | C200/BB250(TH75) | C/68 | 25.8 | +0.000 | +3.643 | 76
2 x PLATE | C200/BB250(TH75) | Z/2525 | 2.9 | +3.352 | +3.656 | 80
COLUMN | C200/BB250(TH75) | C/71 | 25.8 | +0.000 | +3.643 | 76
2 x RAFTER | C200/BB200(TH120)-BB250(TH75) | R/92 | 3.9 | +3.380 | +3.676 | 76
COLUMN | C200/BB200(TH120) | C/70 | 25.8 | +0.000 | +3.643 | 76
2 x PLATE | C200/BB200(TH120) | Z/2525 | 2.9 | +3.314 | +3.618 | 80
COLUMN | C200/BB200(TH120) | C/73 | 25.8 | +0.000 | +3.643 | 76
2 x RAFTER | C200/BB200(TH96)-BB200(TH120) | R/92 | 3.9 | +3.400 | +3.696 | 76
COLUMN | C200/BB200(TH96) | C/69 | 25.8 | +0.000 | +3.643 | 76
2 x PLATE | C200/BB200(TH96) | Z/2525 | 2.9 | +3.334 | +3.638 | 80
COLUMN | C200/BB200(TH96) | C/72 | 25.8 | +0.000 | +3.643 | 76
2 x RAFTER | C200/BB200(TH75)-BB200(TH96) | R/92 | 3.9 | +3.418 | +3.713 | 76
COLUMN | C200/BB200(TH75) | C/71 | 25.8 | +0.000 | +3.643 | 76
2 x PLATE | C200/BB200(TH75) | Z/2525 | 2.9 | +3.352 | +3.656 | 80
COLUMN | C200/BB200(TH75) | C/68 | 25.8 | +0.000 | +3.643 | 76
BRIDGING U-PLATE | C150-C150/BB250(TH120) | PL/2525 | 2.9 | +3.385 | +3.647 | 262
RAFTER | C150-C150/BB250(TH120)-BB300(TH75) | Z/2555 | 2.6 | +3.422 | +3.652 | 64
BB TRUSS BRACKET | C150-C150/BB250(TH120) | PL/2526 | 1.2 | +3.428 | +3.599 | 147.999
BB TRUSS BRACKET | C150-C150/BB250(TH120) | PL/2521 | 1.2 | +3.428 | +3.599 | 147.999
BRIDGING U-PLATE | C150-C150/BB250(TH96) | PL/2524 | 2.9 | +3.361 | +3.623 | 262
RAFTER | C150-C150/BB250(TH96)-BB250(TH120) | Z/2555 | 2.6 | +3.417 | +3.647 | 64
BB TRUSS BRACKET | C150-C150/BB250(TH96) | PL/2526 | 1.2 | +3.423 | +3.594 | 147.999
BB TRUSS BRACKET | C150-C150/BB250(TH96) | PL/2521 | 1.2 | +3.423 | +3.594 | 147.999
BRIDGING U-PLATE | C150-C150/BB250(TH75) | PL/2523 | 2.9 | +3.339 | +3.601 | 262
RAFTER | C150-C150/BB250(TH75)-BB250(TH96) | Z/2555 | 2.6 | +3.413 | +3.644 | 64
BB TRUSS BRACKET | C150-C150/BB250(TH75) | PL/2526 | 1.2 | +3.419 | +3.590 | 147.999
BB TRUSS BRACKET | C150-C150/BB250(TH75) | PL/2521 | 1.2 | +3.419 | +3.590 | 147.999
BRIDGING U-PLATE | C150-C150/BB200(TH120) | PL/1999 | 2.6 | +3.371 | +3.582 | 211
RAFTER | C150-C150/BB200(TH120)-BB250(TH75) | Z/2555 | 2.6 | +3.376 | +3.606 | 64
BB TRUSS BRACKET | C150-C150/BB200(TH120) | PL/2526 | 1.2 | +3.382 | +3.553 | 147.999
BB TRUSS BRACKET | C150-C150/BB200(TH120) | PL/2521 | 1.2 | +3.382 | +3.553 | 147.999
BRIDGING U-PLATE | C150-C150/BB200(TH96) | PL/1999 | 2.6 | +3.390 | +3.601 | 211
RAFTER | C150-C150/BB200(TH96)-BB200(TH120) | Z/2555 | 2.6 | +3.396 | +3.626 | 64
BB TRUSS BRACKET | C150-C150/BB200(TH96) | PL/2526 | 1.2 | +3.402 | +3.573 | 147.999
BB TRUSS BRACKET | C150-C150/BB200(TH96) | PL/2521 | 1.2 | +3.402 | +3.573 | 147.999
2 x RAFTER | C150/BB250(TH120)-BB300(TH75) | Z/222 | 2.6 | +3.422 | +3.652 | 64
COLUMN | C150/BB250(TH120) | Z/3686 | 20.2 | +0.000 | +3.643 | 64
2 x PLATE | C150/BB250(TH120) | Z/2453 | 2.5 | +3.315 | +3.609 | 72.5
2 x RAFTER | C150/BB250(TH96)-BB250(TH120) | Z/222 | 2.6 | +3.417 | +3.647 | 64
COLUMN | C150/BB250(TH96) | Z/3685 | 20.2 | +0.000 | +3.619 | 64
2 x PLATE | C150/BB250(TH96) | Z/2453 | 2.5 | +3.310 | +3.605 | 72.5
2 x RAFTER | C150/BB250(TH75)-BB250(TH96) | Z/222 | 2.6 | +3.413 | +3.644 | 64
COLUMN | C150/BB250(TH75) | Z/3682 | 20.1 | +0.000 | +3.597 | 64
2 x PLATE | C150/BB250(TH75) | Z/2453 | 2.5 | +3.307 | +3.601 | 72.5
2 x RAFTER | C150/BB200(TH120)-BB250(TH75) | Z/222 | 2.6 | +3.376 | +3.606 | 64
COLUMN | C150/BB200(TH120) | Z/3684 | 20.1 | +0.000 | +3.597 | 64
2 x PLATE | C150/BB200(TH120) | Z/2453 | 2.5 | +3.269 | +3.563 | 72.5
2 x RAFTER | C150/BB200(TH96)-BB200(TH120) | Z/222 | 2.6 | +3.396 | +3.626 | 64
COLUMN | C150/BB200(TH96) | Z/3683 | 20.1 | +0.000 | +3.597 | 64
2 x PLATE | C150/BB200(TH96) | Z/2453 | 2.5 | +3.289 | +3.584 | 72.5
COLUMN | C150/BB250(TH120) | Z/3681 | 20.2 | +0.000 | +3.643 | 64
COLUMN | C150/BB250(TH96) | Z/3680 | 20.2 | +0.000 | +3.619 | 64
COLUMN | C150/BB250(TH75) | Z/3663 | 20.1 | +0.000 | +3.597 | 64
COLUMN | C150/BB200(TH120) | Z/3679 | 20.1 | +0.000 | +3.597 | 64
COLUMN | C150/BB200(TH96) | Z/3672 | 20.1 | +0.000 | +3.597 | 64
2 x RAFTER | C150/BB200(TH75)-BB200(TH96) | Z/222 | 2.6 | +3.413 | +3.644 | 64
COLUMN | C150/BB200(TH75) | Z/3682 | 20.1 | +0.000 | +3.597 | 64
2 x PLATE | C150/BB200(TH75) | Z/2453 | 2.5 | +3.307 | +3.601 | 72.5
COLUMN | C150/BB200(TH75) | Z/3663 | 20.1 | +0.000 | +3.597 | 64
BB TRUSS BRACKET | C300-C300/BB350(TH75)-BB350(TH96) | PL/2549 | 4.3 | +3.286 | +3.653 | 147.699
BB TRUSS BRACKET | C250-C250/BB250(TH75) | PL/2546 | 3.1 | +3.391 | +3.680 | 147.999
BB TRUSS BRACKET | C250-C250/BB350(TH75) | PL/2541 | 2.6 | +3.392 | +3.680 | 147.999
BB TRUSS BRACKET | C250-C250/BB350(TH75) | PL/2548 | 2.6 | +3.392 | +3.680 | 147.999
BEAM | C300-C300/BB300(TH96) | B/97 | 23.6 | +3.323 | +3.623 | 96
BEAM | C300-C300/BB350(TH96) | B/98 | 28.2 | +3.269 | +3.619 | 125
BEAM | C300-C300/BB300(TH120) | B/97 | 23.6 | +3.303 | +3.603 | 96
BEAM | C300-C300/BB350(TH120) | B/98 | 28.2 | +3.294 | +3.644 | 125
BRIDGING U-PLATE | C300-C300/BB350(TH75) | PL/2551 | 4.4 | +3.244 | +3.602 | 129
BEAM | C300-C300/BB350(TH75) | B/98 | 28.2 | +3.248 | +3.598 | 125
BEAM | C300-C300/BB300(TH75) | B/97 | 23.6 | +3.344 | +3.644 | 96
BRIDGING U-PLATE | C300-C300/BB300(TH75) | PL/2554 | 3.6 | +3.340 | +3.648 | 100
BEAM | C350-C350/BB350(TH96) | B/99 | 27.7 | +3.281 | +3.631 | 125
BRIDGING U-PLATE | C350-C350/BB350(TH75) | PL/2559 | 4.4 | +3.289 | +3.647 | 358
BEAM | C350-C350/BB350(TH75) | B/99 | 27.7 | +3.293 | +3.643 | 125
BEAM | C250-C250/BB350(TH120) | B/94 | 28.5 | +3.293 | +3.643 | 125
BEAM | C250-C250/BB350(TH96) | B/94 | 28.5 | +3.293 | +3.643 | 125
BRIDGING U-PLATE | C250-C250/BB350(TH75) | PL/1986 | 4.4 | +3.289 | +3.647 | 129
BEAM | C250-C250/BB350(TH75) | B/94 | 28.5 | +3.293 | +3.643 | 125
BEAM | C250-C250/BB300(TH120) | B/93 | 19 | +3.343 | +3.643 | 96
BEAM | C250-C250/BB300(TH96) | B/93 | 19 | +3.343 | +3.643 | 96
BRIDGING U-PLATE | C250-C250/BB300(TH75) | PL/2543 | 3.6 | +3.339 | +3.647 | 100
BEAM | C250-C250/BB300(TH75) | B/93 | 19 | +3.343 | +3.643 | 96
BEAM | C250-C250/BB250(TH120) | B/92 | 15.3 | +3.354 | +3.608 | 76
BEAM | C250-C250/BB250(TH96) | B/92 | 15.3 | +3.369 | +3.623 | 76
BEAM | C250-C250/BB250(TH75) | B/92 | 15.3 | +3.389 | +3.643 | 76
BRIDGING U-PLATE | C250-C250/BB250(TH75) | PL/2018 | 2.9 | +3.385 | +3.647 | 80
BRIDGING BEAM | C200-C200/BB300(TH120) | BB/5 | 19 | +3.343 | +3.643 | 96
BRIDGING BEAM | C200-C200/BB300(TH96) | BB/5 | 19 | +3.343 | +3.643 | 96
BRIDGING U-PLATE | C200-C200/BB300(TH75) | PL/2533 | 3.6 | +3.339 | +3.647 | 308
BRIDGING BEAM | C200-C200/BB300(TH75) | BB/5 | 19 | +3.343 | +3.643 | 96
BRIDGING BEAM | C200-C200/BB250(TH120) | BB/3 | 15.3 | +3.379 | +3.633 | 76
BRIDGING BEAM | C200-C200/BB250(TH96) | BB/3 | 15.3 | +3.389 | +3.643 | 76
BRIDGING U-PLATE | C200-C200/BB250(TH75) | PL/2531 | 2.9 | +3.385 | +3.647 | 262
BRIDGING BEAM | C200-C200/BB250(TH75) | BB/3 | 15.3 | +3.389 | +3.643 | 76
BRIDGING BEAM | C200-C200/BB200(TH120) | BB/1 | 13.5 | +3.380 | +3.583 | 76
BRIDGING BEAM | C200-C200/BB200(TH96) | BB/1 | 13.5 | +3.400 | +3.603 | 76
BEAM | C350-C350/BB350(TH120) | B/99 | 27.7 | +3.261 | +3.611 | 125
BRIDGING BEAM | C200-C200/BB200(TH75) | BB/1 | 13.5 | +3.418 | +3.621 | 76
BRIDGING U-PLATE | C200-C200/BB200(TH75) | PL/2530 | 2.6 | +3.414 | +3.625 | 211
BEAM | C150-C150/BB250(TH120) | B/91 | 15.3 | +3.389 | +3.643 | 76
BEAM | C150-C150/BB250(TH96) | B/91 | 15.3 | +3.365 | +3.619 | 76
BEAM | C150-C150/BB250(TH75) | B/91 | 15.3 | +3.343 | +3.597 | 76
BEAM | C150-C150/BB200(TH120) | B/38 | 13.6 | +3.375 | +3.578 | 76
BEAM | C150-C150/BB200(TH96) | B/38 | 13.6 | +3.394 | +3.597 | 76
BRIDGING U-PLATE | C150-C150/BB200(TH75) | PL/2522 | 2.6 | +3.390 | +3.601 | 211
BEAM | C150-C150/BB200(TH75) | B/38 | 13.6 | +3.394 | +3.597 | 76
2 x FASCIA BRACKET | C200/BB300(TH120) | Z/2556 | 0.6 | +3.487 | +3.648 | 161
FASCIA BRACKET | C200-C200/BB300(TH120) | Z/2556 | 0.6 | +3.487 | +3.648 | 161
2 x FASCIA BRACKET | C200/BB250(TH120) | Z/2556 | 0.6 | +3.487 | +3.648 | 161
FASCIA BRACKET | C200-C200/BB250(TH120) | Z/2556 | 0.6 | +3.487 | +3.648 | 161
2 x FASCIA BRACKET | C200/BB200(TH120) | Z/2556 | 0.6 | +3.487 | +3.648 | 161
FASCIA BRACKET | C200-C200/BB200(TH120) | Z/2556 | 0.6 | +3.487 | +3.648 | 161
2 x FASCIA BRACKET | C200/BB300(TH96) | Z/2554 | 0.4 | +3.487 | +3.648 | 161
FASCIA BRACKET | C200-C200/BB300(TH96) | Z/2554 | 0.4 | +3.487 | +3.648 | 161
2 x FASCIA BRACKET | C200/BB250(TH96) | Z/2554 | 0.4 | +3.487 | +3.648 | 161
FASCIA BRACKET | C200-C200/BB250(TH96) | Z/2554 | 0.4 | +3.487 | +3.648 | 161
2 x FASCIA BRACKET | C200/BB200(TH96) | Z/2554 | 0.4 | +3.487 | +3.648 | 161
FASCIA BRACKET | C200-C200/BB200(TH96) | Z/2554 | 0.4 | +3.487 | +3.648 | 161
2 x FASCIA BRACKET | C200/BB300(TH75) | Z/2553 | 0.4 | +3.487 | +3.648 | 161
FASCIA BRACKET | C200-C200/BB300(TH75) | Z/2553 | 0.4 | +3.487 | +3.648 | 161
2 x FASCIA BRACKET | C200/BB250(TH75) | Z/2553 | 0.4 | +3.487 | +3.648 | 161
FASCIA BRACKET | C200-C200/BB250(TH75) | Z/2553 | 0.4 | +3.487 | +3.648 | 161
2 x FASCIA BRACKET | C200/BB200(TH75) | Z/2553 | 0.4 | +3.487 | +3.648 | 161
FASCIA BRACKET | C200-C200/BB200(TH75) | Z/2553 | 0.4 | +3.487 | +3.648 | 161
RAFTER | C350-C350/BB350(TH75)-BB350(TH96) | Z/2606 | 10.8 | +3.298 | +3.769 | 125
2 x FASCIA BRACKET | C350/BB350(TH120) | Z/2531 | 0.4 | +3.488 | +3.645 | 157.2
FASCIA BRACKET | C350-C350/BB350(TH120) | Z/2531 | 0.4 | +3.488 | +3.645 | 157.2
FASCIA STIFFENER | C350-C350/BB350(TH120) | PL/116 | 1 | +3.291 | +3.641 | 3
2 x FASCIA BRACKET | C350/BB350(TH96) | Z/2520 | 0.4 | +3.488 | +3.645 | 157.2
FASCIA BRACKET | C350-C350/BB350(TH96) | Z/2520 | 0.4 | +3.488 | +3.645 | 157.2
FASCIA STIFFENER | C350-C350/BB350(TH96) | PL/116 | 1 | +3.291 | +3.641 | 3
2 x FASCIA BRACKET | C350/BB350(TH75) | Z/52 | 0.2 | +3.488 | +3.645 | 157.2
FASCIA BRACKET | C350-C350/BB350(TH75) | Z/52 | 0.2 | +3.488 | +3.645 | 157.2
FASCIA STIFFENER | C350-C350/BB350(TH75) | PL/116 | 1 | +3.291 | +3.641 | 3
RAFTER | C300-C300/BB350(TH75)-BB350(TH96) | Z/2599 | 8.9 | +3.294 | +3.714 | 96
2 x FASCIA BRACKET | C300/BB350(TH120) | Z/2531 | 0.4 | +3.489 | +3.646 | 157.2
FASCIA BRACKET | C300-C300/BB350(TH120) | Z/2531 | 0.4 | +3.489 | +3.646 | 157.2
FASCIA STIFFENER | C300-C300/BB350(TH120) | PL/116 | 1 | +3.294 | +3.644 | 3
2 x FASCIA BRACKET | C300/BB350(TH96) | Z/2520 | 0.4 | +3.464 | +3.622 | 157.2
FASCIA BRACKET | C300-C300/BB350(TH96) | Z/2520 | 0.4 | +3.464 | +3.622 | 157.2
FASCIA STIFFENER | C300-C300/BB350(TH96) | PL/116 | 1 | +3.269 | +3.619 | 3
2 x FASCIA BRACKET | C300/BB350(TH75) | Z/52 | 0.2 | +3.443 | +3.600 | 157.2
FASCIA BRACKET | C300-C300/BB350(TH75) | Z/52 | 0.2 | +3.443 | +3.600 | 157.2
FASCIA STIFFENER | C300-C300/BB350(TH75) | PL/116 | 1 | +3.248 | +3.598 | 3
FASCIA STIFFENER | C300-C300/BB300(TH120) | PL/113 | 0.8 | +3.319 | +3.619 | 3
FASCIA STIFFENER | C300-C300/BB300(TH96) | PL/113 | 0.8 | +3.339 | +3.639 | 3
FASCIA STIFFENER | C300-C300/BB300(TH75) | PL/113 | 0.8 | +3.344 | +3.644 | 3
2 x FASCIA BRACKET | C300/BB300(TH120) | Z/2531 | 0.4 | +3.489 | +3.646 | 157.2
FASCIA BRACKET | C300-C300/BB300(TH120) | Z/2531 | 0.4 | +3.489 | +3.646 | 157.2
2 x FASCIA BRACKET | C300/BB300(TH96) | Z/2520 | 0.4 | +3.489 | +3.646 | 157.2
FASCIA BRACKET | C300-C300/BB300(TH96) | Z/2520 | 0.4 | +3.489 | +3.646 | 157.2
RAFTER | C300-C300/BB300(TH75)-BB300(TH96) | Z/2599 | 8.9 | +3.340 | +3.760 | 96
2 x FASCIA BRACKET | C300/BB300(TH75) | Z/52 | 0.2 | +3.489 | +3.646 | 157.2
FASCIA BRACKET | C300-C300/BB300(TH75) | Z/52 | 0.2 | +3.489 | +3.646 | 157.2
RAFTER | C250-C250/BB350(TH75)-BB350(TH96) | Z/2591 | 5.9 | +3.388 | +3.765 | 76
2 x FASCIA BRACKET | C250/BB350(TH120) | Z/2531 | 0.4 | +3.489 | +3.646 | 157.2
FASCIA BRACKET | C250-C250/BB350(TH120) | Z/2531 | 0.4 | +3.489 | +3.646 | 157.2
FASCIA STIFFENER | C250-C250/BB350(TH120) | PL/116 | 1 | +3.293 | +3.643 | 3
2 x FASCIA BRACKET | C250/BB350(TH96) | Z/2520 | 0.4 | +3.489 | +3.646 | 157.2
FASCIA BRACKET | C250-C250/BB350(TH96) | Z/2520 | 0.4 | +3.489 | +3.646 | 157.2
FASCIA STIFFENER | C250-C250/BB350(TH96) | PL/116 | 1 | +3.293 | +3.643 | 3
2 x FASCIA BRACKET | C250/BB350(TH75) | Z/52 | 0.2 | +3.489 | +3.646 | 157.2
FASCIA BRACKET | C250-C250/BB350(TH75) | Z/52 | 0.2 | +3.489 | +3.646 | 157.2
FASCIA STIFFENER | C250-C250/BB350(TH75) | PL/116 | 1 | +3.293 | +3.643 | 3
RAFTER | C250-C250/BB300(TH75)-BB300(TH96) | Z/2591 | 5.9 | +3.388 | +3.765 | 76
2 x FASCIA BRACKET | C250/BB300(TH120) | Z/2531 | 0.4 | +3.489 | +3.646 | 157.2
FASCIA BRACKET | C250-C250/BB300(TH120) | Z/2531 | 0.4 | +3.489 | +3.646 | 157.2
FASCIA STIFFENER | C250-C250/BB300(TH120) | PL/113 | 0.8 | +3.343 | +3.643 | 3
2 x FASCIA BRACKET | C250/BB300(TH96) | Z/2520 | 0.4 | +3.489 | +3.646 | 157.2
FASCIA BRACKET | C250-C250/BB300(TH96) | Z/2520 | 0.4 | +3.489 | +3.646 | 157.2
FASCIA STIFFENER | C250-C250/BB300(TH96) | PL/113 | 0.8 | +3.343 | +3.643 | 3
2 x FASCIA BRACKET | C250/BB300(TH75) | Z/52 | 0.2 | +3.489 | +3.646 | 157.2
FASCIA BRACKET | C250-C250/BB300(TH75) | Z/52 | 0.2 | +3.489 | +3.646 | 157.2
FASCIA STIFFENER | C250-C250/BB300(TH75) | PL/113 | 0.8 | +3.343 | +3.643 | 3
2 x FASCIA BRACKET | C250/BB250(TH120) | Z/2531 | 0.4 | +3.489 | +3.646 | 157.2
FASCIA BRACKET | C250-C250/BB250(TH120) | Z/2531 | 0.4 | +3.489 | +3.646 | 157.2
FASCIA STIFFENER | C250-C250/BB250(TH120) | PL/128 | 0.6 | +3.354 | +3.608 | 3
2 x FASCIA BRACKET | C250/BB250(TH96) | Z/2520 | 0.4 | +3.489 | +3.646 | 157.2
FASCIA BRACKET | C250-C250/BB250(TH96) | Z/2520 | 0.4 | +3.489 | +3.646 | 157.2
FASCIA STIFFENER | C250-C250/BB250(TH96) | PL/128 | 0.6 | +3.369 | +3.623 | 3
2 x FASCIA BRACKET | C250/BB250(TH75) | Z/52 | 0.2 | +3.489 | +3.646 | 157.2
FASCIA BRACKET | C250-C250/BB250(TH75) | Z/52 | 0.2 | +3.489 | +3.646 | 157.2
RAFTER | C250-C250/BB250(TH75)-BB250(TH96) | Z/2591 | 5.9 | +3.389 | +3.765 | 76
FASCIA STIFFENER | C250-C250/BB250(TH75) | PL/128 | 0.6 | +3.389 | +3.643 | 3
RAFTER | C200-C200/BB300(TH75)-BB300(TH96) | R/93 | 3.9 | +3.418 | +3.713 | 76
FASCIA STIFFENER | C200-C200/BB300(TH120) | PL/113 | 0.8 | +3.343 | +3.643 | 3
FASCIA STIFFENER | C200-C200/BB300(TH96) | PL/113 | 0.8 | +3.343 | +3.643 | 3
FASCIA STIFFENER | C200-C200/BB300(TH75) | PL/113 | 0.8 | +3.343 | +3.643 | 3
FASCIA STIFFENER | C200-C200/BB250(TH120) | PL/128 | 0.6 | +3.379 | +3.633 | 3
FASCIA STIFFENER | C200-C200/BB250(TH96) | PL/128 | 0.6 | +3.389 | +3.643 | 3
RAFTER | C200-C200/BB250(TH75)-BB250(TH96) | R/93 | 3.9 | +3.418 | +3.713 | 76
FASCIA STIFFENER | C200-C200/BB250(TH75) | PL/128 | 0.6 | +3.389 | +3.643 | 3
FASCIA STIFFENER | C200-C200/BB200(TH120) | PL/156 | 0.6 | +3.390 | +3.593 | 3
FASCIA STIFFENER | C200-C200/BB200(TH96) | PL/156 | 0.6 | +3.410 | +3.613 | 3
FASCIA STIFFENER | C200-C200/BB200(TH75) | PL/156 | 0.6 | +3.430 | +3.633 | 3
RAFTER | C200-C200/BB200(TH75)-BB200(TH96) | R/93 | 3.9 | +3.418 | +3.713 | 76
FASCIA STIFFENER | C150-C150/BB250(TH120) | PL/128 | 0.6 | +3.389 | +3.643 | 3
2 x FASCIA BRACKET | C150/BB250(TH120) | Z/2531 | 0.4 | +3.489 | +3.646 | 157.2
FASCIA BRACKET | C150-C150/BB250(TH120) | Z/2531 | 0.4 | +3.489 | +3.646 | 157.2
BEAM | C150-C150/BB250(TH120) | B/80 | 15.3 | +3.389 | +3.643 | 76
FASCIA STIFFENER | C150-C150/BB250(TH96) | PL/128 | 0.6 | +3.365 | +3.619 | 3
2 x FASCIA BRACKET | C150/BB250(TH96) | Z/2520 | 0.4 | +3.464 | +3.621 | 157.2
FASCIA BRACKET | C150-C150/BB250(TH96) | Z/2520 | 0.4 | +3.464 | +3.621 | 157.2
BEAM | C150-C150/BB250(TH96) | B/80 | 15.3 | +3.365 | +3.619 | 76
FASCIA STIFFENER | C150-C150/BB250(TH75) | PL/128 | 0.6 | +3.343 | +3.597 | 3
2 x FASCIA BRACKET | C150/BB250(TH75) | Z/52 | 0.2 | +3.443 | +3.600 | 157.2
FASCIA BRACKET | C150-C150/BB250(TH75) | Z/52 | 0.2 | +3.443 | +3.600 | 157.2
BEAM | C150-C150/BB250(TH75) | B/80 | 15.3 | +3.343 | +3.597 | 76
FASCIA STIFFENER | C150-C150/BB200(TH120) | PL/156 | 0.6 | +3.384 | +3.587 | 3
2 x FASCIA BRACKET | C150/BB200(TH120) | Z/2531 | 0.4 | +3.443 | +3.600 | 157.2
FASCIA BRACKET | C150-C150/BB200(TH120) | Z/2531 | 0.4 | +3.443 | +3.600 | 157.2
BEAM | C150-C150/BB200(TH120) | B/15 | 13.6 | +3.375 | +3.578 | 76
FASCIA STIFFENER | C150-C150/BB200(TH96) | PL/156 | 0.6 | +3.394 | +3.597 | 3
2 x FASCIA BRACKET | C150/BB200(TH96) | Z/2520 | 0.4 | +3.443 | +3.600 | 157.2
FASCIA BRACKET | C150-C150/BB200(TH96) | Z/2520 | 0.4 | +3.443 | +3.600 | 157.2
BEAM | C150-C150/BB200(TH96) | B/15 | 13.6 | +3.394 | +3.597 | 76
FASCIA STIFFENER | C150-C150/BB200(TH75) | PL/156 | 0.6 | +3.394 | +3.597 | 3
RAFTER | C150-C150/BB200(TH75)-BB200(TH96) | Z/2555 | 2.6 | +3.413 | +3.644 | 64
2 x FASCIA BRACKET | C150/BB200(TH75) | Z/52 | 0.2 | +3.443 | +3.600 | 157.2
FASCIA BRACKET | C150-C150/BB200(TH75) | Z/52 | 0.2 | +3.443 | +3.600 | 157.2
BEAM | C150-C150/BB200(TH75) | B/15 | 13.6 | +3.394 | +3.597 | 76
BRIDGING-COLUMN STIFF | C350/BB350(TH120) | PL/118 | 4.4 | +3.293 | +3.643 | 112
BRIDGING-COLUMN STIFF | C350/BB350(TH96) | PL/118 | 4.4 | +3.293 | +3.643 | 112
BRIDGING-COLUMN STIFF | C350/BB350(TH75) | PL/118 | 4.4 | +3.293 | +3.643 | 112
BRIDGING-COLUMN STIFF | C300/BB350(TH120) | PL/117 | 3.7 | +3.294 | +3.644 | 83
BRIDGING-COLUMN STIFF | C300/BB350(TH96) | PL/117 | 3.7 | +3.269 | +3.619 | 83
BRIDGING-COLUMN STIFF | C300/BB350(TH75) | PL/117 | 3.7 | +3.248 | +3.598 | 83
BRIDGING-COLUMN STIFF | C300/BB300(TH120) | PL/117 | 3.7 | +3.294 | +3.644 | 83
BRIDGING-COLUMN STIFF | C300/BB300(TH96) | PL/117 | 3.7 | +3.294 | +3.644 | 83
BRIDGING-COLUMN STIFF | C300/BB300(TH75) | PL/117 | 3.7 | +3.294 | +3.644 | 83
BRIDGING-COLUMN STIFF | C250/BB350(TH120) | PL/114 | 2.9 | +3.293 | +3.643 | 64.2
BRIDGING-COLUMN STIFF | C250/BB350(TH96) | PL/114 | 2.9 | +3.293 | +3.643 | 64.2
BRIDGING-COLUMN STIFF | C250/BB350(TH75) | PL/114 | 2.9 | +3.293 | +3.643 | 64.2
BRIDGING-COLUMN STIFF | C250/BB300(TH120) | PL/114 | 2.9 | +3.293 | +3.643 | 64.2
BRIDGING-COLUMN STIFF | C250/BB300(TH96) | PL/114 | 2.9 | +3.293 | +3.643 | 64.2
BRIDGING-COLUMN STIFF | C250/BB300(TH75) | PL/114 | 2.9 | +3.293 | +3.643 | 64.2
BRIDGING-COLUMN STIFF | C250/BB250(TH120) | PL/114 | 2.9 | +3.293 | +3.643 | 64.2
BRIDGING-COLUMN STIFF | C250/BB250(TH96) | PL/114 | 2.9 | +3.293 | +3.643 | 64.2
BRIDGING-COLUMN STIFF | C250/BB250(TH75) | PL/114 | 2.9 | +3.293 | +3.643 | 64.2
BRIDGING-COLUMN STIFF | C200/BB300(TH120) | PL/111 | 2.6 | +3.293 | +3.643 | 64.2
BRIDGING-COLUMN STIFF | C200/BB300(TH96) | PL/111 | 2.6 | +3.293 | +3.643 | 64.2
BRIDGING-COLUMN STIFF | C200/BB300(TH75) | PL/111 | 2.6 | +3.293 | +3.643 | 64.2
BRIDGING-COLUMN STIFF | C200/BB250(TH120) | PL/111 | 2.6 | +3.293 | +3.643 | 64.2
BRIDGING-COLUMN STIFF | C200/BB250(TH96) | PL/111 | 2.6 | +3.293 | +3.643 | 64.2
BRIDGING-COLUMN STIFF | C200/BB250(TH75) | PL/111 | 2.6 | +3.293 | +3.643 | 64.2
BRIDGING-COLUMN STIFF | C200/BB200(TH120) | PL/111 | 2.6 | +3.293 | +3.643 | 64.2
BRIDGING-COLUMN STIFF | C200/BB200(TH96) | PL/111 | 2.6 | +3.293 | +3.643 | 64.2
BRIDGING-COLUMN STIFF | C200/BB200(TH75) | PL/111 | 2.6 | +3.293 | +3.643 | 64.2
BRIDGING-COLUMN STIFF | C150/BB250(TH120) | PL/91 | 1.9 | +3.293 | +3.643 | 52.2
BRIDGING-COLUMN STIFF | C150/BB250(TH96) | PL/91 | 1.9 | +3.269 | +3.619 | 52.2
BRIDGING-COLUMN STIFF | C150/BB250(TH75) | PL/91 | 1.9 | +3.247 | +3.597 | 52.2
BRIDGING-COLUMN STIFF | C150/BB200(TH120) | PL/91 | 1.9 | +3.247 | +3.597 | 52.2
BRIDGING-COLUMN STIFF | C150/BB200(TH96) | PL/91 | 1.9 | +3.247 | +3.597 | 52.2
BRIDGING-COLUMN STIFF | C150/BB200(TH75) | PL/91 | 1.9 | +3.247 | +3.597 | 52.2
2 x BRIDGING BRACKET | C300/BB300(TH120) | PL/218 | 1.7 | +3.318 | +3.588 | 6
2 x BRIDGING BRACKET | C300/BB300(TH96) | PL/218 | 1.7 | +3.338 | +3.608 | 6
2 x BRIDGING BRACKET | C300/BB300(TH75) | PL/218 | 1.7 | +3.359 | +3.629 | 6
2 x BRIDGING BRACKET | C250/BB300(TH75) | PL/218 | 1.7 | +3.358 | +3.628 | 6
2 x BRIDGING BRACKET | C250/BB300(TH96) | PL/218 | 1.7 | +3.358 | +3.628 | 6
2 x BRIDGING BRACKET | C250/BB300(TH120) | PL/218 | 1.7 | +3.358 | +3.628 | 6
2 x BRIDGING BRACKET | C200/BB300(TH120) | PL/218 | 1.7 | +3.358 | +3.628 | 6
2 x BRIDGING BRACKET | C200/BB300(TH96) | PL/218 | 1.7 | +3.358 | +3.628 | 6
2 x BRIDGING BRACKET | C200/BB300(TH75) | PL/218 | 1.7 | +3.358 | +3.628 | 6
2 x BRIDGING BRACKET | C250/BB350(TH75) | PL/1998 | 2.2 | +3.308 | +3.628 | 6
2 x BRIDGING BRACKET | C250/BB350(TH96) | PL/1998 | 2.2 | +3.308 | +3.628 | 6
2 x BRIDGING BRACKET | C250/BB350(TH120) | PL/1998 | 2.2 | +3.308 | +3.628 | 6
2 x BRIDGING BRACKET | C300/BB350(TH120) | PL/1998 | 2.2 | +3.309 | +3.629 | 6
2 x BRIDGING BRACKET | C300/BB350(TH96) | PL/1998 | 2.2 | +3.284 | +3.604 | 6
2 x BRIDGING BRACKET | C300/BB350(TH75) | PL/1998 | 2.2 | +3.263 | +3.583 | 6
2 x BRIDGING BRACKET | C350/BB350(TH75) | PL/1998 | 2.2 | +3.308 | +3.628 | 6
2 x BRIDGING BRACKET | C350/BB350(TH96) | PL/1998 | 2.2 | +3.296 | +3.616 | 6
2 x BRIDGING BRACKET | C350/BB350(TH120) | PL/1998 | 2.2 | +3.276 | +3.596 | 6
BB TRUSS BRACKET | C200-C200/BB300(TH75) | PL/2529 | 1.7 | +3.421 | +3.645 | 147.999
BB TRUSS BRACKET | C200-C200/BB300(TH75) | PL/2538 | 1.7 | +3.421 | +3.645 | 147.999
BB TRUSS BRACKET | C200-C200/BB250(TH75) | PL/2528 | 1.9 | +3.414 | +3.645 | 147.999
BB TRUSS BRACKET | C200-C200/BB250(TH75) | PL/2537 | 1.9 | +3.414 | +3.645 | 147.999
BB TRUSS BRACKET | C150-C150/BB200(TH75) | PL/2526 | 1.2 | +3.419 | +3.590 | 147.999
BB TRUSS BRACKET | C150-C150/BB200(TH75) | PL/2521 | 1.2 | +3.419 | +3.590 | 147.999
TH | C350-C350/BB350(TH120) | B/59 | 2.9 | +2.946 | +3.111 | 165
TH | C350-C350/BB350(TH96) | B/44 | 2.9 | +2.953 | +3.103 | 150
TH | C350-C350/BB350(TH75) | B/28 | 2.9 | +2.966 | +3.091 | 125
BB TRUSS BRACKET | C350-C350/BB350(TH75)-BB350(TH96) | PL/2558 | 5.4 | +3.298 | +3.706 | 147.699
BB TRUSS BRACKET | C350-C350/BB350(TH75)-BB350(TH96) | PL/2560 | 5.4 | +3.298 | +3.706 | 147.699
TH | C350-C350/BB350(TH120)> | B/59 | 2.9 | +3.717 | +3.853 | 165
FASCIA | C350-C350/BB350(TH120) | F/16 | 8.9 | +3.491 | +3.643 | 64
BEAM | C350-C350/BB350(TH120) | B/78 | 27.7 | +3.261 | +3.611 | 125
TH | C350-C350/BB350(TH96)-BB350(TH120) | B/44 | 2.9 | +3.738 | +3.849 | 150
FASCIA | C350-C350/BB350(TH96) | F/16 | 8.9 | +3.491 | +3.643 | 64
BEAM | C350-C350/BB350(TH96) | B/78 | 27.7 | +3.281 | +3.631 | 125
TH | C350-C350/BB350(TH75)-BB350(TH96) | B/28 | 2.9 | +3.758 | +3.846 | 125
FASCIA | C350-C350/BB350(TH75) | F/16 | 8.9 | +3.491 | +3.643 | 64
BEAM | C350-C350/BB350(TH75) | B/78 | 27.7 | +3.293 | +3.643 | 125
TH | C300-C300/BB350(TH120) | B/65 | 2.9 | +2.981 | +3.146 | 165
TH | C300-C300/BB350(TH96) | B/54 | 2.9 | +2.988 | +3.138 | 150
TH | C300-C300/BB350(TH75) | B/30 | 2.9 | +3.001 | +3.126 | 125
TH | C300-C300/BB300(TH120) | B/65 | 2.9 | +2.981 | +3.146 | 165
TH | C300-C300/BB300(TH96) | B/54 | 2.9 | +2.988 | +3.138 | 150
TH | C300-C300/BB300(TH75) | B/30 | 2.9 | +3.001 | +3.126 | 125
BB TRUSS BRACKET | C300-C300/BB350(TH75)-BB350(TH96) | PL/2556 | 4.3 | +3.286 | +3.653 | 147.699
TH | C300-C300/BB350(TH120)> | B/65 | 2.9 | +3.708 | +3.844 | 165
FASCIA | C300-C300/BB350(TH120) | F/15 | 9.4 | +3.492 | +3.644 | 64
BEAM | C300-C300/BB350(TH120) | B/75 | 28.2 | +3.294 | +3.644 | 125
TH | C300-C300/BB350(TH96)-BB350(TH120) | B/54 | 2.9 | +3.705 | +3.816 | 150
FASCIA | C300-C300/BB350(TH96) | F/15 | 9.4 | +3.467 | +3.619 | 64
BEAM | C300-C300/BB350(TH96) | B/75 | 28.2 | +3.269 | +3.619 | 125
TH | C300-C300/BB350(TH75)-BB350(TH96) | B/30 | 2.9 | +3.703 | +3.791 | 125
FASCIA | C300-C300/BB350(TH75) | F/15 | 9.4 | +3.446 | +3.598 | 64
BEAM | C300-C300/BB350(TH75) | B/75 | 28.2 | +3.248 | +3.598 | 125
BEAM | C300-C300/BB300(TH120) | B/19 | 23.6 | +3.303 | +3.603 | 96
TH | C300-C300/BB300(TH120)-BB350(TH75) | B/65 | 2.9 | +3.697 | +3.834 | 165
FASCIA | C300-C300/BB300(TH120) | F/15 | 9.4 | +3.492 | +3.644 | 64
BEAM | C300-C300/BB300(TH96) | B/19 | 23.6 | +3.323 | +3.623 | 96
TH | C300-C300/BB300(TH96)-BB300(TH120) | B/54 | 2.9 | +3.719 | +3.830 | 150
FASCIA | C300-C300/BB300(TH96) | F/15 | 9.4 | +3.492 | +3.644 | 64
BEAM | C300-C300/BB300(TH75) | B/19 | 23.6 | +3.344 | +3.644 | 96
BB TRUSS BRACKET | C300-C300/BB300(TH75)-BB300(TH96) | PL/2550 | 4.4 | +3.344 | +3.699 | 147.699
BB TRUSS BRACKET | C300-C300/BB300(TH75)-BB300(TH96) | PL/2557 | 4.4 | +3.344 | +3.699 | 147.699
TH | C300-C300/BB300(TH75)-BB300(TH96) | B/30 | 2.9 | +3.739 | +3.826 | 125
FASCIA | C300-C300/BB300(TH75) | F/15 | 9.4 | +3.492 | +3.644 | 64
TH | C250-C250/BB350(TH120) | B/64 | 2.9 | +3.088 | +3.253 | 165
TH | C250-C250/BB350(TH96) | B/45 | 2.9 | +3.096 | +3.246 | 150
TH | C250-C250/BB350(TH75) | B/29 | 2.9 | +3.108 | +3.233 | 125
TH | C250-C250/BB300(TH120) | B/64 | 2.9 | +3.088 | +3.253 | 165
TH | C250-C250/BB300(TH96) | B/45 | 2.9 | +3.096 | +3.246 | 150
TH | C250-C250/BB300(TH75) | B/29 | 2.9 | +3.108 | +3.233 | 125
TH | C250-C250/BB250(TH120) | B/64 | 2.9 | +3.088 | +3.253 | 165
TH | C250-C250/BB250(TH96) | B/45 | 2.9 | +3.096 | +3.246 | 150
TH | C250-C250/BB250(TH75) | B/29 | 2.9 | +3.108 | +3.233 | 125
FASCIA | C250-C250/BB350(TH120) | F/14 | 8.1 | +3.491 | +3.643 | 64
TH | C250-C250/BB350(TH120)> | B/64 | 2.9 | +3.714 | +3.851 | 165
BEAM | C250-C250/BB350(TH120) | B/73 | 28.5 | +3.293 | +3.643 | 125
FASCIA | C250-C250/BB350(TH96) | F/14 | 8.1 | +3.491 | +3.643 | 64
TH | C250-C250/BB350(TH96)-BB350(TH120) | B/45 | 2.9 | +3.735 | +3.846 | 150
BEAM | C250-C250/BB350(TH96) | B/73 | 28.5 | +3.293 | +3.643 | 125
TH | C250-C250/BB350(TH75)-BB350(TH96) | B/29 | 2.9 | +3.754 | +3.842 | 125
FASCIA | C250-C250/BB350(TH75) | F/14 | 8.1 | +3.491 | +3.643 | 64
BEAM | C250-C250/BB350(TH75) | B/73 | 28.5 | +3.293 | +3.643 | 125
BB TRUSS BRACKET | C250-C250/BB300(TH75) | PL/2540 | 2.9 | +3.381 | +3.680 | 147.999
BB TRUSS BRACKET | C250-C250/BB300(TH75) | PL/2547 | 2.9 | +3.381 | +3.680 | 147.999
TH | C250-C250/BB300(TH120)-BB350(TH75) | B/64 | 2.9 | +3.714 | +3.851 | 165
FASCIA | C250-C250/BB300(TH120) | F/14 | 8.1 | +3.491 | +3.643 | 64
BEAM | C250-C250/BB300(TH120) | B/72 | 19 | +3.343 | +3.643 | 96
TH | C250-C250/BB300(TH96)-BB300(TH120) | B/45 | 2.9 | +3.735 | +3.846 | 150
FASCIA | C250-C250/BB300(TH96) | F/14 | 8.1 | +3.491 | +3.643 | 64
BEAM | C250-C250/BB300(TH96) | B/72 | 19 | +3.343 | +3.643 | 96
TH | C250-C250/BB300(TH75)-BB300(TH96) | B/29 | 2.9 | +3.754 | +3.842 | 125
FASCIA | C250-C250/BB300(TH75) | F/14 | 8.1 | +3.491 | +3.643 | 64
BEAM | C250-C250/BB300(TH75) | B/72 | 19 | +3.343 | +3.643 | 96
FASCIA | C250-C250/BB250(TH120) | F/12 | 7.9 | +3.491 | +3.643 | 64
TH | C250-C250/BB250(TH120)-BB300(TH75) | B/64 | 2.9 | +3.686 | +3.823 | 165
2 x BRIDGING BRACKET | C250/BB250(TH120) | PL/152 | 1.5 | +3.371 | +3.591 | 6
BEAM | C250-C250/BB250(TH120) | B/70 | 15.3 | +3.354 | +3.608 | 76
FASCIA | C250-C250/BB250(TH96) | F/12 | 7.9 | +3.491 | +3.643 | 64
TH | C250-C250/BB250(TH96)-BB250(TH120) | B/45 | 2.9 | +3.707 | +3.818 | 150
2 x BRIDGING BRACKET | C250/BB250(TH96) | PL/152 | 1.5 | +3.386 | +3.606 | 6
BEAM | C250-C250/BB250(TH96) | B/70 | 15.3 | +3.369 | +3.623 | 76
FASCIA | C250-C250/BB250(TH75) | F/12 | 7.9 | +3.491 | +3.643 | 64
BB TRUSS BRACKET | C250-C250/BB250(TH75) | PL/2539 | 3.1 | +3.391 | +3.680 | 147.999
TH | C250-C250/BB250(TH75)-BB250(TH96) | B/29 | 2.9 | +3.726 | +3.814 | 125
2 x BRIDGING BRACKET | C250/BB250(TH75) | PL/152 | 1.5 | +3.406 | +3.626 | 6
BEAM | C250-C250/BB250(TH75) | B/70 | 15.3 | +3.389 | +3.643 | 76
GIRT | C200-C200/BB300(TH120) | G/5 | 4.6 | +3.056 | +3.221 | 165
GIRT | C200-C200/BB300(TH96) | G/4 | 4.6 | +3.063 | +3.213 | 150
GIRT | C200-C200/BB300(TH75) | G/3 | 4.6 | +3.076 | +3.201 | 125
GIRT | C200-C200/BB250(TH120) | G/5 | 4.6 | +3.056 | +3.221 | 165
GIRT | C200-C200/BB250(TH96) | G/4 | 4.6 | +3.063 | +3.213 | 150
GIRT | C200-C200/BB250(TH75) | G/3 | 4.6 | +3.076 | +3.201 | 125
GIRT | C200-C200/BB200(TH120) | G/5 | 4.6 | +3.056 | +3.221 | 165
GIRT | C200-C200/BB200(TH96) | G/4 | 4.6 | +3.063 | +3.213 | 150
GIRT | C200-C200/BB200(TH75) | G/3 | 4.6 | +3.076 | +3.201 | 125
PURLIN | C200-C200/BB300(TH120)-BB350(TH75) | PU/6 | 4.6 | +3.661 | +3.798 | 165
FASCIA | C200-C200/BB300(TH120) | F/16 | 8.9 | +3.491 | +3.643 | 64
BRIDGING BEAM | C200-C200/BB300(TH120) | BB/6 | 19 | +3.343 | +3.643 | 96
PURLIN | C200-C200/BB300(TH96)-BB300(TH120) | PU/5 | 4.6 | +3.683 | +3.794 | 150
FASCIA | C200-C200/BB300(TH96) | F/16 | 8.9 | +3.491 | +3.643 | 64
BRIDGING BEAM | C200-C200/BB300(TH96) | BB/6 | 19 | +3.343 | +3.643 | 96
PURLIN | C200-C200/BB300(TH75)-BB300(TH96) | PU/4 | 4.6 | +3.703 | +3.790 | 125
FASCIA | C200-C200/BB300(TH75) | F/16 | 8.9 | +3.491 | +3.643 | 64
BRIDGING BEAM | C200-C200/BB300(TH75) | BB/6 | 19 | +3.343 | +3.643 | 96
2 x BRIDGING BRACKET | C200/BB250(TH120) | PL/152 | 1.5 | +3.396 | +3.616 | 6
2 x BRIDGING BRACKET | C200/BB250(TH96) | PL/152 | 1.5 | +3.406 | +3.626 | 6
2 x BRIDGING BRACKET | C200/BB250(TH75) | PL/152 | 1.5 | +3.406 | +3.626 | 6
PURLIN | C200-C200/BB250(TH120)-BB300(TH75) | PU/6 | 4.6 | +3.661 | +3.798 | 165
FASCIA | C200-C200/BB250(TH120) | F/16 | 8.9 | +3.491 | +3.643 | 64
BRIDGING BEAM | C200-C200/BB250(TH120) | BB/4 | 15.3 | +3.379 | +3.633 | 76
PURLIN | C200-C200/BB250(TH96)-BB250(TH120) | PU/5 | 4.6 | +3.683 | +3.794 | 150
FASCIA | C200-C200/BB250(TH96) | F/16 | 8.9 | +3.491 | +3.643 | 64
BRIDGING BEAM | C200-C200/BB250(TH96) | BB/4 | 15.3 | +3.389 | +3.643 | 76
PURLIN | C200-C200/BB250(TH75)-BB250(TH96) | PU/4 | 4.6 | +3.703 | +3.790 | 125
FASCIA | C200-C200/BB250(TH75) | F/16 | 8.9 | +3.491 | +3.643 | 64
BRIDGING BEAM | C200-C200/BB250(TH75) | BB/4 | 15.3 | +3.389 | +3.643 | 76
BB TRUSS BRACKET | C200-C200/BB200(TH75) | PL/2527 | 1.9 | +3.414 | +3.645 | 147.999
BB TRUSS BRACKET | C200-C200/BB200(TH75) | PL/2536 | 1.9 | +3.414 | +3.645 | 147.999
2 x BRIDGING BRACKET | C200/BB200(TH120) | PL/214 | 1.2 | +3.397 | +3.567 | 6
PURLIN | C200-C200/BB200(TH120)-BB250(TH75) | PU/6 | 4.6 | +3.661 | +3.798 | 165
FASCIA | C200-C200/BB200(TH120) | F/16 | 8.9 | +3.491 | +3.643 | 64
BRIDGING BEAM | C200-C200/BB200(TH120) | BB/2 | 13.5 | +3.380 | +3.583 | 76
2 x BRIDGING BRACKET | C200/BB200(TH96) | PL/214 | 1.2 | +3.417 | +3.587 | 6
PURLIN | C200-C200/BB200(TH96)-BB200(TH120) | PU/5 | 4.6 | +3.683 | +3.794 | 150
FASCIA | C200-C200/BB200(TH96) | F/16 | 8.9 | +3.491 | +3.643 | 64
BRIDGING BEAM | C200-C200/BB200(TH96) | BB/2 | 13.5 | +3.400 | +3.603 | 76
2 x BRIDGING BRACKET | C200/BB200(TH75) | PL/214 | 1.2 | +3.435 | +3.605 | 6
PURLIN | C200-C200/BB200(TH75)-BB200(TH96) | PU/4 | 4.6 | +3.703 | +3.790 | 125
FASCIA | C200-C200/BB200(TH75) | F/16 | 8.9 | +3.491 | +3.643 | 64
BRIDGING BEAM | C200-C200/BB200(TH75) | BB/2 | 13.5 | +3.418 | +3.621 | 76
TH | C150-C150/BB250(TH120) | B/62 | 2.9 | +3.097 | +3.262 | 165
TH | C150-C150/BB250(TH96) | B/35 | 2.9 | +3.104 | +3.254 | 150
TH | C150-C150/BB250(TH75) | B/27 | 2.9 | +3.117 | +3.242 | 125
TH | C150-C150/BB200(TH120) | B/62 | 2.9 | +3.097 | +3.262 | 165
TH | C150-C150/BB200(TH96) | B/35 | 2.9 | +3.104 | +3.254 | 150
TH | C150-C150/BB200(TH75) | B/27 | 2.9 | +3.117 | +3.242 | 125
2 x BRIDGING BRACKET | C150/BB250(TH120) | PL/152 | 1.5 | +3.406 | +3.626 | 6
2 x BRIDGING BRACKET | C150/BB250(TH96) | PL/152 | 1.5 | +3.382 | +3.602 | 6
2 x BRIDGING BRACKET | C150/BB250(TH75) | PL/152 | 1.5 | +3.360 | +3.580 | 6
TH | C150-C150/BB250(TH75)-BB250(TH96) | B/27 | 2.9 | +3.633 | +3.721 | 125
TH | C150-C150/BB250(TH120)-BB300(TH75) | B/62 | 2.9 | +3.638 | +3.774 | 165
FASCIA | C150-C150/BB250(TH120) | F/11 | 7.7 | +3.491 | +3.643 | 64
TH | C150-C150/BB250(TH96)-BB250(TH120) | B/35 | 2.9 | +3.634 | +3.745 | 150
FASCIA | C150-C150/BB250(TH96) | F/11 | 7.7 | +3.467 | +3.619 | 64
FASCIA | C150-C150/BB250(TH75) | F/11 | 7.7 | +3.445 | +3.597 | 64
2 x BRIDGING BRACKET | C150/BB200(TH120) | PL/214 | 1.2 | +3.392 | +3.562 | 6
TH | C150-C150/BB200(TH120)-BB250(TH75) | B/62 | 2.9 | +3.592 | +3.728 | 165
FASCIA | C150-C150/BB200(TH120) | F/11 | 7.7 | +3.445 | +3.597 | 64
2 x BRIDGING BRACKET | C150/BB200(TH96) | PL/214 | 1.2 | +3.411 | +3.581 | 6
TH | C150-C150/BB200(TH96)-BB200(TH120) | B/35 | 2.9 | +3.613 | +3.724 | 150
FASCIA | C150-C150/BB200(TH96) | F/11 | 7.7 | +3.445 | +3.597 | 64
2 x BRIDGING BRACKET | C150/BB200(TH75) | PL/214 | 1.2 | +3.411 | +3.581 | 6
TH | C150-C150/BB200(TH75)-BB200(TH96) | B/27 | 2.9 | +3.633 | +3.721 | 125
FASCIA | C150-C150/BB200(TH75) | F/11 | 7.7 | +3.445 | +3.597 | 64

# IfcMechanicalFastener: Bolt assembly (1584)
In: Undefined
Tekla Bolt - Location: Site
Name | NominalDiameter (mm) = Washer diameter (mm) = Bolt size (mm) | NominalLength (mm) = Bolt length (mm) | Material = Bolt standard | Washer count | Washer type | Washer name | Nut count = Bolt count | Nut type | Nut name | Slotted hole y (mm) | Slotted hole x (mm) | Bolt hole diameter (mm) | Bolt Name
72 x Bolt assembly | 16 | 35 | 8.8S | 4 | HARD | WASHERM16-HARD | 4 | 8.8-HEX | NUTM16-8.8-HEX | 8 | 4 | 22 | BOLTM16*35
18 x Bolt assembly | 16 | 40 | 8.8S | 6 | HARD | WASHERM16-HARD | 6 | 8.8-HEX | NUTM16-8.8-HEX | 0 | 0 | 18 | BOLTM16*40
30 x Bolt assembly | 16 | 40 | 8.8S | 6 | HARD | WASHERM16-HARD | 6 | 8.8-HEX | NUTM16-8.8-HEX | 4 | 0 | 18 | BOLTM16*40
30 x Bolt assembly | 16 | 40 | 8.8S | 6 | HARD | WASHERM16-HARD | 6 | 8.8-HEX | NUTM16-8.8-HEX | 0 | 4 | 18 | BOLTM16*40
36 x Bolt assembly | 16 | 35 | 8.8S | 4 | HARD | WASHERM16-HARD | 4 | 8.8-HEX | NUTM16-8.8-HEX | 4 | 0 | 18 | BOLTM16*35
36 x Bolt assembly | 16 | 35 | 8.8S | 4 | HARD | WASHERM16-HARD | 4 | 8.8-HEX | NUTM16-8.8-HEX | 0 | 4 | 18 | BOLTM16*35
126 x Bolt assembly | 16 | 40 | 8.8S | 4 | HARD | WASHERM16-HARD | 4 | 8.8-HEX | NUTM16-8.8-HEX | 0 | 0 | 18 | BOLTM16*40
60 x Bolt assembly | 12 | 30 | 8.8S | 4 | HARD | WASHERM12-HARD | 4 | 8.8-HEX | NUTM12-8.8-HEX | 8 | 4 | 14 | BOLTM12*30
60 x Bolt assembly | 12 | 30 | 8.8S | 4 | HARD | WASHERM12-HARD | 4 | 8.8-HEX | NUTM12-8.8-HEX | 4 | 8 | 14 | BOLTM12*30
60 x Bolt assembly | 12 | 25 | 8.8S | 4 | HARD | WASHERM12-HARD | 4 | 8.8-HEX | NUTM12-8.8-HEX | 8 | 4 | 18 | BOLTM12*25
30 x Bolt assembly | 12 | 35 | 8.8S | 4 | HARD | WASHERM12-HARD | 4 | 8.8-HEX | NUTM12-8.8-HEX | 0 | 0 | 14 | BOLTM12*35
354 x Bolt assembly | 5 | 25 | TEK_16TPIM | 4 | UNDEF_WASH | UNDEFINED_WASHER10G | 2 | UNDEF_NUT | UNDEFINED_NUT10G | 0 | 0 | 7 | TEKSCREW_M5*25
127 x Bolt assembly | 5 | 25 | TEK_16TPIM | 8 | UNDEF_WASH | UNDEFINED_WASHER10G | 4 | UNDEF_NUT | UNDEFINED_NUT10G | 0 | 0 | 7 | TEKSCREW_M5*25
132 x Bolt assembly | 5 | 25 | TEK_16TPIM | 2 | UNDEF_WASH | UNDEFINED_WASHER10G | 2 | UNDEF_NUT | UNDEFINED_NUT10G | 0 | 0 | 7 | TEKSCREW_M5*25
108 x Bolt assembly | 16 | 40 | 8.8S | 3 | HARD | WASHERM16-HARD | 3 | 8.8-HEX | NUTM16-8.8-HEX | 0 | 0 | 22 | BOLTM16*40
72 x Bolt assembly | 16 | 35 | 8.8S | 3 | HARD | WASHERM16-HARD | 3 | 8.8-HEX | NUTM16-8.8-HEX | 0 | 0 | 18 | BOLTM16*35
18 x Bolt assembly | 5 | 25 | TEK_16TPIM | 16 | UNDEF_WASH | UNDEFINED_WASHER10G | 4 | UNDEF_NUT | UNDEFINED_NUT10G | 0 | 0 | 7 | TEKSCREW_M5*25
36 x Bolt assembly | 12 | 30 | PB1230 | 3 | FLAT | WASHERM12-FLAT | 3 | 4.6-HEX | NUTM12-4.6-HEX | 0 | 0 | 14 | BOLTPB1230
24 x Bolt assembly | 12 | 30 | PB1230 | 3 | FLAT | WASHERM12-FLAT | 3 | 4.6-HEX | NUTM12-4.6-HEX | 0 | 0 | 18 | BOLTPB1230
36 x Bolt assembly | 12 | 30 | PB1230 | 4 | FLAT | WASHERM12-FLAT | 4 | 4.6-HEX | NUTM12-4.6-HEX | 4 | 0 | 14 | BOLTPB1230
24 x Bolt assembly | 12 | 30 | PB1230 | 3 | FLAT | WASHERM12-FLAT | 3 | 4.6-HEX | NUTM12-4.6-HEX | 4 | 8 | 14 | BOLTPB1230
53 x Bolt assembly | 5 | 11.6 | TEK_16TPIM | 8 | UNDEF_WASH | UNDEFINED_WASHER10G | 4 | UNDEF_NUT | UNDEFINED_NUT10G | 0 | 0 | 7 | TEKSCREW_M5*25
30 x Bolt assembly | 5 | 25 | TEK_16TPIM | 8 | UNDEF_WASH | UNDEFINED_WASHER10G | 2 | UNDEF_NUT | UNDEFINED_NUT10G | 0 | 0 | 7 | TEKSCREW_M5*25
12 x Bolt assembly | 5 | 11.6 | TEK_16TPIM | 4 | UNDEF_WASH | UNDEFINED_WASHER10G | 2 | UNDEF_NUT | UNDEFINED_NUT10G | 0 | 0 | 7 | TEKSCREW_M5*25

# IfcPlate: PLT3*154.8 (24)
In: Undefined
Description: PLT3*154.8; Material: STEEL/450
Tekla Common - Phase: 1; Class: 9
Tekla Quantity - Weight: 1.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.7 m2; Net surface area: 0.1 m2; Height: 154.8 mm; Width: 3 mm; Length: 388.4 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 154.776 mm; NetArea: 0.102749 m2; GrossArea: 0.0601128 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000149199 m3; GrossVolume: 0.000149199 m3
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation
BB TRUSS BRACKET | PL/2050(?) | +3.425 | +3.596
BB TRUSS BRACKET | PL/2051(?) | +3.425 | +3.596
BB TRUSS BRACKET | PL/2050(?) | +3.422 | +3.593
BB TRUSS BRACKET | PL/2051(?) | +3.422 | +3.593
2 x BB TRUSS BRACKET | PL/2050(?) | +3.419 | +3.590
2 x BB TRUSS BRACKET | PL/2051(?) | +3.419 | +3.590
BB TRUSS BRACKET | PL/2050(?) | +3.379 | +3.550
BB TRUSS BRACKET | PL/2051(?) | +3.379 | +3.550
BB TRUSS BRACKET | PL/2050(?) | +3.400 | +3.571
BB TRUSS BRACKET | PL/2051(?) | +3.400 | +3.571
BB TRUSS BRACKET | PL/2526 | +3.428 | +3.599
BB TRUSS BRACKET | PL/2521 | +3.428 | +3.599
BB TRUSS BRACKET | PL/2526 | +3.423 | +3.594
BB TRUSS BRACKET | PL/2521 | +3.423 | +3.594
2 x BB TRUSS BRACKET | PL/2526 | +3.419 | +3.590
2 x BB TRUSS BRACKET | PL/2521 | +3.419 | +3.590
BB TRUSS BRACKET | PL/2526 | +3.382 | +3.553
BB TRUSS BRACKET | PL/2521 | +3.382 | +3.553
BB TRUSS BRACKET | PL/2526 | +3.402 | +3.573
BB TRUSS BRACKET | PL/2521 | +3.402 | +3.573

# IfcPlate: PLT3*204.8 (36)
In: Undefined
Description: PLT3*204.8; Material: STEEL/450
Tekla Common - Phase: 1; Class: 9
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.2 m2; Height: 204.8 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Net surface area (m2) | Length (mm) | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
BB TRUSS BRACKET | PL/2057(?) | +3.381 | +3.605 | 1.7 | 0.1 | 408.5 | 204.768 | 0.147126 | 0.0836386 | 0.000215045
BB TRUSS BRACKET | PL/2054(?) | +3.381 | +3.605 | 1.7 | 0.1 | 408.5 | 204.766 | 0.147125 | 0.0836376 | 0.000215044
BB TRUSS BRACKET | PL/2057(?) | +3.402 | +3.626 | 1.7 | 0.1 | 408.5 | 204.768 | 0.147126 | 0.0836386 | 0.000215045
BB TRUSS BRACKET | PL/2054(?) | +3.402 | +3.626 | 1.7 | 0.1 | 408.5 | 204.766 | 0.147125 | 0.0836376 | 0.000215044
BB TRUSS BRACKET | PL/2056(?) | +3.374 | +3.605 | 1.9 | 0.2 | 449.1 | 204.778 | 0.161998 | 0.0919602 | 0.000236987
BB TRUSS BRACKET | PL/2053(?) | +3.374 | +3.605 | 1.9 | 0.2 | 449.1 | 204.775 | 0.161997 | 0.0919589 | 0.000236986
BB TRUSS BRACKET | PL/2056(?) | +3.395 | +3.626 | 1.9 | 0.2 | 449.1 | 204.778 | 0.161998 | 0.0919602 | 0.000236987
BB TRUSS BRACKET | PL/2053(?) | +3.395 | +3.626 | 1.9 | 0.2 | 449.1 | 204.775 | 0.161997 | 0.0919589 | 0.000236986
BB TRUSS BRACKET | PL/2055(?) | +3.374 | +3.605 | 1.9 | 0.2 | 449.1 | 204.764 | 0.161992 | 0.0919537 | 0.000236978
BB TRUSS BRACKET | PL/2052(?) | +3.374 | +3.605 | 1.9 | 0.2 | 449.1 | 204.762 | 0.161991 | 0.0919527 | 0.000236977
BB TRUSS BRACKET | PL/2055(?) | +3.395 | +3.626 | 1.9 | 0.2 | 449.1 | 204.764 | 0.161992 | 0.0919537 | 0.000236978
BB TRUSS BRACKET | PL/2052(?) | +3.395 | +3.626 | 1.9 | 0.2 | 449.1 | 204.762 | 0.161991 | 0.0919527 | 0.000236977
BB TRUSS BRACKET | PL/2057(?) | +3.420 | +3.644 | 1.7 | 0.1 | 408.5 | 204.768 | 0.147126 | 0.0836386 | 0.000215045
BB TRUSS BRACKET | PL/2054(?) | +3.420 | +3.644 | 1.7 | 0.1 | 408.5 | 204.766 | 0.147125 | 0.0836376 | 0.000215044
BB TRUSS BRACKET | PL/2056(?) | +3.413 | +3.644 | 1.9 | 0.2 | 449.1 | 204.778 | 0.161998 | 0.0919602 | 0.000236987
BB TRUSS BRACKET | PL/2053(?) | +3.413 | +3.644 | 1.9 | 0.2 | 449.1 | 204.775 | 0.161997 | 0.0919589 | 0.000236986
BB TRUSS BRACKET | PL/2055(?) | +3.413 | +3.644 | 1.9 | 0.2 | 449.1 | 204.764 | 0.161992 | 0.0919537 | 0.000236978
BB TRUSS BRACKET | PL/2052(?) | +3.413 | +3.644 | 1.9 | 0.2 | 449.1 | 204.762 | 0.161991 | 0.0919527 | 0.000236977
BB TRUSS BRACKET | PL/2529 | +3.383 | +3.607 | 1.7 | 0.1 | 408.5 | 204.768 | 0.147126 | 0.0836386 | 0.000215045
BB TRUSS BRACKET | PL/2538 | +3.383 | +3.607 | 1.7 | 0.1 | 408.5 | 204.766 | 0.147125 | 0.0836376 | 0.000215044
BB TRUSS BRACKET | PL/2529 | +3.403 | +3.627 | 1.7 | 0.1 | 408.5 | 204.768 | 0.147126 | 0.0836386 | 0.000215045
BB TRUSS BRACKET | PL/2538 | +3.403 | +3.627 | 1.7 | 0.1 | 408.5 | 204.766 | 0.147125 | 0.0836376 | 0.000215044
BB TRUSS BRACKET | PL/2528 | +3.376 | +3.607 | 1.9 | 0.2 | 449.1 | 204.778 | 0.161998 | 0.0919602 | 0.000236987
BB TRUSS BRACKET | PL/2537 | +3.376 | +3.607 | 1.9 | 0.2 | 449.1 | 204.775 | 0.161997 | 0.0919589 | 0.000236986
BB TRUSS BRACKET | PL/2528 | +3.396 | +3.627 | 1.9 | 0.2 | 449.1 | 204.778 | 0.161998 | 0.0919602 | 0.000236987
BB TRUSS BRACKET | PL/2537 | +3.396 | +3.627 | 1.9 | 0.2 | 449.1 | 204.775 | 0.161997 | 0.0919589 | 0.000236986
BB TRUSS BRACKET | PL/2527 | +3.376 | +3.607 | 1.9 | 0.2 | 449.1 | 204.764 | 0.161992 | 0.0919537 | 0.000236978
BB TRUSS BRACKET | PL/2536 | +3.376 | +3.607 | 1.9 | 0.2 | 449.1 | 204.762 | 0.161991 | 0.0919526 | 0.000236977
BB TRUSS BRACKET | PL/2527 | +3.396 | +3.627 | 1.9 | 0.2 | 449.1 | 204.764 | 0.161992 | 0.0919537 | 0.000236978
BB TRUSS BRACKET | PL/2536 | +3.396 | +3.627 | 1.9 | 0.2 | 449.1 | 204.762 | 0.161991 | 0.0919526 | 0.000236977
BB TRUSS BRACKET | PL/2529 | +3.421 | +3.645 | 1.7 | 0.1 | 408.5 | 204.768 | 0.147126 | 0.0836386 | 0.000215045
BB TRUSS BRACKET | PL/2538 | +3.421 | +3.645 | 1.7 | 0.1 | 408.5 | 204.766 | 0.147125 | 0.0836376 | 0.000215044
BB TRUSS BRACKET | PL/2528 | +3.414 | +3.645 | 1.9 | 0.2 | 449.1 | 204.778 | 0.161998 | 0.0919602 | 0.000236987
BB TRUSS BRACKET | PL/2537 | +3.414 | +3.645 | 1.9 | 0.2 | 449.1 | 204.775 | 0.161997 | 0.0919589 | 0.000236986
BB TRUSS BRACKET | PL/2527 | +3.414 | +3.645 | 1.9 | 0.2 | 449.1 | 204.764 | 0.161992 | 0.0919537 | 0.000236978
BB TRUSS BRACKET | PL/2536 | +3.414 | +3.645 | 1.9 | 0.2 | 449.1 | 204.762 | 0.161991 | 0.0919526 | 0.000236977

# IfcPlate: PLT3*232.9 (12)
In: Undefined
Description: PLT3*232.9; Material: STEEL/450
Tekla Common - Phase: 1; Class: 2
Tekla Quantity - Weight: 1.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.4 m2; Net surface area: 0.2 m2; Height: 232.9 mm; Width: 3 mm; Length: 350 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 232.879 mm; NetArea: 0.169434 m2; GrossArea: 0.0815076 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000247169 m3; GrossVolume: 0.000247169 m3
Name | Bottom elevation | Top elevation | ASSEMBLY_POS = Reference
BRIDGING-COLUMN STIFF | +3.361 | +3.711 | PL/91(?)
BRIDGING-COLUMN STIFF | +3.314 | +3.664 | PL/91(?)
2 x BRIDGING-COLUMN STIFF | +3.269 | +3.619 | PL/91(?)
BRIDGING-COLUMN STIFF | +3.315 | +3.665 | PL/91(?)
BRIDGING-COLUMN STIFF | +3.293 | +3.643 | PL/91(?)
BRIDGING-COLUMN STIFF | +3.293 | +3.643 | PL/91
BRIDGING-COLUMN STIFF | +3.269 | +3.619 | PL/91
4 x BRIDGING-COLUMN STIFF | +3.247 | +3.597 | PL/91

# IfcPlate: PLT3*254.8 (36)
In: Undefined
Description: PLT3*254.8; Material: STEEL/450
Pset_PlateCommon - LoadBearing: no
Tekla Common - Phase: 1; Class: 9
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.7 m2; Height: 254.8 mm; Width: 3 mm
BaseQuantities - CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Net surface area (m2) | Length (mm) | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) | GrossVolume (m3)
2 x BB TRUSS BRACKET | PL/0(?) | +3.340 | +3.628 | 2.6 | 0.2 | 495.3 | 254.77 | 0.225727 | 0.126175 | 0.000331628 | 0.000331628
2 x BB TRUSS BRACKET | PL/0(?) | +3.360 | +3.649 | 2.6 | 0.2 | 495.3 | 254.77 | 0.225727 | 0.126175 | 0.000331628 | 0.000331628
BB TRUSS BRACKET | PL/2062(?) | +3.329 | +3.628 | 2.9 | 0.3 | 554.2 | 254.769 | 0.253175 | 0.141181 | 0.000372269 | 0.000372269
BB TRUSS BRACKET | PL/2059(?) | +3.329 | +3.628 | 2.9 | 0.3 | 554.2 | 254.769 | 0.253175 | 0.141181 | 0.000372269 | 0.000372269
BB TRUSS BRACKET | PL/2062(?) | +3.350 | +3.649 | 2.9 | 0.3 | 554.2 | 254.769 | 0.253175 | 0.141181 | 0.000372269 | 0.000372269
BB TRUSS BRACKET | PL/2059(?) | +3.350 | +3.649 | 2.9 | 0.3 | 554.2 | 254.769 | 0.253175 | 0.141181 | 0.000372269 | 0.000372269
BB TRUSS BRACKET | PL/0(?) | +3.337 | +3.628 | 3.1 | 0.3 | 592.3 | 254.767 | 0.266768 | 0.150897 | 0.000392397 | 0.000400297
BB TRUSS BRACKET | PL/2061(?) | +3.337 | +3.628 | 3.1 | 0.3 | 592.3 | 254.767 | 0.266768 | 0.150897 | 0.000392397 | 0.000400297
BB TRUSS BRACKET | PL/0(?) | +3.358 | +3.649 | 3.1 | 0.3 | 592.3 | 254.767 | 0.266768 | 0.150897 | 0.000392397 | 0.000400297
BB TRUSS BRACKET | PL/2061(?) | +3.358 | +3.649 | 3.1 | 0.3 | 592.3 | 254.767 | 0.266768 | 0.150897 | 0.000392397 | 0.000400297
BB TRUSS BRACKET | PL/0(?) | +3.376 | +3.667 | 3.1 | 0.3 | 592.3 | 254.767 | 0.266768 | 0.150897 | 0.000392397 | 0.000400297
2 x BB TRUSS BRACKET | PL/0(?) | +3.379 | +3.667 | 2.6 | 0.2 | 495.3 | 254.77 | 0.225727 | 0.126175 | 0.000331628 | 0.000331628
BB TRUSS BRACKET | PL/2062(?) | +3.369 | +3.667 | 2.9 | 0.3 | 554.2 | 254.769 | 0.253175 | 0.141181 | 0.000372269 | 0.000372269
BB TRUSS BRACKET | PL/2059(?) | +3.369 | +3.667 | 2.9 | 0.3 | 554.2 | 254.769 | 0.253175 | 0.141181 | 0.000372269 | 0.000372269
BB TRUSS BRACKET | PL/2061(?) | +3.376 | +3.667 | 3.1 | 0.3 | 592.3 | 254.767 | 0.266768 | 0.150897 | 0.000392397 | 0.000400297
BB TRUSS BRACKET | PL/2541 | +3.355 | +3.643 | 2.6 | 0.2 | 495.3 | 254.77 | 0.225727 | 0.126175 | 0.000331628 | 0.000331628
BB TRUSS BRACKET | PL/2548 | +3.355 | +3.643 | 2.6 | 0.2 | 495.3 | 254.77 | 0.225727 | 0.126175 | 0.000331628 | 0.000331628
BB TRUSS BRACKET | PL/2541 | +3.374 | +3.663 | 2.6 | 0.2 | 495.3 | 254.77 | 0.225727 | 0.126175 | 0.000331628 | 0.000331628
BB TRUSS BRACKET | PL/2548 | +3.374 | +3.663 | 2.6 | 0.2 | 495.3 | 254.77 | 0.225727 | 0.126175 | 0.000331628 | 0.000331628
BB TRUSS BRACKET | PL/2540 | +3.345 | +3.643 | 2.9 | 0.3 | 554.2 | 254.769 | 0.253173 | 0.141181 | 0.000372267 | 0.000372267
BB TRUSS BRACKET | PL/2547 | +3.345 | +3.643 | 2.9 | 0.3 | 554.2 | 254.769 | 0.253173 | 0.141181 | 0.000372267 | 0.000372267
BB TRUSS BRACKET | PL/2540 | +3.364 | +3.663 | 2.9 | 0.3 | 554.2 | 254.769 | 0.253173 | 0.141181 | 0.000372267 | 0.000372267
BB TRUSS BRACKET | PL/2547 | +3.364 | +3.663 | 2.9 | 0.3 | 554.2 | 254.769 | 0.253173 | 0.141181 | 0.000372267 | 0.000372267
BB TRUSS BRACKET | PL/2546 | +3.354 | +3.643 | 3.1 | 0.3 | 591.9 | 254.767 | 0.265824 | 0.150807 | 0.000390995 | 0.000400298
BB TRUSS BRACKET | PL/2539 | +3.354 | +3.643 | 3.1 | 0.3 | 591.9 | 254.767 | 0.265824 | 0.150807 | 0.000390995 | 0.000400298
BB TRUSS BRACKET | PL/2546 | +3.374 | +3.663 | 3.1 | 0.3 | 591.9 | 254.767 | 0.265824 | 0.150807 | 0.000390995 | 0.000400298
BB TRUSS BRACKET | PL/2539 | +3.374 | +3.663 | 3.1 | 0.3 | 591.9 | 254.767 | 0.265824 | 0.150807 | 0.000390995 | 0.000400298
BB TRUSS BRACKET | PL/2546 | +3.391 | +3.680 | 3.1 | 0.3 | 591.9 | 254.767 | 0.265824 | 0.150807 | 0.000390995 | 0.000400298
BB TRUSS BRACKET | PL/2541 | +3.392 | +3.680 | 2.6 | 0.2 | 495.3 | 254.77 | 0.225727 | 0.126175 | 0.000331628 | 0.000331628
BB TRUSS BRACKET | PL/2548 | +3.392 | +3.680 | 2.6 | 0.2 | 495.3 | 254.77 | 0.225727 | 0.126175 | 0.000331628 | 0.000331628
BB TRUSS BRACKET | PL/2540 | +3.381 | +3.680 | 2.9 | 0.3 | 554.2 | 254.769 | 0.253173 | 0.141181 | 0.000372267 | 0.000372267
BB TRUSS BRACKET | PL/2547 | +3.381 | +3.680 | 2.9 | 0.3 | 554.2 | 254.769 | 0.253173 | 0.141181 | 0.000372267 | 0.000372267
BB TRUSS BRACKET | PL/2539 | +3.391 | +3.680 | 3.1 | 0.3 | 591.9 | 254.767 | 0.265824 | 0.150807 | 0.000390995 | 0.000400298

# IfcPlate: PLT3*304.7 (24)
In: Undefined
Description: PLT3*304.7; Material: STEEL/450
Tekla Common - Phase: 1; Class: 9
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.3 m2; Height: 304.7 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Net surface area (m2) | Length (mm) | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) | GrossVolume (m3)
BB TRUSS BRACKET | PL/0(?) | +3.292 | +3.659 | 4.3 | 0.5 | 665.1 | 304.728 | 0.36782 | 0.202689 | 0.0005427 | 0.0005427
BB TRUSS BRACKET | PL/2065(?) | +3.292 | +3.659 | 4.3 | 0.5 | 665.1 | 304.728 | 0.36782 | 0.202689 | 0.0005427 | 0.0005427
BB TRUSS BRACKET | PL/0(?) | +3.288 | +3.655 | 4.3 | 0.5 | 665.1 | 304.728 | 0.36782 | 0.202689 | 0.0005427 | 0.0005427
BB TRUSS BRACKET | PL/2065(?) | +3.288 | +3.655 | 4.3 | 0.5 | 665.1 | 304.728 | 0.36782 | 0.202689 | 0.0005427 | 0.0005427
BB TRUSS BRACKET | PL/2066(?) | +3.299 | +3.659 | 4.6 | 0.5 | 720.9 | 304.727 | 0.394072 | 0.219682 | 0.000581678 | 0.000592168
BB TRUSS BRACKET | PL/2064(?) | +3.299 | +3.659 | 4.6 | 0.5 | 720.9 | 304.727 | 0.394072 | 0.219682 | 0.000581678 | 0.000592168
BB TRUSS BRACKET | PL/2066(?) | +3.320 | +3.679 | 4.6 | 0.5 | 720.9 | 304.727 | 0.394072 | 0.219682 | 0.000581678 | 0.000592168
BB TRUSS BRACKET | PL/2064(?) | +3.320 | +3.679 | 4.6 | 0.5 | 720.9 | 304.727 | 0.394072 | 0.219682 | 0.000581678 | 0.000592168
BB TRUSS BRACKET | PL/0(?) | +3.285 | +3.652 | 4.3 | 0.3 | 665.1 | 304.728 | 0.36782 | 0.202689 | 0.0005427 | 0.0005427
BB TRUSS BRACKET | PL/2065(?) | +3.285 | +3.652 | 4.3 | 0.3 | 665.1 | 304.728 | 0.36782 | 0.202689 | 0.0005427 | 0.0005427
BB TRUSS BRACKET | PL/2066(?) | +3.339 | +3.698 | 4.6 | 0.3 | 720.9 | 304.727 | 0.394072 | 0.219682 | 0.000581678 | 0.000592168
BB TRUSS BRACKET | PL/2064(?) | +3.339 | +3.698 | 4.6 | 0.3 | 720.9 | 304.727 | 0.394072 | 0.219682 | 0.000581678 | 0.000592168
BB TRUSS BRACKET | PL/2549 | +3.294 | +3.661 | 4.3 | 0.3 | 665.1 | 304.728 | 0.36782 | 0.202689 | 0.0005427 | 0.0005427
BB TRUSS BRACKET | PL/2556 | +3.294 | +3.661 | 4.3 | 0.3 | 665.1 | 304.728 | 0.36782 | 0.202689 | 0.0005427 | 0.0005427
BB TRUSS BRACKET | PL/2549 | +3.290 | +3.657 | 4.3 | 0.3 | 665.1 | 304.728 | 0.36782 | 0.202689 | 0.0005427 | 0.0005427
BB TRUSS BRACKET | PL/2556 | +3.290 | +3.657 | 4.3 | 0.3 | 665.1 | 304.728 | 0.36782 | 0.202689 | 0.0005427 | 0.0005427
BB TRUSS BRACKET | PL/2550 | +3.306 | +3.661 | 4.4 | 0.3 | 720.2 | 304.727 | 0.391809 | 0.219452 | 0.000578316 | 0.000592168
BB TRUSS BRACKET | PL/2557 | +3.306 | +3.661 | 4.4 | 0.3 | 720.2 | 304.727 | 0.391809 | 0.219452 | 0.000578316 | 0.000592168
BB TRUSS BRACKET | PL/2550 | +3.326 | +3.681 | 4.4 | 0.3 | 720.2 | 304.727 | 0.391809 | 0.219452 | 0.000578316 | 0.000592168
BB TRUSS BRACKET | PL/2557 | +3.326 | +3.681 | 4.4 | 0.3 | 720.2 | 304.727 | 0.391809 | 0.219452 | 0.000578316 | 0.000592168
BB TRUSS BRACKET | PL/2549 | +3.286 | +3.653 | 4.3 | 0.3 | 665.1 | 304.728 | 0.36782 | 0.202689 | 0.0005427 | 0.0005427
BB TRUSS BRACKET | PL/2556 | +3.286 | +3.653 | 4.3 | 0.3 | 665.1 | 304.728 | 0.36782 | 0.202689 | 0.0005427 | 0.0005427
BB TRUSS BRACKET | PL/2550 | +3.344 | +3.699 | 4.4 | 0.3 | 720.2 | 304.727 | 0.391809 | 0.219452 | 0.000578316 | 0.000592168
BB TRUSS BRACKET | PL/2557 | +3.344 | +3.699 | 4.4 | 0.3 | 720.2 | 304.727 | 0.391809 | 0.219452 | 0.000578316 | 0.000592168

# IfcPlate: PLT3*307.9 (18)
In: Undefined
Description: PLT3*307.9; Material: STEEL/450
Tekla Common - Phase: 1; Class: 2
Tekla Quantity - Weight: 2.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 86.9 m2; Net surface area: 0.2 m2; Height: 307.9 mm; Width: 3 mm; Length: 350 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 307.879 mm; NetArea: 0.222384 m2; GrossArea: 0.107758 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.000325919 m3; GrossVolume: 0.000325919 m3
Name | Bottom elevation | Top elevation | ASSEMBLY_POS = Reference
3 x BRIDGING-COLUMN STIFF | +3.360 | +3.710 | PL/111(?)
3 x BRIDGING-COLUMN STIFF | +3.339 | +3.689 | PL/111(?)
3 x BRIDGING-COLUMN STIFF | +3.315 | +3.665 | PL/111(?)
9 x BRIDGING-COLUMN STIFF | +3.293 | +3.643 | PL/111

# IfcPlate: PLT3*310 (66)
In: Undefined
Description: PLT3*310; Material: STEEL/450
Tekla Common - Phase: 1; Class: 11
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 310 mm; Width: 3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 310.001 mm; CrossSectionArea: 0.000009 m2
Name | ASSEMBLY_POS = Reference | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
BRIDGING U-PLATE | PL/2030(?) | +3.317 | +3.625 | 3.6 | 86.5 | 0.3 | 491.3 | 0.311989 | 0.152296 | 0.000459232
BRIDGING U-PLATE | PL/2046(?) | +3.293 | +3.651 | 4.4 | 86.3 | 0.3 | 599.3 | 0.379597 | 0.185776 | 0.000559672
BRIDGING U-PLATE | PL/2030(?) | +3.296 | +3.604 | 3.6 | 86.5 | 0.3 | 491.3 | 0.311989 | 0.152296 | 0.000459232
BRIDGING U-PLATE | PL/2046(?) | +3.296 | +3.654 | 4.4 | 86.3 | 0.3 | 599.3 | 0.379597 | 0.185776 | 0.000559672
BRIDGING U-PLATE | PL/2045(?) | +3.266 | +3.624 | 4.4 | 86.3 | 0.3 | 599.3 | 0.379597 | 0.185776 | 0.000559672
BRIDGING U-PLATE | PL/1992(?) | +3.335 | +3.643 | 3.6 | 86.5 | 0.3 | 491.3 | 0.311989 | 0.152296 | 0.000459232
BRIDGING U-PLATE | PL/2034(?) | +3.275 | +3.633 | 4.4 | 86.3 | 0.3 | 599.3 | 0.379597 | 0.185776 | 0.000559672
BRIDGING U-PLATE | PL/2034(?) | +3.293 | +3.651 | 4.4 | 86.3 | 0.3 | 599.3 | 0.379597 | 0.185776 | 0.000559672
BRIDGING U-PLATE | PL/2044(?) | +3.332 | +3.690 | 4.4 | 86.3 | 0.3 | 599.3 | 0.379597 | 0.185776 | 0.000559672
BRIDGING U-PLATE | PL/2043(?) | +3.334 | +3.692 | 4.4 | 86.3 | 0.3 | 599.3 | 0.379597 | 0.185776 | 0.000559672
BRIDGING U-PLATE | PL/2042(?) | +3.311 | +3.669 | 4.4 | 86.3 | 0.3 | 599.3 | 0.379597 | 0.185776 | 0.000559672
BRIDGING U-PLATE | PL/2041(?) | +3.332 | +3.640 | 3.6 | 86.5 | 0.3 | 491.3 | 0.311989 | 0.152296 | 0.000459232
BRIDGING U-PLATE | PL/2040(?) | +3.352 | +3.660 | 3.6 | 86.5 | 0.3 | 491.3 | 0.311989 | 0.152296 | 0.000459232
BRIDGING U-PLATE | PL/2039(?) | +3.361 | +3.669 | 3.6 | 86.5 | 0.3 | 491.3 | 0.311989 | 0.152296 | 0.000459232
BRIDGING U-PLATE | PL/1985(?) | +3.332 | +3.594 | 2.9 | 86.7 | 0.3 | 405.3 | 0.258153 | 0.125636 | 0.000379252
BRIDGING U-PLATE | PL/1985(?) | +3.354 | +3.616 | 2.9 | 86.7 | 0.3 | 405.3 | 0.258153 | 0.125636 | 0.000379252
BRIDGING U-PLATE | PL/2018(?) | +3.372 | +3.634 | 2.9 | 86.7 | 0.3 | 405.3 | 0.258153 | 0.125636 | 0.000379252
BRIDGING U-PLATE | PL/2047(?) | +3.254 | +3.612 | 4.4 | 86.3 | 0.3 | 599.3 | 0.379597 | 0.185776 | 0.000559672
BRIDGING U-PLATE | PL/2038(?) | +3.373 | +3.681 | 3.6 | 86.5 | 0.3 | 491.3 | 0.311989 | 0.152296 | 0.000459232
BRIDGING U-PLATE | PL/2037(?) | +3.385 | +3.693 | 3.6 | 86.5 | 0.3 | 491.3 | 0.311989 | 0.152296 | 0.000459232
BRIDGING U-PLATE | PL/2031(?) | +3.361 | +3.669 | 3.6 | 86.5 | 0.3 | 491.3 | 0.311989 | 0.152296 | 0.000459232
BRIDGING U-PLATE | PL/2026(?) | +3.373 | +3.635 | 2.9 | 86.7 | 0.3 | 405.3 | 0.258153 | 0.125636 | 0.000379252
BRIDGING U-PLATE | PL/2026(?) | +3.395 | +3.657 | 2.9 | 86.7 | 0.3 | 405.3 | 0.258153 | 0.125636 | 0.000379252
BRIDGING U-PLATE | PL/2025(?) | +3.407 | +3.669 | 2.9 | 86.7 | 0.3 | 405.3 | 0.258153 | 0.125636 | 0.000379252
BRIDGING U-PLATE | PL/2017(?) | +3.373 | +3.584 | 2.6 | 86.9 | 0.2 | 354.3 | 0.226227 | 0.109826 | 0.000331822
BRIDGING U-PLATE | PL/2035(?) | +3.395 | +3.606 | 2.6 | 86.9 | 0.2 | 354.3 | 0.226227 | 0.109826 | 0.000331822
BRIDGING U-PLATE | PL/2035(?) | +3.412 | +3.623 | 2.6 | 86.9 | 0.2 | 354.3 | 0.226227 | 0.109826 | 0.000331822
BRIDGING U-PLATE | PL/2016(?) | +3.415 | +3.677 | 2.9 | 86.7 | 0.3 | 405.3 | 0.258153 | 0.125636 | 0.000379252
BRIDGING U-PLATE | PL/2015(?) | +3.406 | +3.668 | 2.9 | 86.7 | 0.3 | 405.3 | 0.258153 | 0.125636 | 0.000379252
BRIDGING U-PLATE | PL/2014(?) | +3.361 | +3.623 | 2.9 | 86.7 | 0.3 | 405.3 | 0.258153 | 0.125636 | 0.000379252
BRIDGING U-PLATE | PL/2007(?) | +3.369 | +3.580 | 2.6 | 86.9 | 0.2 | 354.3 | 0.226227 | 0.109826 | 0.000331822
BRIDGING U-PLATE | PL/1999(?) | +3.391 | +3.602 | 2.6 | 86.9 | 0.2 | 354.3 | 0.226227 | 0.109826 | 0.000331822
BRIDGING U-PLATE | PL/2005(?) | +3.412 | +3.623 | 2.6 | 86.9 | 0.2 | 354.3 | 0.226227 | 0.109826 | 0.000331822
BRIDGING U-PLATE | PL/2555 | +3.319 | +3.627 | 3.6 | 86.5 | 0.3 | 491.3 | 0.311989 | 0.152296 | 0.000459232
BRIDGING U-PLATE | PL/2552 | +3.265 | +3.623 | 4.4 | 86.3 | 0.3 | 599.3 | 0.379597 | 0.185776 | 0.000559672
BRIDGING U-PLATE | PL/2555 | +3.299 | +3.607 | 3.6 | 86.5 | 0.3 | 491.3 | 0.311989 | 0.152296 | 0.000459232
BRIDGING U-PLATE | PL/2553 | +3.290 | +3.648 | 4.4 | 86.3 | 0.3 | 599.3 | 0.379597 | 0.185776 | 0.000559672
BRIDGING U-PLATE | PL/2551 | +3.244 | +3.602 | 4.4 | 86.3 | 0.3 | 599.3 | 0.379597 | 0.185776 | 0.000559672
BRIDGING U-PLATE | PL/2554 | +3.340 | +3.648 | 3.6 | 86.5 | 0.3 | 491.3 | 0.311989 | 0.152296 | 0.000459232
BRIDGING U-PLATE | PL/2033 | +3.277 | +3.635 | 4.4 | 86.3 | 0.3 | 599.3 | 0.379597 | 0.185776 | 0.000559672
BRIDGING U-PLATE | PL/2559 | +3.289 | +3.647 | 4.4 | 86.3 | 0.3 | 599.3 | 0.379597 | 0.185776 | 0.000559672
BRIDGING U-PLATE | PL/2024 | +3.289 | +3.647 | 4.4 | 86.3 | 0.3 | 599.3 | 0.379597 | 0.185776 | 0.000559672
BRIDGING U-PLATE | PL/2023 | +3.289 | +3.647 | 4.4 | 86.3 | 0.3 | 599.3 | 0.379597 | 0.185776 | 0.000559672
BRIDGING U-PLATE | PL/1986 | +3.289 | +3.647 | 4.4 | 86.3 | 0.3 | 599.3 | 0.379597 | 0.185776 | 0.000559672
BRIDGING U-PLATE | PL/2545 | +3.339 | +3.647 | 3.6 | 86.5 | 0.3 | 491.3 | 0.311989 | 0.152296 | 0.000459232
BRIDGING U-PLATE | PL/2544 | +3.339 | +3.647 | 3.6 | 86.5 | 0.3 | 491.3 | 0.311989 | 0.152296 | 0.000459232
BRIDGING U-PLATE | PL/2543 | +3.339 | +3.647 | 3.6 | 86.5 | 0.3 | 491.3 | 0.311989 | 0.152296 | 0.000459232
BRIDGING U-PLATE | PL/2018 | +3.350 | +3.612 | 2.9 | 86.7 | 0.3 | 405.3 | 0.258153 | 0.125636 | 0.000379252
BRIDGING U-PLATE | PL/2542 | +3.365 | +3.627 | 2.9 | 86.7 | 0.3 | 405.3 | 0.258153 | 0.125636 | 0.000379252
BRIDGING U-PLATE | PL/2018 | +3.385 | +3.647 | 2.9 | 86.7 | 0.3 | 405.3 | 0.258153 | 0.125636 | 0.000379252
BRIDGING U-PLATE | PL/2535 | +3.339 | +3.647 | 3.6 | 86.5 | 0.3 | 491.3 | 0.311989 | 0.152296 | 0.000459232
BRIDGING U-PLATE | PL/2534 | +3.339 | +3.647 | 3.6 | 86.5 | 0.3 | 491.3 | 0.311989 | 0.152296 | 0.000459232
BRIDGING U-PLATE | PL/2533 | +3.339 | +3.647 | 3.6 | 86.5 | 0.3 | 491.3 | 0.311989 | 0.152296 | 0.000459232
BRIDGING U-PLATE | PL/2532 | +3.375 | +3.637 | 2.9 | 86.7 | 0.3 | 405.3 | 0.258153 | 0.125636 | 0.000379252
BRIDGING U-PLATE | PL/2010 | +3.385 | +3.647 | 2.9 | 86.7 | 0.3 | 405.3 | 0.258153 | 0.125636 | 0.000379252
